# Allegro board LAE671PR10-1018.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 118.75,2.99 119.04,2.7 120.28,2.7 120.34,2.64 120.34,2.11 120.26,2.04 117.81,2.04 117.73,2.11 117.73,2.63 117.78,2.69 118.23,2.69 118.5,2.95 118.5,3.21 118.5,3.21 118.75,3.21
GND on BOTTOM (solid shape): 38.4,38.71 38.4,33.64 38,33.25 37,33.25 36.66,33.59 36.66,37.72 36.66,37.72 36.66,38.05 37.16,38.55 37.16,38.93 37.23,39 38.11,39
GND on BOTTOM (solid shape): 71.43,36.8 71.43,34.62 71.17,34.36 71.17,32.54 71.17,32.53 69.47,32.53 69.46,32.54 69.46,34.23 69.47,34.24 70.19,34.24 70.44,34.48 70.44,35.52 70.34,35.62 70.34,36.94 70.43,37.02 71.21,37.02
GND on BOTTOM (solid shape): 146.3,16.13 146.3,13.56 146.19,13.45 145.7,13.45 145.63,13.52 145.63,16.13 145.71,16.2 146.22,16.2
GND on BOTTOM (solid shape): 116.35,7.09 117.64,7.09 117.66,7.11 118.01,7.11 118.07,7.04 118.07,6.15 118.05,6.13 115.89,6.13 115.71,6.31 115.71,6.61 115.08,7.25 113.2,7.25 113.17,7.28 113.17,8.31 113.32,8.47 114.97,8.47
GND on BOTTOM (solid shape): 147.46,16.12 147.46,14.37 147.29,14.2 147.29,13.61 147.18,13.51 146.88,13.51 146.82,13.57 146.82,15.58 146.7,15.7 146.7,16.12 146.78,16.2 147.38,16.2
GND on BOTTOM (solid shape): 222.15,21.1 222.71,20.38 223.31,19.67 224.42,18.31 224.45,18.31 225.41,17.34 225.33,17.26 211.05,17.26 210.97,17.34 210.97,17.44 212.5,18.97 212.67,18.97 215.63,22.85 220.7,22.87
GND on BOTTOM (solid shape): 8.53,63.72 8.53,62.42 8.5,62.39 7.14,62.39 7.02,62.5 7.02,62.89 7.03,62.97 7.02,63.05 7.02,63.5 7.03,63.58 7.02,63.66 7.02,63.69 7.1,63.77 8.49,63.77
GND on BOTTOM (solid shape): 59.98,51.82 59.98,50.27 59.89,50.18 55.81,50.18 55.46,49.84 55.46,49.46 55.23,49.23 50.54,49.23 50.38,49.38 50.38,50.48 51.07,51.16 55.77,51.16 56.76,52.15 59.65,52.15
GND on BOTTOM (solid shape): 60.89,36.98 60.89,35.14 60.46,34.71 60.46,32.76 60.46,32.75 58.75,32.75 58.74,32.76 58.74,34.45 58.75,34.46 59.63,34.46 59.72,34.56 59.72,35.63 59.52,35.83 59.52,36.02 59.93,36.42 59.93,37.09 59.97,37.13 60.74,37.13
GND on BOTTOM (solid shape): 88.92,47.75 91.56,47.75 92.27,47.04 92.27,40.34 90.8,38.87 80.38,38.87 80.08,39.17 80.08,40.95 80.41,41.28 84.77,41.28 84.96,41.46 84.96,47.26 84.96,47.26 84.96,48.01 85.21,48.25 88.42,48.25
GND on BOTTOM (solid shape): 290.37,21.83 290.39,21.66 290.42,21.5 290.42,21.03 290.3,20.91 289.67,20.91 289.43,21.15 288.83,21.15 288.81,21.17 288.76,21.2 288.76,21.82 289.13,22.19 290.01,22.19
GND on BOTTOM (solid shape): 69.7,19.91 69.7,17.06 70.84,15.92 70.84,12.28 71.02,12.1 71.02,11.88 70.91,11.77 70.02,11.77 69.98,11.81 69.98,12.28 70.07,12.36 70.07,15.11 68.44,16.73 67.78,16.73 67.62,16.9 67.62,19.86 67.82,20.06 69.55,20.06
GND on BOTTOM (solid shape): 84.06,11.3 84.06,8.99 83.68,8.61 78.16,8.61 77.45,7.89 75.11,7.89 75.08,7.93 75.08,11.01 75.45,11.38 77.5,11.38 77.74,11.14 77.74,10.27 77.99,10.02 82.03,10.02 83.43,11.41 83.95,11.41
GND on BOTTOM (solid shape): 61.69,28.63 61.69,26.33 61.37,26.02 56.76,26.02 56.25,25.51 56.25,20.42 56.17,20.34 55.51,20.34 55.42,20.43 55.42,21.01 55.17,21.27 54.79,21.27 54.65,21.41 54.65,26.05 56.31,27.72 57.61,27.72 58.84,28.95 61.37,28.95
GND on BOTTOM (solid shape): 117.91,10.92 117.91,8.92 118.06,8.77 118.06,7.34 118.01,7.29 117.88,7.29 117.76,7.41 117.76,8.34 117.08,9.02 117.08,9.29 117.08,9.29 116.95,9.42 116.94,9.42 116.86,9.49 116.15,9.49 116.07,9.57 116.07,10.28 116.16,10.36 116.91,10.36 117.08,10.53 117.08,10.98 117.17,11.07 117.76,11.07
GND on BOTTOM (solid shape): 125.05,62.91 125.05,62.04 124.97,61.83 125.05,61.62 125.05,61.14 124.96,61.06 124.78,61.06 124.66,61.18 124.66,62.07 124.04,62.7 123.88,62.7 123.77,62.81 123.77,62.93 123.86,63.03 124.93,63.03
GND on BOTTOM (solid shape): 42.15,58.43 42.29,58.43 42.35,58.37 42.35,57.71 42.61,57.46 42.61,55.7 42.86,55.44 43.91,55.44 44.29,55.83 44.91,55.83 45.11,56.03 45.62,56.03 45.73,55.92 45.73,55.31 45.58,55.17 44.4,55.17 44.05,54.82 42.26,54.82 41.84,55.24 41.84,58.05 41.58,58.32 41.58,58.62 41.63,58.67 41.91,58.67
GND on BOTTOM (solid shape): 47.09,21.88 47.09,21.25 47.56,20.78 47.96,20.78 48.53,20.21 48.68,20.21 48.84,20.05 48.84,19.31 48.56,19.03 47.54,19.03 47.37,19.2 47.37,19.65 47.28,19.74 47.19,19.85 47.08,19.94 46.96,20.06 46.84,20.06 46.44,20.46 46.44,21.77 46.58,21.9 47.06,21.9
GND on BOTTOM (solid shape): 287.9,20.26 288.17,20.26 288.23,20.2 288.23,19.84 288.2,19.83 288.14,19.78 288.1,19.71 288.1,19.7 287.88,19.49 287.88,19.34 287.77,19.22 286.92,19.22 286.85,19.29 286.85,19.44 287.2,19.79 287.27,19.79 287.34,19.86 287.34,20.27 287.43,20.36 287.79,20.36
GND on BOTTOM (solid shape): 165.6,9.86 165.6,8.49 165.55,8.44 165.1,8.44 165.06,8.4 165.06,7.13 165.26,6.93 165.26,6.71 165.18,6.63 164.49,6.63 164.41,6.71 164.41,7.18 164.16,7.43 164.16,7.87 164.18,7.97 164.16,8.07 164.16,9.22 163.91,9.47 163.91,10.18 164.01,10.28 165.19,10.28
GND on BOTTOM (solid shape): 25.82,58.38 25.82,55.1 25.72,55 25.52,55 25.41,55.1 25.41,55.38 25.36,55.43 25.36,55.43 25.29,55.5 25.29,55.5 24.88,55.92 24.88,56.17 24.87,56.17 24.87,56.43 24.65,56.65 24.24,56.65 24.07,56.82 24.07,57.79 24.13,57.85 24.64,57.85 24.75,57.95 24.75,58.47 24.86,58.58 25.62,58.58
GND on BOTTOM (solid shape): 277.97,11.7 278.05,11.54 278.2,11.46 278.46,11.21 278.46,10.3 278.44,10.28 277.88,10.28 277.38,9.78 277.38,8.39 277.24,8.25 277.24,6.57 277.13,6.46 277,6.46 276.93,6.53 276.93,8.44 276.78,8.59 276.78,11.68 276.87,11.77 277.9,11.77
GND on BOTTOM (solid shape): 27.94,43.93 27.94,43.8 27.77,43.62 27.75,43.62 27.66,43.58 27.6,43.51 27.59,43.48 25.04,43.48 24.98,43.55 24.98,43.75 25.01,43.78 25.98,43.78 26,43.77 26.12,43.73 26.25,43.77 26.26,43.78 27.32,43.78 27.53,43.99 27.88,43.99
GND on BOTTOM (solid shape): 162.63,57.23 162.63,56.43 162.76,56.29 163.6,56.29 163.68,56.21 163.68,54.46 163.62,54.4 162.77,54.4 162.62,54.25 162.62,53.32 162.61,53.32 162.61,52.56 162.52,52.47 161.43,52.47 161.28,52.62 161.28,53.21 161.82,53.75 161.82,54.16 161.89,54.23 161.89,56.2 161.95,56.27 162.3,56.27 162.38,56.35 162.38,57.22 162.45,57.29 162.57,57.29
GND on BOTTOM (solid shape): 204.35,7.63 204.35,4.86 204.17,4.68 203.04,4.68 202.92,4.8 202.92,5.88 202.72,6.09 201.21,6.09 201.08,6.22 201.08,6.78 201.15,6.86 201.95,6.86 202.27,7.18 202.3,7.18 202.54,7.42 202.56,7.42 202.77,7.5 202.85,7.71 202.85,7.73 202.97,7.84 204.14,7.84
GND on BOTTOM (solid shape): 166.53,7.6 166.53,6.97 166.52,6.96 166.52,6.78 166.44,6.59 166.53,6.41 166.53,5.79 166.46,5.72 166.01,5.72 165.95,5.76 165.89,5.79 165.85,5.8 165.85,6.29 165.9,6.34 165.9,6.36 165.92,6.37 165.92,7.02 165.92,7.02 165.92,7.63 165.95,7.67 166.46,7.67
GND on BOTTOM (solid shape): 132.46,46.65 132.73,46.65 133.43,45.95 133.43,45.81 133.32,45.7 133.12,45.7 133.03,45.79 132.74,45.79 132.66,45.8 132.59,45.79 132.31,45.79 132.2,45.68 131.81,45.68 131.66,45.83 131.32,45.83 131.24,45.75 131.2,45.71 130.7,45.71 130.66,45.75 130.66,45.99 130.74,46.06 131.07,46.06 131.58,46.58 131.82,46.58 132.1,46.86 132.24,46.86
GND on BOTTOM (solid shape): 116.16,69.63 116.16,69.29 116.11,69.24 116.11,68.8 116.11,68.79 116.11,68.63 116.77,67.98 116.93,67.98 117.96,66.95 117.96,66.46 117.89,66.42 117.85,66.35 117.83,66.32 117.59,66.32 117.41,66.51 117.41,66.53 117.31,66.77 117.07,66.86 117.05,66.86 116.88,67.03 116.23,67.03 115.54,67.72 115.54,69.74 115.56,69.76 116.02,69.76
GND on BOTTOM (solid shape): 126.33,55.92 126.54,55.85 126.74,55.92 126.9,55.92 127.03,55.79 127.03,55.52 126.86,55.35 126.02,55.35 125.86,55.2 125.86,54.84 126.1,54.6 126.1,54.41 126.34,54.17 126.34,54.01 126.26,53.92 126.06,53.92 125.85,54 125.65,53.92 125.36,53.92 125.11,54.17 125.11,55.68 125.35,55.92
GND on BOTTOM (solid shape): 158.04,73.93 158.04,73.61 158.05,73.61 158.05,72.18 158.2,72.04 158.92,72.04 158.98,71.97 158.98,70.28 158.86,70.16 158.07,70.16 157.97,70.06 157.97,68.73 157.8,68.56 157.8,65.07 157.75,65.03 157.11,65.03 157.03,65.1 157.03,68.56 156.83,68.77 156.83,68.94 157.1,69.21 157.1,72.02 157.19,72.11 157.32,72.11 157.38,72.11 157.54,72.11 157.69,72.26 157.69,73.28 157.26,73.71 157,73.71 156.93,73.78 156.93,74.25 156.96,74.28 157.69,74.28
GND on BOTTOM (solid shape): 83.18,58.43 85.79,58.43 86.15,58.08 86.15,56.81 86.14,56.77 86.15,56.72 86.15,56.41 85.95,56.22 83.41,56.22 83.13,55.94 82.97,55.94 82.6,55.58 80.05,55.58 79.86,55.39 79.16,55.39 77.45,53.68 76.47,53.68 76.37,53.78 76.37,54.44 76.37,54.45 76.37,56.13 76.75,56.51 77.41,56.51 77.54,56.64 79.86,56.64 80.07,56.85 80.07,58.91 80.08,58.91 80.08,58.99 80.1,59.01 82.6,59.01
GND on BOTTOM (solid shape): 34.59,56.15 34.59,55.91 34.6,55.91 34.6,55.8 35.84,55.8 35.92,55.87 35.98,55.87 36.05,55.8 38.57,55.8 38.61,55.84 38.61,56.16 38.69,56.23 38.8,56.23 38.9,56.13 38.9,55.73 38.66,55.49 38.27,55.49 38.27,55.5 38.19,55.51 38.1,55.5 38.1,55.49 37.85,55.49 37.69,55.33 37.69,54.87 37.47,54.65 35.5,54.66 35.46,54.65 34.44,54.65 34.21,54.88 34.21,56.06 34.38,56.23 34.51,56.23
GND on BOTTOM (solid shape): 132.64,7.52 132.64,6.19 132.84,5.98 133.63,5.98 133.63,5.98 133.78,5.98 134.15,6.35 135.49,6.35 135.88,5.97 136.77,5.97 136.78,5.96 136.99,6.17 136.99,6.56 137.13,6.71 137.54,6.71 137.65,6.59 137.65,5.86 137.44,5.65 136.83,5.65 136.79,5.69 135.93,5.69 135.47,5.23 132.41,5.23 132.27,5.37 132.27,5.51 132.2,5.58 131.11,5.58 131.04,5.51 131.04,4.8 130.9,4.67 129.48,4.67 129.45,4.7 129.45,6.16 130.6,7.32 130.6,7.74 130.72,7.85 132.31,7.85
GND on BOTTOM (solid shape): 269.13,68.39 269.96,68.39 269.96,68.21 269.58,67.82 269.09,67.82 268.77,67.5 268.77,64.17 268.56,63.96 267.57,63.96 267.42,63.8 267.42,60.15 267.99,59.57 271.51,59.57 271.6,59.48 271.6,57.62 272.17,57.06 272.17,56.57 272.03,56.43 266.45,56.43 265.09,55.07 265.09,55.01 265.09,41.01 265.1,41.01 265.1,40.85 265.07,40.73 265.1,40.61 265.1,39.72 264.42,39.04 264.12,39.04 264.05,39.12 264.05,39.23 264.02,42.03 264.02,54.32 264.02,68.29 264.24,68.51 269.01,68.51
GND on BOTTOM (solid shape): 50.89,29.57 50.89,27.74 51.35,27.29 51.35,24.45 51.65,24.15 52.34,24.15 52.47,24.02 52.47,22.41 52.25,22.2 51.02,22.2 49.97,23.25 49.21,23.25 49.21,23.24 49.08,23.24 48.27,24.06 48.27,24.75 49.06,25.54 49.06,25.54 49.13,25.61 49.49,25.61 49.58,25.52 49.58,24.78 49.74,24.62 50.42,24.62 50.54,24.74 50.54,24.91 50.54,25.55 50.54,25.58 50.54,25.61 50.54,25.67 50.2,26 50.2,27.46 50.59,27.85 50.59,28.81 49.94,29.45 49.94,29.7 50.04,29.81 50.65,29.81
GND on BOTTOM (solid shape): 279.46,21.49 279.46,21.38 279.39,21.31 278.26,21.31 278.22,21.27 278.22,21.11 278.26,21.07 279.39,21.07 279.46,21 279.46,20.88 279.39,20.81 278.26,20.81 278.22,20.77 278.22,20.62 278.26,20.57 279.38,20.57 279.46,20.49 279.46,20.38 279.39,20.31 278.27,20.31 278.27,20.31 278.23,20.26 278.23,20.11 278.27,20.07 279.39,20.07 279.46,20 279.46,19.88 279.39,19.81 278.27,19.81 278.27,19.81 278.23,19.76 278.23,19.61 278.27,19.56 279.39,19.56 279.46,19.49 279.46,19.39 279.38,19.32 278.29,19.32 278.23,19.26 278.23,19.13 278.29,19.07 279.4,19.07 279.46,19.01 279.46,18.91 279.37,18.82 277.8,18.82 277.66,18.96 277.66,21.2 278.04,21.58 279.38,21.58
GND on BOTTOM (solid shape): 40.66,29.03 40.66,27.84 40.47,27.65 40.06,27.65 39.92,27.52 39.92,26.34 40.3,25.97 40.3,25 40.35,24.94 40.35,23.5 40.5,23.35 42.03,23.35 42.22,23.54 42.32,23.54 42.48,23.71 43.04,23.71 43.14,23.6 43.14,21.45 42.97,21.28 42.29,21.28 41.81,20.79 39.03,20.79 38.98,20.84 38.98,21.33 39.18,21.52 39.39,21.52 39.99,22.13 39.99,23.05 39.97,23.07 39.97,23.21 39.67,23.51 39.67,24.61 39.29,24.98 39.29,25.98 39.64,26.33 39.64,28.73 39.64,28.74 39.64,29.08 39.78,29.23 40.47,29.23
GND on BOTTOM (solid shape): 264.01,11.61 265.03,11.61 265.34,11.31 265.34,10.86 265.65,10.54 266.2,10.54 266.3,10.45 266.3,9.29 266.62,8.96 267.12,8.96 267.12,8.96 267.3,8.96 267.49,8.77 267.49,8.29 267.79,7.98 267.79,7.14 267.64,6.99 267.44,6.99 267.29,6.83 267.29,5.89 267.64,5.53 267.64,4.6 267.65,4.6 267.39,4.22 267.72,3.9 267.72,3.5 267.53,3.31 267.06,3.31 266.99,3.37 266.99,3.56 266.97,3.58 266.97,3.72 266.04,4.66 266.04,6.86 265.86,7.05 260.87,7.05 260.48,7.44 260.48,12.24 260.81,12.57 263.05,12.57
GND on BOTTOM (solid shape): 119.53,62.95 119.53,62.76 119.03,62.26 119.03,62.02 119.03,61.73 118.9,61.61 118.77,61.73 118.77,62.07 118.72,62.11 118.7,62.18 118.68,62.29 118.61,62.39 118.24,62.77 117.71,62.77 117.2,62.26 117.2,62.02 117.2,62.02 117.2,61.73 117.07,61.61 116.95,61.73 116.95,62.07 116.94,62.07 116.94,62.31 116.49,62.76 116.49,62.93 116.64,63.08 119.4,63.08
GND on BOTTOM (solid shape): 156.06,6.79 157.69,6.79 157.75,6.76 157.79,6.71 157.79,6.64 157.81,6.58 157.81,6.45 157.95,6.31 158.85,6.31 158.93,6.23 158.93,6.11 158.88,6.06 158.02,6.06 157.81,5.85 157.81,5.8 157.81,5.79 157.78,5.69 157.81,5.58 157.81,5.57 157.81,5.48 157.98,5.31 158.86,5.31 158.94,5.24 158.94,5.12 158.87,5.06 157.85,5.06 157.82,5.08 157.33,5.08 157.33,5.09 157.03,5.09 157.03,5.08 156.84,5.08 156.84,5.09 156.52,5.09 156.52,5.08 156.34,5.08 156.34,5.09 156.09,5.09 156.09,5.98 156,6.06 155.01,6.06 154.96,6.12 154.94,6.16 154.94,6.74 155.02,6.81 156.03,6.81
GND on BOTTOM (solid shape): 159.61,64.5 159.61,63.07 159.72,62.95 160.22,62.95 160.34,63.07 160.34,64.06 160.79,64.5 161.23,64.5 161.34,64.39 161.34,64.13 161.21,64 160.83,64 160.59,63.76 160.59,62.94 160.59,62.93 160.58,62.85 160.59,62.77 160.59,62.76 160.59,62.49 160.58,62.48 160.58,62.35 160.58,62.29 160.58,61.91 160.58,61.85 160.58,61.8 160.58,61.4 160.44,61.26 159.71,61.26 159.6,61.15 159.6,60.07 159.71,59.96 159.71,59.77 160.15,59.32 160.15,57.23 159.84,56.91 158.84,56.91 158.65,57.1 158.65,60.86 158.88,61.09 158.88,62.87 158.97,62.95 159.04,62.96 159.19,62.96 159.34,63.11 159.34,64.09 159.11,64.33 159.11,64.54 159.22,64.66 159.44,64.66
GND on BOTTOM (solid shape): 121.07,73.15 121.07,69.99 121.05,69.97 121.05,69.14 121.07,69.12 121.07,67.7 120.83,67.46 120.23,67.46 119.64,66.87 119.64,66.28 119.63,66.27 119.63,65.95 119.63,65.77 119.49,65.77 119.38,65.88 119.38,66.14 119.38,66.32 119.24,66.47 119.05,66.45 118.95,66.44 118.89,66.53 118.89,66.85 120.04,68 120.04,68.1 120.59,68.64 120.59,69.41 120.49,69.5 120.49,72.84 120.36,72.97 118.89,72.97 118.64,72.71 118.4,72.71 118.15,72.96 116.33,72.96 116.07,73.22 116.07,73.44 120.78,73.44
GND on BOTTOM (solid shape): 140.69,63.72 140.69,61.71 140.96,61.45 140.96,61.41 140.99,61.41 141.02,61.39 141.02,60.87 141.01,60.87 140.12,60.87 139.35,61.63 139.35,62.85 139.15,63.05 138.84,63.05 138.82,63.08 138.63,63.2 138.43,63.08 138.42,63.05 138.29,63.05 138.11,63.14 137.93,63.05 135.71,63.05 135.28,63.49 135.28,63.58 135.09,63.76 135.09,64 135.3,64 135.31,63.99 136.02,63.99 136.02,63.94 136.14,63.74 136.38,63.74 136.42,63.76 136.6,63.57 136.68,63.57 136.73,63.52 137.17,63.52 137.22,63.57 137.34,63.57 137.48,63.72 137.51,63.71 137.73,63.78 137.8,64 137.79,64.03 138.18,64.41 140,64.41
GND on BOTTOM (solid shape): 10.78,65.74 11.02,65.77 11.1,65.74 11.14,65.67 11.14,61.92 11.26,61.8 11.29,61.8 11.51,61.42 11.93,61.54 14.6,58.87 14.6,58.68 14.64,58.63 14.64,55.2 14.9,54.95 14.97,54.95 16.22,54.95 16.32,54.95 16.5,54.77 16.5,54.74 16.53,54.74 16.65,54.62 16.88,54.62 16.89,54.61 17.25,54.61 17.4,54.46 17.4,53.88 18.09,53.19 18.09,53.18 18.46,52.81 18.46,52.81 18.5,52.77 18.66,52.77 18.71,52.72 18.71,52.05 18.69,52.03 18.53,52.03 18.44,52.12 18.44,52.35 18.35,52.44 18.05,52.44 16.86,53.63 13.58,53.63 13.39,53.82 13.39,54.29 13.88,54.78 13.88,58.63 13.88,58.63 13.88,58.67 10.69,61.86 10.69,65.36 10.45,65.6 10.43,65.72 10.54,65.77
GND on BOTTOM (solid shape): 33.98,53.47 33.98,41.41 33.78,41.21 33.44,41.21 33.41,41.25 33.26,41.25 32.79,41.72 31.82,41.72 31.64,41.78 31.46,41.72 31.27,41.72 31.26,41.72 31.18,41.73 31.1,41.72 31.09,41.72 30.99,41.72 30.92,41.79 30.92,42.4 30.93,42.4 30.93,43.64 30.54,43.64 30.46,43.71 30.46,43.85 30.51,43.9 30.83,43.9 30.86,43.92 30.93,43.92 30.93,44.76 31.01,44.84 31.33,44.84 31.47,44.69 31.47,43.47 31.57,43.47 31.59,43.45 32.63,43.45 32.65,43.47 32.69,43.47 32.69,43.51 32.74,43.56 32.74,47.36 32.74,47.39 32.77,47.51 32.75,47.62 32.74,47.63 32.74,47.78 32.75,47.79 32.78,47.9 32.75,48.02 32.74,48.03 32.74,49.3 32.75,49.31 32.77,49.41 32.75,49.51 32.74,49.52 32.74,49.69 32.75,49.7 32.77,49.8 32.75,49.9 32.74,49.91 32.74,51.48 32.69,51.53 32.69,52.5 32.69,52.5 32.69,52.58 32.61,52.58 32.59,52.61 32.36,52.61 32.29,52.67 32.29,52.9 32.47,53.08 32.93,53.08 33.4,53.54 33.91,53.54
GND on BOTTOM (solid shape): outline of 113 points within 65.06,38.23 75.08,74.01
GND on BOTTOM (solid shape): outline of 140 points within 13.07,36.74 20.2,43.38
GND on BOTTOM (solid shape): outline of 181 points within 122.94,64.95 172.34,75.74
GND on BOTTOM (solid shape): outline of 198 points within 78.78,71.52 84.27,77
GND on BOTTOM (solid shape): outline of 198 points within 145.89,71.52 151.37,77
GND on BOTTOM (solid shape): outline of 286 points within 267.12,23.01 278.28,31.53
GND on BOTTOM (solid shape): outline of 326 points within 265.07,6.51 276.03,21.03
GND on BOTTOM (solid shape): outline of 314 points within 285.89,14.19 289.19,18.06
GND on BOTTOM (solid shape): outline of 399 points within 134.46,63.75 143.27,67.06
GND on BOTTOM (solid shape): outline of 525 points within 20.72,59.31 93.92,75.72
GND on BOTTOM (solid shape): outline of 1303 points within 0.26,0.26 54.03,73.89
GND on BOTTOM (solid shape): outline of 1667 points within 0.25,0.25 297.51,75.75
GND on IN1 (solid shape): 139.52,37.88 139.52,35.63 139.31,35.42 135.95,35.42 135.85,35.52 135.85,39.37 136.02,39.54 137.87,39.54
GND on IN1 (solid shape): 66.26,9.14 67.2,9.14 67.49,8.85 68.86,8.85 69.05,8.65 70.06,8.65 70.16,8.55 70.16,8.29 70.08,8.21 66.99,8.21 66.54,8.66 65.78,8.66 65.71,8.73 63.24,8.73 62.77,9.2 62.77,9.71 62.9,9.84 65.56,9.84
GND on IN1 (solid shape): 276.83,68.36 276.83,68.11 275.92,67.19 275.92,67.18 275.74,67 275.74,66.87 275.47,66.61 272.51,66.61 272.05,67.06 268.66,67.06 266.87,65.27 266.87,53.25 265.99,52.37 265.99,49.45 265.81,49.28 265.81,49.18 265.72,49.1 265.72,42.8 264.99,42.07 264.99,40.32 264.47,39.81 264.22,39.81 264.06,39.97 264.06,68.25 264.3,68.49 276.7,68.49
GND on IN1 (solid shape): outline of 91 points within 17.59,6.78 20.08,10.18
GND on IN1 (solid shape): outline of 170 points within 14.65,6.78 18.27,10.33
GND on IN1 (solid shape): outline of 508 points within 9.08,29.61 17.59,38.84
GND on IN1 (solid shape): outline of 1008 points within 263.41,14.74 274.42,29.94
GND on IN1 (solid shape): outline of 1026 points within 257.55,3.18 287.42,15.64
GND on IN1 (solid shape): outline of 1350 points within 137.75,39.3 172.35,75.73
GND on IN1 (solid shape): outline of 1667 points within 0.25,0.25 297.51,75.75
GND on IN1 (solid shape): outline of 3110 points within 256.36,0.3 297.01,62.31
GND on IN1 (solid shape): outline of 3343 points within 0.25,0.26 87.01,75.72
GND on GND1 (solid shape): 143.25,9.75 143.25,9.53 143.1,9.38 140.42,9.38 140.35,9.45 140.35,9.78 140.43,9.86 143.14,9.86
GND on GND1 (solid shape): 266.1,22.08 266.1,21.55 266.01,21.46 265.76,21.46 265.72,21.5 265.7,21.55 265.67,21.59 265.67,21.78 265.73,21.85 265.73,22.15 265.45,22.43 264.98,22.43 264.96,22.41 264.73,22.25 264.79,21.97 264.79,21.65 264.72,21.47 264.79,21.29 264.79,21.27 264.86,21.21 265.06,21.21 265.12,21.15 265.12,21 265.04,20.92 264.72,20.92 264.49,21.15 264.49,22.58 264.63,22.72 265.46,22.72
GND on IN2 (solid shape): 15.23,41.51 16.01,41.51 17.23,40.3 17.23,39.93 17.69,39.46 18.59,39.46 19.62,38.43 19.62,36.02 19.35,35.75 15.9,35.75 14.56,37.1 13.6,37.1 13.06,37.63 13.06,39.25 13.6,39.79 13.6,41.17 13.94,41.51 13.94,41.65 14.27,41.98 14.77,41.98
GND on IN2 (solid shape): outline of 936 points within 264.05,40.24 279.06,68.51
GND on IN2 (solid shape): outline of 1286 points within 143.12,22.44 175.93,75.7
GND on IN2 (solid shape): outline of 1667 points within 0.25,0.25 297.51,75.75
GND on IN2 (solid shape): outline of 2232 points within 0.25,2.26 41.67,75.74
GND on IN2 (solid shape): outline of 2874 points within 281.19,2.26 297.01,71.74
GND on IN3 (solid shape): 17.26,40.44 17.26,37.69 17.73,37.21 17.73,36.77 17.24,36.28 13.83,36.28 13.79,36.29 13.75,36.3 13.04,37.01 13.04,39.17 13.65,39.78 13.65,41.05 13.77,41.17 16.53,41.17
GND on IN3 (solid shape): 297.01,69.59 297,69.59 297,61.11 296.42,60.53 295.14,60.53 294.88,60.78 294.88,68.77 293.59,70.06 290.24,70.06 289.96,69.77 289.96,67.63 289.85,67.52 288.02,67.52 287.55,67.05 286.51,67.05 285.51,68.05 285.51,68.35 285.51,68.35 285.51,68.54 287.63,68.54 288.17,68.76 288.39,69.3 288.39,69.59 288.38,69.59 288.38,71.49 288.46,71.66 288.63,71.74 297.01,71.74
GND on IN3 (solid shape): outline of 1667 points within 0.25,0.25 297.51,75.75
GND on IN3 (solid shape): outline of 1969 points within 149.73,20.02 177.64,75.69
GND on IN3 (solid shape): outline of 2097 points within 264.01,19.55 297.01,68.52
GND on IN3 (solid shape): outline of 2452 points within 0.25,0.26 149.76,75.74
GND on IN4 (solid shape): 144.3,7.58 144.3,3.89 144.31,3.88 144.31,3.86 146.35,1.82 156.47,1.82 160.07,5.42 160.35,5.42 160.49,5.28 160.49,4.93 156.81,1.25 145.99,1.25 143.7,3.54 143.7,7.44 142.69,8.45 138.05,8.45 137.94,8.57 137.94,8.81 138.12,8.99 142.88,8.99
GND on IN4 (solid shape): 280.01,11.82 279.94,11.53 280.2,11.37 280.2,8.69 279.23,7.71 279.23,6.94 278.87,6.59 278.02,6.59 277.9,6.71 277.9,7.95 277.93,7.99 277.93,10.26 278.62,10.94 278.62,11.69 278.74,11.82
GND on IN4 (solid shape): 130.23,8.11 130.23,7.86 129.33,6.95 129.33,2.9 128.2,1.78 92.06,1.78 89.06,4.78 85.07,4.78 85.07,4.78 80.73,4.78 80.66,4.85 80.66,5.18 80.97,5.48 99,5.48 102.06,2.42 115.7,2.42 115.78,2.41 115.86,2.42 116.91,2.42 117.2,2.13 127.87,2.13 128.58,2.85 128.58,2.86 128.82,3.1 128.82,7.3 129.74,8.22 130.11,8.22
GND on IN4 (solid shape): outline of 131 points within 277.66,19.93 288.14,26.18
GND on IN4 (solid shape): outline of 163 points within 134.31,59.32 147.84,67.02
GND on IN4 (solid shape): outline of 148 points within 135.9,50.73 139.93,54.77
GND on IN4 (solid shape): 23.93,46.37 24,46.24 23.96,46.22 24.11,45.57 24.46,46.13 24.45,46.23 24.52,46.29 25.01,46.29 25.05,46.33 25.08,46.36 25.11,46.37 25.17,46.37 25.21,46.36 25.24,46.33 25.27,46.29 25.65,46.29 25.73,46.37 26.09,46.37 26.16,46.34 26.19,46.26 26.27,46.06 26.48,46 26.56,45.97 26.6,45.9 26.6,45.83 26.54,45.83 26.53,45.84 26.19,45.62 26.48,45.35 26.56,45.32 26.6,45.25 26.6,44.67 26.48,44.55 26.46,44.55 26.32,44.52 26.22,44.42 26.02,44.42 25.79,44.55 25.57,44.42 25.37,44.42 25.04,44.53 24.9,44.21 24.92,44.18 24.86,44.12 24.16,44.12 23.83,44.45 23.84,44.48 23.87,44.69 23.77,44.87 23.75,44.94 23.78,45.01 23.88,45.32 23.68,45.58 23.65,45.6 23.65,46.29 23.69,46.29 23.74,46.37
GND on IN4 (solid shape): outline of 290 points within 33.47,53.68 42.41,62.2
GND on IN4 (solid shape): outline of 293 points within 21.21,52.03 25.17,54.68
GND on IN4 (solid shape): outline of 482 points within 264.01,56.18 278.76,68.54
GND on IN4 (solid shape): outline of 534 points within 285.3,28.43 290.96,38.66
GND on IN4 (solid shape): outline of 637 points within 154.74,15.74 163.71,48.44
GND on IN4 (solid shape): outline of 640 points within 106.94,63.34 111.86,69.32
GND on IN4 (solid shape): outline of 1109 points within 27.68,41.46 33.99,53.05
GND on IN4 (solid shape): outline of 1589 points within 268.57,33.76 297.01,71.74
GND on IN4 (solid shape): outline of 1786 points within 0.25,0.25 297.51,75.75
GND on IN4 (solid shape): outline of 1780 points within 150.48,24.53 174.78,75.73
GND on IN4 (solid shape): outline of 2449 points within 109.1,61.36 131.36,73.98
GND on IN4 (solid shape): outline of 4404 points within 0.25,2.26 37.79,75.74
GND on IN4 (solid shape): outline of 9134 points within 91.52,35.49 132.5,53.99
GND on GND1: 113.16,8.33 114.85,8.33 115.13,8.05 115.13,7.46 115.04,7.37 113.76,7.37 113.07,8.06 113.07,8.24
GND on GND1: outline of 148 points within 0.25,0.26 297.51,75.74 ; 4 cut-outs
GND on GND2: outline of 138 points within 0.26,0.25 297.5,75.75 ; 2 cut-outs
GND on VCC: 1.67,50.55 1.62,50.59 1.57,50.63 1.06,50.63 1.02,50.65 1.02,51.77 2.17,52.92 2.2,52.95 2.51,53.43 2.62,54 2.62,55.88 2.51,56.45 2.2,56.93 2.17,56.96 1.02,58.11 1.02,58.38 1.27,58.38 1.27,59.08 2,59.73 2.27,60.67 2.27,65.67 2,66.61 1.27,67.26 1.27,72.88 6.36,72.88 6.36,69.3 6.88,68.05 8.13,67.53 26.13,67.53 27.38,68.05 27.9,69.3 27.9,74.73 49.03,74.73 49.42,74.34 49.42,65.92 49.03,65.54 29.09,65.54 25.64,62.08 23.72,62.08 20.26,65.54 3.97,65.54 2.73,64.3 2.73,57.86 9.29,51.31 9.29,50.95 8.89,50.55
GND on VCC: 81,16.34 80.48,16.86 80.48,40.24 80.92,40.66 82.4,40.66 83.43,41.69 83.43,45.27 90.57,52.41 91.29,52.41 92.75,53.87 96.2,53.87 96.64,53.42 101,53.42 101,53.42 101.55,53.42 102.53,52.44 102.53,51.9 104.18,50.25 112.18,50.25 113.85,48.57 120.95,48.57 121.53,49.16 122.82,49.16 125.81,46.16 125.87,46.16 127.67,44.36 149.9,44.36 150.41,43.85 150.41,26.02 145.07,20.69 145.07,16.34
GND on VCC: 292.4,43.34 289.63,46.11 289.63,50.48 288.77,51.34 286.73,51.34 286.2,51.87 282.81,51.87 282.39,52.3 282.39,54.89 282.83,55.33 283.63,55.33 283.94,55.63 284.97,56.66 287.39,56.66 288.84,56.66 289.44,57.26 289.44,58.89 289.13,59.2 288.46,59.2 288.25,59.41 288.25,59.72 289.83,59.72 290.2,60.09 290.2,60.68 290.38,60.86 290.62,60.87 291.73,61.98 291.73,62.83 291.91,63.01 294.7,63.01 294.76,63.07 294.88,63.2 294.88,68.77 293.59,70.06 290.24,70.06 289.96,69.77 289.96,67.63 289.84,67.51 288.05,67.51 288.04,67.52 288.04,67.58 289,68.18 289.4,69.25 289.4,70.72 295.99,70.72 295.99,69.25 295.99,69.25 295.99,54.39 295.26,53.74 294.99,52.8 294.99,47.8 295.26,46.86 295.99,46.21 295.99,46.06 295.99,46.06 295.99,45.26 294.93,44.19 294.67,43.88 294.5,43.51 294.44,43.51 294.28,43.34
GND on VCC: 13.73,36.79 13.55,36.97 13.55,41.05 13.78,41.28 16.3,41.28 17.01,41.99 17.01,48.77 17.49,49.26 17.49,51.37 17.01,51.86 17.01,55.02 17.44,55.46 32.07,55.46 33.06,54.46 33.06,39.58 32.01,38.54 30.14,38.54 29.14,37.55 21.88,37.55 21.12,36.79
GND on GND3: outline of 150 points within 0.25,0.26 297.51,75.74 ; 3 cut-outs
VCC0V9_LVR_OUT on TOP (solid shape): 19.98,45.19 19.98,43.52 19.85,43.39 18.45,43.39 18.33,43.52 18.33,43.9 18.49,44.06 19.35,44.06 19.51,44.22 19.51,45.21 19.55,45.25 19.92,45.25
VCC0V9_SVR on TOP (solid shape): 23.59,48.71 23.59,47.81 23.59,47.72 23.55,47.68 23.19,47.68 23.13,47.74 23.13,48.01 23.04,48.1 23.02,48.1 22.87,48.26 21.41,48.26 21.17,48.02 21.17,47.22 21.09,47.14 21.09,46.38 21.03,46.32 20.87,46.32 20.87,46.33 20.71,46.33 20.67,46.28 20.16,46.28 19.92,46.04 18.35,46.04 18.28,46.11 18.28,48.06 18.35,48.12 19.2,48.12 19.3,48.02 19.3,47.91 19.74,47.58 19.82,48.12 19.78,48.2 19.82,48.28 19.86,48.32 19.94,48.36 20.02,48.32 20.41,48.24 20.57,48.6 20.59,48.69 20.67,48.72 20.67,48.76 20.73,48.82 23.48,48.82
VCC0V9_SVR on BOTTOM (solid shape): 20.26,58.81 20.26,57.11 19.72,56.57 16.7,56.57 16.35,56.22 16.35,55.39 16.29,55.33 16.3,55.33 16.3,55.2 16.17,55.07 15.03,55.07 14.89,55.21 14.89,58.82 15.2,59.14 19.93,59.14
VCC0V9_SVR on BOTTOM (solid shape): outline of 90 points within 19.82,46.15 23.31,49.2
VCC0V9_SVR on IN1 (solid shape): outline of 1065 points within 15.05,46.36 22.65,59.14
VCC0V9_SVR on IN2 (solid shape): outline of 1119 points within 15.32,46.34 24.22,59.11
VCC3V3_TBT_LDO_A on TOP (solid shape): 29.6,44.55 29.6,43.34 29.41,43.15 29.23,43.15 28.82,43.56 28.82,44.55 29.05,44.77 29.38,44.77
VCC3V3_TBT_LDO_A on TOP (solid shape): 12.74,34.74 12.74,34.11 12.94,33.92 13.5,33.92 13.57,33.85 13.57,33.32 13.52,33.28 13.43,33.28 13.41,33.26 13.39,33.26 13.38,33.25 12.69,33.25 12.17,33.77 12.17,34.76 12.21,34.8 12.67,34.8
VCC3V3_TBT_LDO_A on TOP (solid shape): 24.46,38.44 24.51,38.42 24.57,38.36 24.6,38.3 24.64,38.24 24.64,37.8 24.51,37.68 22.65,37.68 22.39,37.93 22.39,38.18 22.65,38.44
VCC3V3_TBT_LDO_A on BOTTOM (solid shape): 19.89,34.76 19.89,30.38 19.86,30.37 19.67,30.19 19.72,29.93 19.74,29.89 19.72,29.86 19.55,29.69 18.92,29.69 18.75,29.52 18.75,28.92 18.6,28.77 18.03,28.77 17.92,28.88 17.92,29.58 17.77,29.73 16.94,29.73 16.79,29.88 16.79,31.05 16.86,31.12 17.33,31.12 17.49,31.29 17.49,32.76 17.44,32.82 16.87,32.82 16.76,32.93 16.76,33.95 16.53,34.19 8.71,34.19 8.32,33.8 8.32,33.27 8.05,32.99 6.39,32.99 6.11,33.28 6.11,33.62 5.99,33.74 5.5,33.74 5.18,33.42 5.18,33.11 5.09,33.02 4.78,33.02 4.51,33.3 4.51,33.77 5.75,35.01 19.64,35.01
VCC3V3_TBT_LDO_A on IN1 (solid shape): 25.06,38.31 25.06,38.06 24.3,37.29 24.04,37.29 23.92,37.42 23.92,37.93 24.17,38.19 24.39,38.19 24.71,38.51 24.71,38.56 24.8,38.56
VCC3V3_TBT_LDO_A on IN2 (solid shape): 10.86,35.94 10.94,35.62 11.26,35.54 11.26,34.01 10.84,33.59 10.33,33.59 10.12,33.81 10.12,34.72 10.13,34.75 10.16,34.77 10.45,35.01 10.33,35.36 10.3,35.41 10.29,35.46 10.29,35.82 10.41,35.94
VCC3V3_TBT_LDO_B on BOTTOM (solid shape): 31.07,38.84 31.07,37.94 30.55,37.42 30.14,37.42 30.04,37.52 30.04,38.56 30.4,38.92 30.98,38.92
VCC3V3_TBT_LDO_C on TOP (solid shape): 283.37,19.84 283.37,19.44 283.22,19.28 281.71,19.28 281.58,19.41 281.58,19.87 281.67,19.96 283.26,19.96
VCC3V3_TBT_LDO_C on BOTTOM (solid shape): 281.1,19.34 281.1,17.83 280.91,17.64 280.45,17.64 280.35,17.75 280.35,19.29 280.48,19.43 281.01,19.43
VCC3V3_TBT_LDO_C on GND3 (solid shape): 281.53,19.77 281.53,19.49 280.87,18.84 280.61,18.84 280.5,18.94 280.5,19.29 280.69,19.48 280.77,19.48 281.21,19.92 281.38,19.92
VCC_3V3_USB2 on TOP (solid shape): 21.38,46.06 21.38,44.53 21.25,44.41 20.87,44.41 20.74,44.53 20.74,46.06 20.87,46.18 21.25,46.18
VCC_3V3_USB2 on GND1 (solid shape): 21.77,45.48 21.77,45.12 21.6,44.96 21.38,44.96 21.28,44.86 21.28,44.59 21.19,44.49 20.94,44.49 20.86,44.57 20.86,46.05 20.9,46.09 21.15,46.09
VDD on TOP (solid shape): 60.75,14.48 60.75,13.8 61.44,13.11 62.36,13.11 62.4,13.07 62.4,12.96 62.35,12.91 60.55,12.91 60.25,13.21 59.91,13.21 59.9,13.22 59.9,14.02 59.79,14.13 59.79,14.39 60.03,14.64 60.59,14.64
VIN_1V_PRIM on TOP (solid shape): 66.67,34.87 67.71,34.87 67.72,34.86 67.72,33.65 67.6,33.52 65.97,33.52 65.8,33.7 65.8,34.93 65.86,34.99 66.54,34.99
VIN_1V_PRIM on BOTTOM (solid shape): 66.8,34.87 67.69,34.87 67.78,34.96 68.51,34.96 69.21,34.26 69.21,33.08 69.11,32.98 69.06,32.98 69.06,32.98 67.61,32.98 67.48,33.01 67.35,32.98 66.96,32.98 66.95,32.97 66.81,32.97 66.54,32.7 65.68,32.7 65.67,32.71 65.67,34.81 65.82,34.96 66.72,34.96
VIN_PRIM on TOP (solid shape): 161.36,70.62 161.36,69.23 160.95,68.83 159.79,68.83 159.5,69.12 159.5,70.49 159.78,70.77 161.2,70.77
VIN_PRIM on BOTTOM (solid shape): 160.56,71.24 160.56,70.86 160.65,70.77 161.3,70.77 161.47,70.6 161.47,69.95 161.82,69.6 161.82,67.53 161.8,67.51 159.57,67.51 159.4,67.68 159.4,69.91 159.11,70.19 159.11,71.38 159.23,71.5 160.3,71.5
VIN_VCC_EDRAM on TOP (solid shape): 57.05,34.04 57.05,32.96 56.97,32.88 55.23,32.88 55.07,33.04 55.07,34.07 55.12,34.11 56.97,34.11
VIN_VCC_EDRAM on BOTTOM (solid shape): 58.53,34.47 58.53,33.16 58.47,33.11 57.74,33.11 57.54,33.02 57.48,32.81 57.48,32.59 57,32.11 57,31.31 56.93,31.23 55.59,31.23 55.1,31.72 55.1,34.12 55.16,34.18 57.29,34.18 57.64,34.53 58.47,34.53
VIN_VCCIO on BOTTOM (solid shape): 165.27,55.45 165.27,55.22 165.41,55.09 168.51,55.09 168.79,54.8 168.79,53.05 168.58,52.84 163.96,52.84 163.84,52.96 163.84,55.65 163.9,55.71 165.02,55.71
+BAT_TABLET on BOTTOM (solid shape): 88.69,15.04 88.69,14.31 88.62,14.24 88.45,14.24 88.44,14.23 86.93,14.23 86.6,13.91 86.6,8.73 86.6,8.73 86.6,8.43 86.48,8.31 84.44,8.31 84.2,8.56 84.2,15.49 84.92,16.21 87.51,16.21
+BATT on TOP (solid shape): 96.23,14.05 96.23,13.71 96.48,13.46 97.23,13.46 97.23,13.35 97.23,13.35 97.23,13.17 97.2,13.15 97.2,11.74 97.23,11.71 97.23,9.75 97.09,9.6 94.81,9.6 94.28,9.06 89.66,9.06 86.4,12.32 86.4,13.73 86.87,14.2 96.09,14.2
+BATT on BOTTOM (solid shape): 97.36,15.63 98.71,15.63 98.88,15.46 98.88,14.01 98.87,14.01 98.62,13.76 98.62,13.41 98.87,13.15 98.88,13.15 98.88,8 97.03,6.14 89.39,6.14 86.89,8.65 86.89,11.31 89.9,11.31 89.9,8.1 90.06,7.94 91.06,7.94 91.06,7.88 92.61,7.88 92.61,11.49 91.06,11.49 91.06,11.48 90.07,11.48 89.9,11.31 86.89,11.31 86.89,13.85 87.03,13.99 88.64,13.99 90.28,15.64 97.35,15.64
+BATT on IN2 (solid shape): 96.44,14.05 96.65,14.05 97.27,13.43 97.27,12.14 96.74,11.61 86.86,11.61 86.76,11.71 86.76,13.88 86.93,14.05 96.44,14.05
+BATT on IN3 (solid shape): 97.27,13.43 97.27,12.14 96.74,11.61 86.86,11.61 86.76,11.71 86.76,13.88 86.93,14.05 96.65,14.05
+CHG_SRC_20V on TOP (solid shape): 58.4,25.29 58.4,23.07 58.69,22.78 62.45,22.78 62.6,22.63 62.6,21.85 61.71,20.96 61.71,20.33 59.74,18.36 56.53,18.36 56.5,18.38 56.5,25.18 56.92,25.6 58.09,25.6
+CHG_SRC_20V on BOTTOM (solid shape): 58.41,25.33 58.41,23.02 58.64,22.79 62.47,22.79 62.61,22.65 62.61,21.84 61.72,20.95 61.72,19.53 59.35,17.15 56.42,17.15 56.35,17.22 56.35,18.63 56.85,19.12 56.85,25.56 56.89,25.6 58.14,25.6
+CHG_SRC_20V on IN1 (solid shape): 58.41,25.33 58.41,23.02 58.64,22.79 62.47,22.79 62.61,22.65 62.61,21.84 61.72,20.95 61.72,20.34 58.53,17.15 56.42,17.15 56.35,17.22 56.35,18.63 56.85,19.12 56.85,25.56 56.89,25.6 58.14,25.6
+CHG_SRC_20V on IN2 (solid shape): 58.41,25.33 58.41,23.02 58.64,22.79 62.47,22.79 62.61,22.65 62.61,21.84 61.72,20.95 61.72,19.53 59.35,17.15 56.42,17.15 56.35,17.22 56.35,18.63 56.85,19.12 56.85,25.56 56.89,25.6 58.14,25.6
+CHG_SRC_20V on IN4 (solid shape): 58.41,25.33 58.41,23.02 58.64,22.79 62.47,22.79 62.61,22.65 62.61,21.84 61.72,20.95 61.72,19.53 59.35,17.15 56.42,17.15 56.35,17.22 56.35,18.63 56.85,19.12 56.85,25.56 56.89,25.6 58.14,25.6
+CHG_VIN_20V on TOP (solid shape): 41.67,12.98 41.77,12.96 41.87,12.98 41.88,12.99 47.8,12.99 49.46,11.33 51.26,11.33 51.52,11.07 51.52,8.43 51.21,8.12 49.24,8.12 49.08,8.27 49.08,8.34 48.69,8.34 48.5,8.58 48.2,8.67 48.1,8.67 47.8,8.58 47.6,8.34 46.53,8.34 46.41,8.21 43.6,8.21 43.6,8.21 43.38,8.21 42.99,8.6 42.99,9.84 42.7,10.13 42.34,10.13 42.34,9.77 42.48,9.63 42.48,8.96 42.2,8.68 40.38,8.68 40.17,8.47 40.17,7.95 40.49,7.63 40.49,6.07 40.49,6.06 40.47,5.95 40.49,5.84 40.49,5.83 40.49,5.4 40.58,5.31 40.58,4.49 40.28,4.19 39.44,4.19 39.28,4.35 39.28,4.77 39.79,5.28 39.79,5.46 39.79,5.47 39.81,5.57 39.79,5.67 39.79,5.68 39.79,6.26 39.61,6.43 39.61,6.94 37.95,8.6 37.95,9.31 41.62,12.99 41.66,12.99
+CHG_VIN_20V on BOTTOM (solid shape): 186.2,7.17 186.2,1.77 186.01,1.58 182.1,1.58 182.1,2.27 179.81,2.27 179.65,2.43 179.65,3.68 179.88,3.91 181.23,3.91 181.42,4.1 181.42,6.94 181.79,7.31 186.06,7.31
+CHG_VIN_20V on BOTTOM (solid shape): outline of 142 points within 35.96,1.28 56.95,12.99
+CHG_VIN_20V on GND3 (solid shape): 182.98,3.22 182.98,2.68 182.81,2.51 179.95,2.51 179.86,2.61 179.86,3.18 179.99,3.3 182.89,3.3
+CHG_VIN_20V on GND1: 53.66,1.23 53.46,1.43 53.46,1.83 53.74,2.11 53.74,3.89 54.02,3.89 55.53,5.4 76.55,5.4 78.62,7.47 88.7,7.47 91.71,4.46 107.29,4.46 107.51,4.25 113.14,4.25 114.09,5.2 129.35,5.2 129.96,5.81 134.12,5.81 134.75,5.19 143.74,5.19 144.59,4.34 149.14,4.34 149.94,5.14 153.01,5.14 153.87,4.27 157.94,4.27 159.5,5.84 163.25,5.84 163.66,5.42 165.8,5.42 166.26,4.96 169.43,4.96 169.8,5.33 173.87,5.33 174.65,6.12 180.94,6.12 182.53,4.53 182.53,2.98 182.21,2.66 171.26,2.66 171.06,2.46 171.06,1.7 171.01,1.65 87.09,1.65 86.55,2.18 86.55,3.15 85.07,4.63 80.89,4.63 79.34,3.08 79.34,1.81 78.75,1.23
+EC_DEBUG_VCC on BOTTOM (solid shape): 16.51,12.31 16.51,10.93 16.41,10.83 15.93,10.83 15.32,10.22 13.88,10.22 13.52,9.86 12.85,9.86 12.74,9.97 12.74,10.42 12.74,10.42 12.74,10.7 12.92,10.88 13.73,10.88 14.06,10.65 14.4,10.88 14.71,10.88 14.83,11 15,11.08 15.08,11.25 15.15,11.33 15.15,11.72 15.88,12.45 16.37,12.45
+INV_PWR_SRC on TOP (solid shape): 281.12,27.48 281.12,23.79 280.42,23.09 280.42,19.11 279.4,18.09 279.27,18.09 279.27,17.97 279.17,17.86 279.17,17.2 278.69,16.72 278.69,15.88 278.64,15.83 278.06,15.83 277.99,15.9 277.98,15.91 277.93,16 277.84,16.06 277.83,16.06 277.49,16.39 277.49,18.65 277.51,18.65 277.51,19.06 277.7,19.25 277.7,20.05 278.02,20.38 278.44,20.38 278.44,21.19 278.18,21.19 278.18,21.22 278.17,21.22 278.17,24.04 279.19,25.05 279.19,25.82 279.19,26.43 279.19,27.64 279.31,27.77 280.83,27.77
+INV_PWR_SRC on BOTTOM (solid shape): 280.21,27.52 280.21,25.89 280.12,25.79 277.94,25.79 277.83,25.9 277.83,26.06 279.38,26.06 279.38,26.33 278.21,26.33 278.21,26.06 277.83,26.06 277.83,26.56 279.36,26.56 279.36,26.82 278.21,26.82 278.21,26.56 277.83,26.56 277.83,27.06 279.39,27.06 279.39,27.32 278.18,27.32 278.18,27.06 277.83,27.06 277.83,27.54 277.92,27.64 280.1,27.64
+INV_PWR_SRC on GND1 (solid shape): 280.71,27.51 280.71,26.37 280.59,26.25 280.04,26.25 279.69,26.59 279.69,27.43 280,27.73 280.49,27.73
+INV_PWR_SRC on GND3 (solid shape): 280.7,27.55 280.7,26.33 280.43,26.06 279.71,26.06 279.54,26.23 279.54,27.63 279.71,27.79 280.45,27.79
+INV_PWR_SRC_IN+ on TOP (solid shape): 281.78,16.65 283.8,16.65 283.94,16.51 283.94,15.87 283.74,15.66 281.12,15.66 280.81,15.35 280.81,14.48 280.76,14.44 280.13,14.44 280.02,14.54 280.02,14.97 279.35,15.65 279.35,16.73 279.45,16.83 281.6,16.83
+LCDVDD on BOTTOM (solid shape): 43.74,62.33 43.74,58.36 44.36,57.74 45.58,57.74 45.68,57.64 45.68,57.64 45.76,57.56 46.96,57.56 47.08,57.43 47.82,57.43 47.97,57.59 47.97,59.18 48.15,59.36 48.69,59.36 48.84,59.21 48.84,57.14 48.47,56.78 47.03,56.78 46.83,56.57 46.83,55.59 46.64,55.4 46.15,55.4 46,55.56 46,56.06 45.77,56.29 45.09,56.29 44.8,56 44.19,56 43.96,55.77 42.92,55.77 42.85,55.84 42.85,57.49 42.55,57.79 42.55,58.44 42.4,58.59 42.27,58.59 41.83,59.02 41.83,60.23 41.93,60.33 41.93,61.8 41.93,61.8 41.93,62.35 42.03,62.45 43.63,62.45
+LCDVDD on IN1 (solid shape): 39.75,60.75 41.91,60.75 43.15,59.52 43.15,58.87 42.92,58.64 42.47,58.64 41.29,59.82 39.26,59.82 37.43,61.65 33.76,61.65 33.12,61.01 31.91,61.01 31.8,61.12 31.8,61.83 32.42,62.45 38.05,62.45
+LCDVDD_IN+ on BOTTOM (solid shape): 48.32,56.37 48.32,54.48 48.02,54.18 47.2,54.18 47.07,54.31 47.07,55.11 47.5,55.54 47.5,56.42 47.59,56.5 48.19,56.5
+ODR_PWR on TOP (solid shape): 280.5,33.57 280.5,32.97 280.8,32.66 281.78,32.66 281.79,32.66 283.69,32.66 283.87,32.47 283.87,31.97 283.77,31.86 280.09,31.86 279.99,31.96 279.99,32.43 279.77,32.65 279.77,33.66 279.94,33.83 280.23,33.83
+ODR_PWR on IN3 (solid shape): 284.3,34.06 284.58,33.74 284.94,33.97 284.96,33.99 285,34 285.18,34.01 285.33,34.11 285.64,34.11 285.81,33.94 285.81,33.07 285.52,32.77 281.41,32.77 281.41,32.77 280.38,32.77 280.11,33.04 280.11,33.57 280.65,34.11 284.29,34.11
+PECI_VREF on TOP (solid shape): 13.88,18.83 13.88,18.41 13.76,18.29 12.79,18.29 12.49,17.99 11.47,17.99 11.34,18.12 11.34,18.57 11.42,18.65 12.38,18.65 12.63,18.9 13.81,18.9
+RTC_CELL_VBAT on BOTTOM (solid shape): 24.83,11.46 24.83,10.86 24.69,10.72 24.7,10.52 24.7,10.42 24.61,10.37 24.07,10.37 23.81,10.12 23.31,10.12 23.23,10.19 23.23,11.09 23.47,11.33 23.99,11.33 24.09,11.34 24.25,11.49 24.81,11.49
+RTCBATT on BOTTOM (solid shape): 254.98,7.5 254.98,6.57 254.85,6.45 254.82,6.45 254.56,6.18 254.56,6.15 254.5,6.09 254.5,5.46 254.09,5.05 252.33,5.05 251.88,5.49 251.88,5.65 252.13,5.9 253.46,5.9 253.91,6.36 253.91,6.51 253.96,6.72 253.91,6.94 253.91,7.34 254.18,7.61 254.87,7.61
+RTCVCC on TOP (solid shape): 131.8,43.81 131.8,43.3 131.66,43.16 129.99,43.16 129.69,42.86 129.25,42.86 129.14,42.97 129.14,43.21 129.31,43.39 129.31,43.57 129.5,43.76 131.12,43.76 131.24,43.87 131.73,43.87
+RTCVCC on BOTTOM (solid shape): 148.63,39.07 148.63,38.41 148.12,37.9 145.49,37.9 145.4,37.98 145.4,38.37 145.42,38.39 147.18,38.39 147.81,39.02 148.07,39.02 148.24,39.2 148.5,39.2
+RTCVCC on BOTTOM (solid shape): 26.3,11.54 26.3,11.01 26.17,10.87 25.96,10.87 25.91,10.93 25.91,11.05 25.91,11.1 25.67,11.34 25.25,11.34 24.83,11.77 24.81,11.79 24.26,11.79 24.18,11.87 24.18,12.36 24.22,12.4 25.44,12.4
+RTCVCC on IN1 (solid shape): outline of 363 points within 125.63,42.89 129.72,50.76
+RTCVCC on IN4 (solid shape): 146.67,38.09 146.67,37.31 146.59,37.22 146.22,37.22 146,37.44 146,37.8 145.92,37.87 145.5,37.87 145.39,37.99 145.39,38.37 145.55,38.53 146.24,38.53
+RTCVCC on IN4 (solid shape): 143.78,36.79 143.78,36.22 145.78,34.21 145.78,32.56 145.67,32.45 145.4,32.45 145.11,32.74 145.11,33.87 142.79,36.2 142.79,36.85 142.97,37.03 143.54,37.03
+SD_VDD2 on TOP (solid shape): 296.79,34.54 296.79,34.21 296.64,34.06 295.62,34.06 295.47,33.9 295.47,33.89 295.42,33.84 295.42,33.44 295.33,33.36 295.06,33.36 294.93,33.48 294.93,34.45 295.24,34.75 296.57,34.75
+SD_VDD2 on BOTTOM (solid shape): 295.55,35.28 295.84,35.28 295.98,35.14 295.98,33.67 295.71,33.41 295.71,33.41 295.67,33.37 295.09,33.37 294.74,33.71 294.02,33.71 293.55,34.18 293.55,34.46 293.93,34.84 293.93,35.73 294.07,35.87 294.96,35.87
+SD_VDD2 on IN2 (solid shape): outline of 134 points within 284.31,33.82 294.67,39.45
+SD_VDD2 on GND3 (solid shape): 294.31,35.74 294.31,34.48 294.31,34.48 294.31,34.41 294.18,34.28 293.65,34.28 293.57,34.36 293.57,34.87 293.63,34.92 293.63,35.57 293.88,35.82 294.24,35.82
+SD_VDD2 on GND3 (solid shape): 284.98,34.56 285.02,34.56 285.21,34.56 285.26,34.55 285.32,34.56 285.34,34.56 285.56,34.34 285.56,34.25 285.62,34.18 285.77,34.18 285.86,34.09 285.86,33.92 285.8,33.86 284.46,33.86 284.4,33.91 284.4,34.15 284.81,34.56
+TPM_LPM on BOTTOM (solid shape): 168.88,15.78 169.64,15.78 169.7,15.72 169.7,15.58 169.63,15.51 168.66,15.51 168.44,15.29 167.62,15.29 167.52,15.39 165.9,15.39 165.88,15.41 165.88,16.3 165.95,16.38 167.04,16.38 167.15,16.48 168.19,16.48
+VREFCA on BOTTOM (solid shape): outline of 407 points within 123.6,14.57 127.28,21.55
+VREFCA on IN1 (solid shape): outline of 83 points within 84.41,16.12 89.44,21.48
+VREFCA on IN2 (solid shape): outline of 256 points within 84.03,15.81 89.52,21.53
AMP_OUT_L+ on TOP (solid shape): 279.54,10.63 279.54,9.47 279.34,9.27 279.34,8.79 278.96,8.79 278.93,8.82 278.93,9.69 278.66,9.96 276.78,9.96 276.56,9.74 275.29,9.74 275.22,9.81 275.22,9.87 275.3,9.95 276.16,9.95 276.29,10.08 276.29,10.23 277,10.95 279.22,10.95
AMP_OUT_L- on TOP (solid shape): 278.69,12.85 278.69,11.46 278.64,11.41 276.85,11.41 276.6,11.16 276.59,11.16 276.38,10.95 275.29,10.95 275.23,11 275.23,11.09 275.3,11.16 276.19,11.16 277.27,12.24 277.93,12.24 278,12.31 278,12.8 278.11,12.91 278.63,12.91
AMP_OUT_P_L- on TOP (solid shape): 281.5,13.04 281.5,11.58 281.39,11.47 278.89,11.47 278.89,12.23 278.98,12.33 279.56,12.33 280.31,13.07 281.47,13.07
AMP_OUT_P_L- on IN2 (solid shape): 279.37,11.49 279.37,11.05 278.08,9.76 277.38,9.76 277.16,9.98 277.16,10.25 278.59,11.68 279.18,11.68
AMP_OUT_P_L- on IN2 (solid shape): 272.47,9.52 272.83,9.18 273.18,9.52 273.19,9.56 273.85,9.56 273.85,9.52 274.21,9.18 274.56,9.52 274.57,9.56 275.47,9.56 275.78,9.26 275.78,8.54 275.6,8.36 274.5,8.36 274.21,8.51 273.91,8.36 271.52,8.36 271.36,8.51 271.31,8.55 271.29,8.61 271.29,9.08 271.32,9.16 271.4,9.18 271.67,9.26 271.8,9.51 271.8,9.53 271.83,9.56 272.47,9.56
AMP_OUT_P_L- on GND3 (solid shape): 272.23,9.07 272.23,8.69 272.12,8.59 270.03,8.59 269.99,8.63 269.99,8.93 270.18,9.13 272.18,9.13
AMP_OUT_P_L-_R on BOTTOM (solid shape): 269.6,9.09 269.6,8.47 269.44,8.31 267.77,8.31 267.68,8.4 267.68,8.78 268.07,9.18 269.52,9.18
AMP_OUT_P_L-_R on GND3 (solid shape): 268.09,8.77 268.09,7.86 267.71,7.47 267.4,7.47 267.4,7.48 267.22,7.48 267.15,7.55 267.15,8.04 267.44,8.33 267.44,8.74 267.58,8.87 267.98,8.87
AMP_OUT_P_R- on TOP (solid shape): 282.35,8.35 282.35,6.99 282.31,6.95 281.46,6.95 281.43,6.98 281.43,7.11 281.26,7.28 279.74,7.28 279.72,7.29 279.72,8.2 279.86,8.33 279.86,8.33 279.92,8.39 282.32,8.39
AMP_OUT_P_R- on IN2 (solid shape): 280.06,7.68 280.06,7.17 279.81,6.91 278.14,6.91 277.93,7.12 277.93,7.55 278.29,7.91 279.84,7.91
AMP_OUT_P_R- on IN2 (solid shape): 273.86,8.08 274.21,7.8 274.56,8.08 274.56,8.12 275.65,8.12 275.82,7.95 275.82,6.95 275.77,6.9 275.47,6.9 275.27,7.1 274.36,7.1 274.35,7.1 274.08,7.11 273.88,6.91 273.87,6.88 273.79,6.88 273.73,6.82 273.72,6.82 272.23,5.33 272.23,5.32 271.64,4.73 270.81,4.73 270.8,4.73 270.31,4.73 270.19,4.85 270.19,5.29 270.5,5.6 270.5,5.6 271.34,6.44 271.74,6.57 271.73,6.99 271.71,7.06 271.74,7.12 271.81,7.24 271.83,7.37 271.83,7.39 272.56,8.12 273.85,8.12
AMP_OUT_P_R-_R on BOTTOM (solid shape): 268.52,5.52 268.52,5.22 268.6,5.14 269.28,5.14 269.36,5.07 269.36,4.59 269.31,4.54 267.95,4.54 267.92,4.57 267.88,4.59 267.88,5.49 267.96,5.57 268.47,5.57
AMP_OUT_R+ on TOP (solid shape): 277.28,6.01 278.15,6.01 278.43,5.73 278.43,4.77 278.5,4.69 278.5,4.29 278.45,4.24 278.08,4.24 277.81,4.51 277.81,4.89 277.47,5.23 277.03,5.23 276.74,5.52 276.74,5.93 276.12,6.55 275.29,6.55 275.23,6.61 275.23,6.69 275.29,6.75 276.53,6.75
AMP_OUT_R- on TOP (solid shape): 279.51,8.03 279.51,6.94 279.22,6.65 278.97,6.65 278.89,6.73 278.89,7.05 278.64,7.29 278.44,7.29 278.43,7.28 276.8,7.28 276.32,7.75 275.29,7.75 275.22,7.82 275.22,7.9 275.26,7.94 278.86,7.94 278.97,8.06 279.48,8.06
B+ on TOP (solid shape): 170.09,7.68 170.09,1.74 170.1,1.73 170.1,1.47 169.98,1.35 166.9,1.35 166.8,1.45 166.8,5.51 166.81,5.52 166.81,8.16 167.27,8.62 169.16,8.62
B+ on TOP (solid shape): 47.89,24.41 47.89,24.21 49,23.09 49.82,23.09 50.57,22.33 50.63,22.27 50.69,22.22 50.87,22.04 50.87,20.93 50.7,20.76 49.95,20.76 49.78,20.58 48.92,20.58 47.59,21.91 47.59,21.98 47.4,22.17 45.9,22.17 45.54,22.53 45.05,22.53 44.87,22.71 44.87,22.71 44.79,22.79 44.79,24.26 45.16,24.62 47.68,24.62
B+ on TOP (solid shape): 288.29,12.6 288.92,12.6 288.93,12.59 289,12.59 289.22,12.37 289.56,12.37 293.78,8.15 294.99,8.15 295.24,8.4 295.84,8.4 295.98,8.26 295.98,6.15 295.88,6.05 295.03,6.05 295.02,6.06 294.34,6.2 293.66,6.06 293.65,6.05 293.04,6.05 291.64,7.45 291.32,7.78 291.31,7.78 290.66,8.43 290.66,9.38 290.01,10.04 289.26,10.04 289.25,10.03 288.72,10.03 288.2,10.56 287.42,10.56 283.97,14 283.19,14 283.03,14.16 283.03,15.34 283.18,15.49 283.82,15.49 284.18,15.86 285.03,15.86
B+ on TOP (solid shape): 75.8,19.89 75.8,12.53 75.8,12.53 75.8,12.26 74.83,11.3 74.83,7.83 75.27,7.39 77.66,7.39 78.37,8.1 78.41,8.14 86.32,8.14 90.01,4.45 90.01,1.55 89.74,1.29 86.74,1.29 86.32,1.54 86.16,2 85.5,3.61 83.89,4.27 81.89,4.27 81.74,4.27 81.59,4.25 72.53,4.25 71.96,4.82 71.96,6.72 71.89,7.05 71.68,7.32 71.68,9.53 72.21,10.06 72.21,10.89 71.43,11.67 71.43,16.09 71.43,16.1 71.43,16.35 71.59,16.52 72.49,16.52 73.1,17.13 73.1,20.23 73.41,20.53 75.16,20.53
B+ on TOP (solid shape): outline of 294 points within 165.18,33.49 171.29,56.87
B+ on BOTTOM (solid shape): 160,2.83 160,1.53 159.76,1.28 158.58,1.28 158.52,1.35 158.52,3.12 159.7,3.12
B+ on BOTTOM (solid shape): 226.56,2.41 225.53,1.38 223.31,1.38 223.18,1.52 223.18,3.8 223.33,3.96 226.56,3.96
B+ on BOTTOM (solid shape): 130.5,3.03 130.5,1.45 130.34,1.29 129.48,1.29 129.34,1.42 129.34,3.14 129.44,3.25 130.29,3.25
B+ on BOTTOM (solid shape): 67.24,32.18 67.24,31.56 66.77,31.09 65.71,31.09 65.54,30.92 65.21,30.92 65.15,30.98 65.15,31.85 65.5,32.2 66.75,32.2 66.91,32.36 67.07,32.36
B+ on BOTTOM (solid shape): 282.12,35.63 282.72,35.63 282.72,35.3 282.73,35.29 282.73,34.09 282.68,34.04 281.69,34.04 281.61,34.12 281.61,34.8 281.14,35.27 281.14,35.8 281.18,35.83 281.92,35.83
B+ on BOTTOM (solid shape): 52.85,44.35 55.16,44.35 55.34,44.17 55.34,39.17 54.93,38.76 53.19,38.76 52.41,39.53 52.41,40.8 50.33,42.89 50.33,44.65 50.78,45.1 52.1,45.1
B+ on BOTTOM (solid shape): 266.49,3.35 266.49,2.69 266.81,2.36 269.56,2.36 269.69,2.23 269.69,1.54 269.56,1.4 255.87,1.4 255.54,1.73 255.54,3.64 255.58,3.68 266.15,3.68
B+ on BOTTOM (solid shape): 38.6,23.73 38.6,23.42 38.2,23.01 37.23,23.01 37.16,22.94 36.61,22.94 36.58,22.97 36.58,23.45 36.59,23.46 37.87,23.46 38.31,23.9 38.44,23.9
B+ on BOTTOM (solid shape): 55.36,31.02 56.98,31.02 57.01,30.99 57.01,29.52 57.16,29.37 58.16,29.37 58.36,29.17 58.36,28.71 57.8,28.15 56.07,28.15 55.86,28.36 55.86,29.76 55.72,29.9 55.72,29.9 55.67,29.95 55.11,29.95 55.1,29.96 54.91,29.96 54.84,30.04 54.84,30.98 54.93,31.07 55.31,31.07
B+ on BOTTOM (solid shape): 171.24,67.81 171.24,53.98 171.06,53.81 169.47,53.81 169.33,53.95 169.33,54.98 169.3,55.01 169.3,55.01 168.72,55.59 168.71,55.59 168.6,55.7 168.6,56.64 168.2,57.05 168.2,58.45 168.2,64.2 168.16,64.24 168.16,64.25 166.5,65.91 164.01,65.91 163.85,66.07 163.85,67.22 163.55,67.52 162.61,67.52 162.49,67.63 162.49,68.48 162.56,68.55 164.64,68.55 165.84,69.74 169.31,69.74
B+ on BOTTOM (solid shape): 47.59,24.47 47.76,24.47 47.99,24.24 47.99,24.07 49.06,23 49.86,23 49.86,22.99 49.95,22.99 50.91,22.03 51.53,22.03 51.67,21.89 51.67,20.86 51.23,20.42 48.72,20.42 48.12,21.02 47.66,21.02 47.34,21.34 47.34,21.66 47.34,21.67 47.34,21.88 47.15,22.07 46.28,22.07 46.12,22.22 46.12,22.22 45.03,22.22 44.88,22.37 44.88,22.37 44.79,22.46 44.79,24.28 44.98,24.47 47.59,24.47
B+ on BOTTOM (solid shape): 281.63,40.7 281.63,40 281.54,39.92 280.05,39.92 279.99,39.86 279.6,39.48 279.6,38.55 278.96,37.9 278.96,37.2 278.92,37.16 278.18,37.16 278.04,37.3 278.04,38.93 278.27,39.43 278.04,39.92 278.04,39.93 279.05,40.94 279.4,40.67 279.74,40.95 281.38,40.95
B+ on BOTTOM (solid shape): outline of 83 points within 70.66,1.27 113.16,21.06
B+ on IN1 (solid shape): 224.24,2.54 224.24,1.4 224.14,1.3 218.35,1.3 218.02,1.62 218.02,2.74 224.03,2.74
B+ on IN1 (solid shape): 32.62,25.7 37.75,25.7 37.92,25.54 37.92,25.27 37.77,25.12 32.14,25.12 31.94,25.32 31.3,25.32 31.22,25.39 31.22,26.02 31.35,26.14 32.18,26.14
B+ on IN1 (solid shape): 117.27,3.44 132.31,3.44 132.33,3.42 132.37,3.39 132.41,3.36 132.46,3.34 132.51,3.32 132.56,3.31 132.61,3.31 132.66,3.32 132.71,3.33 132.76,3.35 132.8,3.38 132.83,3.41 132.86,3.42 132.89,3.42 132.92,3.42 132.95,3.4 132.98,3.38 133.02,3.35 133.07,3.32 133.12,3.31 133.18,3.3 133.23,3.3 133.28,3.31 133.34,3.33 133.38,3.35 133.43,3.38 133.47,3.42 133.48,3.44 170.8,3.44 171.27,2.97 171.27,1.62 170.99,1.34 86.68,1.34 86.26,1.76 86.26,2.98 86.58,3.3 115.92,3.3 115.92,3.26 115.94,3.21 115.96,3.17 115.99,3.14 116.02,3.11 116.06,3.08 116.11,3.07 116.15,3.06 116.2,3.06 116.24,3.07 116.28,3.08 116.32,3.11 116.36,3.14 116.39,3.17 116.41,3.21 116.42,3.26 116.43,3.3 116.43,3.35 116.42,3.39 116.4,3.43 116.37,3.47 116.34,3.51 116.3,3.53 116.26,3.55 116.22,3.57 116.17,3.57 116.13,3.57 116.08,3.55 116.04,3.53 116.01,3.51 115.97,3.47 115.95,3.43 115.93,3.39 115.92,3.35 115.92,3.3 86.58,3.3 86.72,3.44 115.1,3.44 115.55,3.9 116.82,3.9
B+ on GND1 (solid shape): 224.87,2.19 224.87,1.56 224.71,1.4 223.06,1.4 222.91,1.55 222.91,2.2 223.1,2.39 224.67,2.39
