# Allegro board LAE671PR10-1018.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.8VU on TOP (solid shape): 147.85,23.33 148.87,23.33 149,23.2 149,22.57 148.87,22.44 147.09,22.44 146.46,21.81 146.46,21.17 146.71,20.92 146.71,20.16 146.52,19.97 146.52,19.96 146.33,19.77 145.95,19.77 145.82,19.9 145.82,20.66 145.64,20.85 145.63,20.87 145.58,20.99 145.47,21.08 145.44,21.09 145.44,21.27 145.62,21.44 145.62,21.47 145.7,21.55 145.7,21.68 145.44,21.93 145.44,22.07 145.62,22.24 145.62,22.32 145.63,22.38 145.95,22.7 146.2,22.7 146.84,23.33 146.84,23.46 146.97,23.58 147.6,23.58
+1.8VU on BOTTOM (solid shape): outline of 9107 points within 82.92,13.27 155.34,30.25
+1.8VUP on BOTTOM (solid shape): 154.58,12.59 155.02,12.59 155.02,13.13 155.3,13.13 155.32,13.11 155.32,11.71 155.06,11.45 155.06,7.15 154.78,6.86 154.78,5.96 154.87,5.86 155.89,5.86 155.95,5.8 155.95,5.66 155.9,5.61 154.54,5.61 154.44,5.71 154.44,6.6 154.26,6.77 153.18,6.77 152.81,7.14 152.81,10.8 152.81,10.81 152.81,13.05 152.89,13.13 154.58,13.13
+3.3V_1.8V_PGPPA on BOTTOM (solid shape): 134.92,41.42 134.92,39.59 135.15,39.37 135.15,39.18 135.08,39.11 134.95,39.11 134.82,39.24 134.82,39.39 134.81,39.4 134.31,39.4 134.24,39.48 134.24,40.54 134.54,40.85 134.54,41.11 134.55,41.11 134.55,41.53 134.64,41.62 134.72,41.62
+3.3V_1.8V_PGPPA on IN3 (solid shape): outline of 97 points within 129.29,49.91 131.08,51.45
+3.3V_1.8V_PGPPA on GND3 (solid shape): 135.96,42.52 136.01,42.52 136.06,42.52 136.09,42.51 136.11,42.5 136.15,42.46 136.18,42.42 136.2,42.4 136.2,42.37 136.21,42.32 136.2,42.27 136.2,42.24 136.18,42.22 136.15,42.18 136.11,42.14 136.09,42.13 135.81,41.85 135.77,41.81 135.21,41.81 135.04,41.63 135.04,41.59 134.96,41.52 134.96,41.41 134.89,41.33 134.63,41.33 134.54,41.42 134.54,41.67 135.05,42.18 135.59,42.18 135.6,42.19 135.82,42.4 135.83,42.42 135.91,42.5 135.93,42.51
+3.3V_EC5105 on TOP (solid shape): 27.03,15.69 27.03,15.27 26.98,15.22 25.75,15.22 25.74,15.21 24.65,15.21 24.49,15.37 24.49,15.7 24.57,15.78 26.94,15.78
+3.3V_EC5105 on TOP (solid shape): 21.72,22.77 22.41,22.77 22.56,22.62 22.56,22.16 22.45,22.05 21.07,22.05 20.91,22.22 20.91,22.66 21.02,22.77 21.54,22.77 21.54,23.32 21.72,23.32
+3.3V_EC5105 on BOTTOM (solid shape): 29.25,13.42 29.25,11.64 29,11.39 27.85,11.39 27.47,11.77 27.47,13.55 27.6,13.67 29,13.67
+3.3V_EC5105 on BOTTOM (solid shape): 11.09,17.61 11.24,17.61 11.36,17.49 11.93,17.49 12.03,17.38 12.03,16.85 11.9,16.73 10.52,16.73 10.24,17.01 10.24,17.53 10.31,17.61 11.09,17.61
+3.3V_EC5105 on IN3 (solid shape): outline of 336 points within 15.45,14.25 19.72,16.63
+3.3V_EC_PLL on TOP (solid shape): 25.84,13.86 27.1,13.86 27.11,13.85 28.11,13.85 28.11,13.73 28.56,13.27 29.54,13.27 29.58,13.23 29.58,12.92 29.48,12.82 28.8,12.82 28.58,13 28.32,12.9 28.14,13.08 26.8,13.08 26.65,13.23 26.07,13.23 26.06,13.26 25.82,13.56 25.45,13.47 25.37,13.44 25.3,13.47 25.01,13.76 24.64,13.76 24.63,13.79 24.58,13.88 24.51,13.95 24.51,14.21 24.61,14.31 25.4,14.31
+3.3V_PGPP on GND1 (solid shape): 131.04,54.35 131.27,54.27 131.5,54.35 131.63,54.35 131.78,54.26 131.95,54.25 132.06,54.29 132.16,54.35 132.3,54.35 132.51,54.25 132.74,54.31 132.99,54.31 133.14,54.25 133.3,54.27 133.47,54.27 133.52,54.21 133.52,53.3 133.39,53.17 133.13,53.17 133.03,53.26 133.03,53.56 132.83,53.76 132.74,53.76 132.6,53.79 132.46,53.76 132.11,53.76 131.96,53.79 131.82,53.76 131.5,53.76 131.33,53.8 131.16,53.76 131.1,53.76 130.72,53.38 129.63,53.38 129.5,53.51 129.5,53.79 129.66,53.95 130.44,53.95 130.85,54.35
+3.3VDX_SSD on TOP (solid shape): 149.88,37.4 149.88,35.88 149.73,35.73 145.56,35.73 145.41,35.89 145.41,36.9 145.7,37.19 147.59,37.19 147.91,37.51 149.78,37.51
+3.3VDX_SSD on TOP (solid shape): 151.8,26.5 153.46,26.5 154.52,25.45 154.52,21.72 154.75,21.48 154.75,19.76 154.49,19.5 153.04,19.5 152.97,19.57 152.97,21.11 153.04,21.19 153.57,21.19 154.08,21.7 154.08,25.19 153.25,26.02 150.21,26.02 150.13,26.1 150.13,26.51 150.2,26.58 151.72,26.58
+3.3VDX_SSD on BOTTOM (solid shape): outline of 179 points within 149.16,17.82 156.76,39.35
+3.3VDX_SSD on GND1 (solid shape): 150.14,37.51 150.14,36.47 150.05,36.29 150.11,36.11 150.11,35.22 149.97,35.08 149.5,35.08 149.36,35.22 149.27,35.46 149.05,35.56 149.05,37.57 149.13,37.64 150.01,37.64
+3.3VDX_SSD on GND3 (solid shape): 150.6,37.4 150.6,35.5 150.18,35.08 149.77,35.08 149.62,35.23 149.62,37.53 149.72,37.64 150.36,37.64
+3.3VDX_SSD_IN+ on TOP (solid shape): 150.24,35.24 150.24,34.48 150.16,34.41 149.04,34.41 148.99,34.36 148.95,34.36 148.23,33.64 147.5,33.64 147.33,33.69 147.17,33.64 146.48,33.64 146.39,33.72 146.39,35 146.43,35.03 147.29,35.03 147.33,35.07 147.33,35.5 147.38,35.54 149.93,35.54
+3V_LDO on BOTTOM (solid shape): 24.35,34.84 24.35,33.99 24.47,33.87 24.99,33.87 25.08,33.78 25.08,33.22 25.06,33.2 23.62,33.2 23.59,33.24 23.59,33.7 23.59,33.7 23.59,34.89 23.7,35 24.19,35
+3V_LDO on IN4 (solid shape): 208.07,11.87 208.07,11.73 207.34,11.01 207.14,11.01 206.92,11.22 206.92,11.47 207.64,12.19 207.75,12.19
+3V_LDOP on BOTTOM (solid shape): 45.25,3.13 45.25,2.45 44.29,1.48 41.82,1.48 41.19,2.12 39.28,2.12 39.03,2.37 39.03,2.75 39.41,3.13 41.7,3.13 42.33,2.5 43.47,2.5 44.36,3.39 45,3.39
+3V_PCH on TOP (solid shape): 161.05,27.76 161.05,27.37 160.46,26.78 158.67,26.78 158.52,26.93 158.52,27.53 158.87,27.88 160.93,27.88
+3V_PCH on TOP (solid shape): 132.48,52.72 132.48,51.86 132.19,51.58 132.19,51.21 132.02,51.03 131.85,51.03 131.67,51.21 131.67,51.66 131.76,51.76 131.76,52.68 131.84,52.76 132.44,52.76
+3V_PCH on TOP (solid shape): 148.17,30.87 150.77,30.87 151.12,30.52 151.12,29.85 151.08,29.81 147.33,29.81 147.2,29.93 147.2,30.33 146.89,30.65 146.46,30.65 146.38,30.73 146.38,31.28 146.4,31.3 147.73,31.3
+3V_PCH on TOP (solid shape): 128.11,51.76 128.11,50.87 128.05,50.81 127.15,50.81 126.84,51.12 126.83,51.13 126.66,51.13 126.59,51.19 126.36,51.19 126.35,51.21 126.35,51.53 126.39,51.61 126.47,51.63 126.8,51.74 126.89,52.07 126.91,52.15 126.99,52.19 127.68,52.19
+3V_PCH on TOP (solid shape): 134.83,52.63 134.81,52.6 134.81,52.35 134.96,52.16 135.12,52 135.12,51.65 135.1,51.57 135.11,51.49 135.25,51.27 135.49,51.2 135.57,51.17 135.6,51.1 135.6,50.19 135.51,50.1 135.02,50.1 134.81,50.31 134.81,50.77 134.62,50.95 134.6,51.03 134.63,51.1 134.7,51.59 134.23,51.68 134.17,51.67 134.11,51.69 134.11,52.7 134.16,52.74 134.71,52.74
+3V_PCH on TOP (solid shape): 136.52,48.8 136.52,48.45 136.63,48.34 137.46,48.34 137.57,48.45 137.57,48.66 137.76,48.85 138.28,48.85 138.38,48.75 138.38,48.54 138.38,48.51 137.8,47.93 137.8,47.36 137.66,47.22 137.66,46.13 137.57,45.83 137.8,45.63 137.81,45.63 138.12,45.32 138.17,45.32 138.2,45.3 138.67,45.3 138.69,45.32 138.93,45.32 139.06,45.22 139.23,45.19 139.38,45.21 139.51,45.29 139.54,45.28 139.57,45.27 139.69,45.2 139.83,45.18 140,45.21 140.14,45.32 140.31,45.32 140.62,45.64 141.76,45.64 143.39,47.27 143.97,47.27 144.92,48.22 147.6,48.22 147.98,47.83 147.98,46.3 147.4,45.72 144.48,45.72 142.9,44.14 142.9,43.77 142.32,43.18 141.25,43.18 141.07,43.36 141.07,44.03 140.75,44.35 139.11,44.35 139.09,44.38 138.84,44.55 138.58,44.38 138.57,44.35 138.21,44.35 138.13,44.36 138.06,44.35 137.08,44.35 136.46,44.97 136.46,46.62 135.85,47.23 135.85,48.58 136.13,48.85 136.47,48.85
+3V_PCH on BOTTOM (solid shape): 141.93,45.34 141.93,44.59 141.45,44.11 141.05,44.11 140.86,44.3 140.86,44.49 141.21,44.84 141.21,45.21 141.43,45.43 141.83,45.43
+3V_PCH on BOTTOM (solid shape): 142.19,40.84 142.34,40.59 142.5,40.36 142.5,39.56 142.41,39.47 141.62,39.47 141.57,39.52 141.57,40.16 141.14,40.6 141.14,40.98 141.28,41.12 141.63,41.12 141.64,41.13 141.9,41.13
+3V_PCH on BOTTOM (solid shape): 148.16,47.8 148.16,46.33 147.98,46.16 147.85,46.16 146.97,46.57 146.03,46.76 145.96,46.82 145.96,47.84 146.09,47.96 147.99,47.96
+3V_PCH on BOTTOM (solid shape): 143.02,56.85 144.25,56.85 144.3,56.8 144.3,56.26 144.03,55.99 143.67,55.99 143.59,55.91 143.59,55.9 142.9,55.21 142.9,53.88 142.83,53.8 142.57,53.8 142.44,53.93 142.44,55.39 142.31,55.53 141.78,55.53 141.68,55.63 141.68,57.44 141.68,57.44 141.68,57.55 141.73,57.6 142.27,57.6
+3V_PCH on BOTTOM (solid shape): 166.41,41.74 166.41,40.68 166.2,40.47 163.62,40.47 163.36,40.21 162.63,40.21 162.63,40.18 162.6,40.14 162.54,40.15 162.35,40.34 161.29,40.34 161.2,40.43 160.88,40.43 160.78,40.54 160.78,40.84 160.92,40.98 162.09,40.98 162.09,40.98 165.39,40.98 165.61,41.2 165.61,41.52 165.52,41.61 163.61,41.61 163.42,41.79 163.42,42.02 163.65,42.25 165.9,42.25
+3V_PCH on IN1 (solid shape): 165.22,36.08 165.22,34.91 164.96,34.65 164.29,34.65 163.66,35.28 163.66,36.32 163.68,36.35 164.95,36.35
+3V_PCH on IN1 (solid shape): 167.52,33.31 167.52,30.43 166.98,29.89 166.53,29.89 166.25,30.16 166.25,32.46 167.26,33.47 167.37,33.47
+3V_PCH on IN1 (solid shape): 150.09,47.9 150.09,47 149.93,46.84 149.08,46.84 148.28,46.04 147.71,46.04 147.05,46.7 147.05,47.42 147.83,48.2 149.78,48.2
+3V_PCH on IN1 (solid shape): 160.94,42.39 160.94,41.49 161.09,41.34 161.09,40.96 161.27,40.78 161.27,38.99 161.02,38.73 159.97,38.73 159.62,39.08 159.62,40.55 159.07,41.11 159.07,42.62 159.24,42.8 160.53,42.8
+3V_PCH on IN1 (solid shape): 161.68,30.62 161.68,27.5 161.24,27.07 160.33,27.07 160.06,27.33 160.06,28.71 160.31,28.71 160.32,28.67 160.33,28.62 160.35,28.58 160.38,28.55 160.41,28.51 160.45,28.49 160.49,28.47 160.53,28.46 160.58,28.46 160.62,28.46 160.67,28.48 160.71,28.5 160.74,28.53 160.77,28.56 160.8,28.6 160.81,28.65 160.82,28.69 160.82,28.74 160.81,28.78 160.8,28.82 160.77,28.86 160.74,28.9 160.71,28.93 160.67,28.95 160.62,28.96 160.58,28.97 160.53,28.97 160.49,28.96 160.45,28.94 160.41,28.91 160.38,28.88 160.35,28.84 160.33,28.8 160.32,28.76 160.31,28.71 160.06,28.71 160.06,30.78 160.16,30.88 161.42,30.88
+3V_PCH on IN1 (solid shape): outline of 1321 points within 123.13,50.07 143.34,57.03
+3V_PCH on IN2 (solid shape): outline of 1911 points within 122.96,48.31 140.46,58.64
+3V_PCH on IN4 (solid shape): 141.4,44.84 141.4,44.53 140.67,43.8 140.3,43.8 140.29,43.81 140.29,44.43 140.81,44.94 141.3,44.94
+3V_PCH_DSW on IN2 (solid shape): outline of 1004 points within 127.67,44.59 135.47,52.15
+3V_TBT on TOP (solid shape): 27.29,56.75 28.38,56.75 28.76,56.37 28.76,55.84 28.45,55.53 27.28,55.53 26.62,56.19 26,56.19 25.8,56.39 25.8,56.9 25.97,57.08 26.96,57.08
+3V_TBT on BOTTOM (solid shape): 30.22,56.79 30.22,56.18 30.09,56.05 28.96,56.05 28.53,55.63 27.66,55.63 27.48,55.82 27.48,56.6 27.7,56.83 27.99,56.83 28.11,56.81 28.23,56.83 28.96,56.83 28.97,56.84 30.16,56.84
+3V_TBT on BOTTOM (solid shape): 18.06,52.24 18.25,52.24 18.31,52.18 18.31,52.02 18.48,51.85 18.61,51.85 18.72,51.73 18.72,51.64 18.64,51.56 18.57,51.56 18.53,51.6 18.43,51.6 18.41,51.63 17.9,51.63 17.89,51.63 17.2,51.63 17.19,51.65 17.04,51.65 16.59,52.1 14.84,52.1 14.59,51.85 14.13,51.85 13.99,51.71 13.62,51.71 13.37,51.95 13.37,53.36 13.48,53.47 16.82,53.47
+3V_TBT on GND1 (solid shape): 17.9,52.67 17.9,52.1 17.49,51.7 17.09,51.7 16.91,51.88 16.91,52.04 17.1,52.23 17.18,52.23 17.36,52.4 17.36,52.64 17.5,52.79 17.78,52.79
+3V_TBT on IN4 (solid shape): outline of 401 points within 13.4,51.73 28.83,59.66
+3V_TBT_S0 on BOTTOM (solid shape): 28.98,58.41 28.98,57.12 28.86,57 27.65,57 27.33,56.68 27.33,56.42 27.26,56.35 26.4,56.35 26.22,56.53 26.22,58.38 26.43,58.59 27.27,58.59 27.27,58.6 28.8,58.6
+3V_TBT_S0 on IN1 (solid shape): outline of 1149 points within 23.76,45.47 28.32,57.4
+3V_TBT_S0 on GND1 (solid shape): 24.81,47.37 24.81,47.07 24.48,46.73 24.48,46.57 24.34,46.43 24.03,46.43 23.76,46.7 23.76,47.48 23.84,47.56 24.62,47.56
+3V_VC_A on TOP (solid shape): 18,35 18,34.51 17.8,34.31 17.8,33.68 18.06,33.42 18.06,33.23 18.02,33.2 17.88,33.2 17.73,33.35 17.72,33.36 17.68,33.46 17.6,33.53 17.56,33.57 17.56,34.41 17.42,34.54 17.42,34.99 17.49,35.05 17.95,35.05
+3V_VC_A on BOTTOM (solid shape): 23.38,34.78 23.38,33.98 23.27,33.87 23.27,33.31 23.38,33.2 23.38,31.61 23.28,31.51 22.55,31.51 22.52,31.54 22.52,32.64 22.56,32.68 22.56,33.95 22.39,34.12 21.63,34.12 21.5,33.99 21.5,33.14 21.42,33.05 20.17,33.05 20.08,33.15 20.08,33.68 20.14,33.75 20.77,33.75 20.99,33.97 20.99,34.5 21.5,35.01 23.15,35.01
+3V_VC_A on IN1 (solid shape): 21.6,33.62 21.67,33.59 21.7,33.51 22.05,33.1 22.4,33.51 22.43,33.59 22.51,33.62 22.65,33.62 23.23,33.04 23.23,32.67 23.1,32.53 21.63,32.53 20.87,33.3 20.87,33.49 21,33.62
+3V_VC_B on BOTTOM (solid shape): 29.86,37.97 29.86,36.89 29.68,36.71 29.41,36.71 29.1,37.02 29.1,37.84 29.34,38.09 29.74,38.09
+3V_VC_B on IN2 (solid shape): 30.94,36.44 30.83,36.33 29.76,36.33 29.35,36.74 29.35,36.96 29.47,37.08 30.31,37.08
+3V_VC_C on TOP (solid shape): 288.06,17.25 288.06,16.85 287.97,16.77 285.59,16.77 285.53,16.83 285.53,17.26 285.59,17.32 287.99,17.32
+3VA_TBT on TOP (solid shape): 25.36,56.84 25.36,56.57 25.38,56.56 25.38,56.26 25.61,56.02 26.55,56.02 27.08,55.49 27.08,54.85 27.27,54.65 27.27,54.24 27.22,54.19 26.93,54.19 26.22,54.89 26.18,54.89 26.17,54.91 25.47,54.91 25.46,54.9 22.8,54.9 22.79,54.94 22.46,55.13 22.32,54.77 22.34,54.74 22.34,54.2 22.34,54.19 22.34,52.47 22.28,52.41 21.88,52.41 21.74,52.27 21.74,51.48 21.15,50.9 21.15,50.89 21.06,50.79 21.06,49.69 20.95,49.69 20.94,49.69 20.87,49.69 20.56,49.39 20.56,48.97 20.47,48.88 20.2,48.88 20.06,49.02 20.06,49.36 19.96,49.46 19.59,49.46 19.45,49.6 19.45,50 19.37,50.08 17.93,50.08 17.7,50.31 17.7,51.62 18.31,52.23 18.84,52.23 18.92,52.14 18.92,51.92 18.79,51.79 18.33,51.79 18.1,51.56 18.1,50.58 18.23,50.45 20.07,50.45 21.29,51.68 21.29,52.69 21.63,53.02 21.6,53.05 21.6,54.5 20.94,55.16 20.94,56.8 21.17,57.03 25.17,57.03
+3VA_TBT on BOTTOM (solid shape): 25.24,55.38 25.24,55.03 24.81,55.03 24.78,55 24.2,55 24.02,55.18 24.02,55.84 24.14,55.96 24.65,55.96
+3VA_TBT on BOTTOM (solid shape): 15.43,51.89 15.43,51.53 15.35,51.44 14.92,51.44 14.92,51.25 14.74,51.07 14.21,51.07 14.18,51.1 14.18,51.63 14.22,51.67 14.6,51.67 14.89,51.96 15.36,51.96
+3VA_TBT on BOTTOM (solid shape): 24.54,58.88 24.54,58.07 24.49,58.02 24.19,58.02 24.14,58.06 24.14,58.53 24.06,58.61 24.06,58.61 24.01,58.66 23.47,58.66 22.81,58.66 22.77,58.62 22.77,58.16 22.74,58.13 22.21,58.13 22.16,58.08 22.16,57.47 22.13,57.44 21.82,57.44 21.72,57.54 21.72,58.79 22.04,59.11 24.31,59.11
+3VA_TBT on BOTTOM (solid shape): 30.98,56.29 30.98,54.28 30.38,53.68 30.36,53.68 30.15,53.49 30.24,53.22 30.24,53.07 30.93,52.38 30.93,51.82 30.76,51.66 30.46,51.66 30.41,51.71 30.41,52.24 29.9,52.75 29.9,53.66 29.97,53.73 29.98,53.73 30.36,54.11 30.36,54.14 30.57,54.29 30.57,54.54 30.57,55.24 30.58,55.6 30.22,55.62 29.09,55.62 29.05,55.57 29.05,55.05 28.95,54.95 26.74,54.95 26.63,55.05 26.63,55.42 26.49,55.56 26.48,55.56 26.26,55.56 26.1,55.71 26.1,56.06 26.18,56.14 27.07,56.14 27.22,55.99 27.22,55.86 27.62,55.46 28.56,55.46 29.04,55.93 30.19,55.93 30.34,56.08 30.34,56.34 30.42,56.42 30.85,56.42
+3VA_TBT_LC on TOP (solid shape): 28.63,52.65 28.63,52.05 28.45,51.87 27.62,51.87 27.55,51.95 26.41,51.95 26.1,51.65 26.1,51.01 25.92,50.83 25.9,50.83 25.74,50.67 25.74,50.38 25.66,50.3 25.27,50.3 25.24,50.27 24.68,50.27 24.58,50.36 24.58,51.27 24.59,51.28 24.59,51.71 24.74,51.86 25.08,51.86 25.19,51.97 25.19,52.61 25.4,52.82 28.46,52.82
+3VA_TBT_LC on GND1 (solid shape): 25.01,51.49 25.17,51.49 25.67,50.99 25.67,50.36 25.48,50.18 24.62,50.18 24.53,50.28 24.53,51.38 24.64,51.49 25.01,51.49
+3VALW on TOP (solid shape): 151.02,40.86 151.02,40.62 150.32,39.92 149.7,39.92 149.61,40.01 149.61,40.24 150.37,40.99 150.89,40.99
+3VALW on TOP (solid shape): 22.6,24.1 22.6,23.14 22.36,22.9 21.85,22.9 21.85,23.45 21.41,23.45 21.41,22.9 20.87,22.9 20.72,23.05 20.72,24.24 20.85,24.38 22.33,24.38
+3VALW on TOP (solid shape): 50.19,64.22 50.19,61.84 50.41,61.62 51.1,61.62 51.16,61.57 51.16,60.69 50.87,60.41 48.65,60.41 48.45,60.61 48.45,62.99 48.28,63.15 48.28,64.37 48.48,64.56 49.85,64.56
+3VALW on TOP (solid shape): 282.49,18.55 283.44,18.55 283.48,18.51 283.48,17.85 283.34,17.7 283.34,16.9 283.26,16.82 283.05,16.82 282.96,16.91 282.96,17.68 282.8,17.84 282.69,17.84 282.45,18.08 282.45,18.51 282.48,18.55
+3VALW on TOP (solid shape): 19.52,5.52 19.52,5.31 19.5,5.2 19.52,5.09 19.52,3.88 19.38,3.75 17.92,3.75 17.78,3.88 17.78,4.29 18.15,4.66 18.15,5.93 18.36,6.14 18.9,6.14
+3VALW on TOP (solid shape): 19.01,61.27 19.01,60.82 19.44,60.4 21.58,60.4 21.91,60.07 21.91,60.06 26.85,60.06 27,59.91 27,57.84 26.85,57.68 24.25,57.68 23.9,57.33 20.58,57.33 19.76,58.15 19.01,58.15 17.26,59.89 17.26,61.21 17.45,61.39 18.89,61.39
+3VALW on TOP (solid shape): 31.03,17.23 31.03,16.88 31.14,16.76 31.7,16.76 31.81,16.65 31.81,16.02 31.73,15.94 31.22,15.94 30.95,15.68 30.17,15.68 30.07,15.58 29.07,15.58 29,15.65 29,16.2 29.15,16.35 29.66,16.35 29.91,16.6 29.91,17.25 30.01,17.36 30.9,17.36
+3VALW on TOP (solid shape): 253.65,10.6 253.65,9.22 253.57,9.13 252.96,9.13 252.79,8.96 252.79,8.63 252.71,8.56 252.05,8.56 252,8.5 252,8.39 252.02,8.36 252.71,8.36 252.79,8.28 252.79,8.19 252.69,8.1 251.53,8.1 251.13,8.49 251.13,9.64 251.93,10.44 251.93,10.45 252.26,10.78 253.47,10.78
+3VALW on TOP (solid shape): 268.76,52.71 269.02,52.71 269.18,52.64 269.35,52.68 269.38,52.7 270.07,52.02 270.07,48.14 269.67,47.74 269.5,47.74 269.48,47.73 268.95,47.73 268.87,47.81 268.87,49.46 268.95,49.64 268.87,49.82 268.87,50.7 268.7,50.87 268.75,50.92 268.75,51.13 268.6,51.28 268.39,51.28 268.27,51.16 267.71,51.16 267.55,51.01 267.55,49.23 267.32,49 267.32,48.62 267.48,48.47 267.48,47.81 267.35,47.68 266.56,47.68 266.21,48.03 266.21,52.1 266.84,52.73 268.68,52.73
+3VALW on TOP (solid shape): 154.27,36.19 155,35.89 155.73,36.19 157.93,36.19 159.05,35.06 159.05,32.26 157.81,31.02 151.88,31.02 151.52,31.39 151.52,33 151.55,33.07 152.18,33.1 152.25,33.11 152.32,33.15 152.33,33.16 152.37,33.16 152.39,33.14 152.81,33.33 152.39,33.52 152.37,33.51 152.33,33.51 152.32,33.52 152.25,33.55 152.18,33.56 151.62,33.56 151.55,33.59 151.52,33.66 151.52,33.8 151.55,33.87 152.18,33.9 152.25,33.91 152.32,33.95 152.33,33.96 152.4,33.96 152.41,33.94 152.84,34.13 152.41,34.32 152.4,34.31 152.33,34.31 152.32,34.32 152.25,34.35 152.18,34.36 151.62,34.36 151.55,34.39 151.52,34.46 151.52,36.05 151.65,36.19
+3VALW on BOTTOM (solid shape): 49.04,5.84 49.04,3.69 48.86,3.51 48.1,3.51 47.97,3.64 47.97,5.85 48.11,5.99 48.88,5.99
+3VALW on BOTTOM (solid shape): 136.23,9 136.23,7.42 135.74,6.93 135.65,6.93 135.53,7.05 135.53,8.96 135.61,9.04 136.2,9.04
+3VALW on BOTTOM (solid shape): 152.67,43.18 152.67,41.93 152.55,41.81 151.13,41.81 151,41.94 151,43.18 151.14,43.32 152.54,43.32
+3VALW on BOTTOM (solid shape): 133.21,9.97 133.21,9.28 133.05,9.12 132.57,9.12 132.46,9.01 132.46,8.88 132.37,8.8 132.24,8.8 132.17,8.86 132.17,10.01 132.36,10.19 132.99,10.19
+3VALW on BOTTOM (solid shape): 61.61,10.47 61.61,10.45 61.62,10.35 61.67,10.27 61.67,9.72 61.6,9.66 60.25,9.66 60.17,9.73 60.17,10.56 60.27,10.65 61.44,10.65
+3VALW on BOTTOM (solid shape): 282.16,37.99 282.16,37.09 282.1,37.03 281.38,37.03 281.26,37.15 280.42,37.15 280.37,37.2 280.37,37.37 280.44,37.43 281.07,37.43 281.71,38.07 282.08,38.07
+3VALW on BOTTOM (solid shape): 163.39,9.19 163.39,8.73 163.52,8.6 163.52,7.59 163.03,7.1 163.03,6.21 162.95,6.13 162.15,6.13 162.11,6.17 161.94,6.34 161.94,7.29 162.11,7.46 162.11,8.33 162.91,9.13 162.91,9.2 162.93,9.22 163.36,9.22
+3VALW on BOTTOM (solid shape): 51.88,40.5 51.88,39.63 51.75,39.5 50.54,39.5 50.54,38.95 50.15,38.95 50.15,39.5 49.37,39.5 49.32,39.45 49.32,38.97 47.66,38.97 47.44,39.2 47.44,41.31 48.3,42.17 50.21,42.17
+3VALW on BOTTOM (solid shape): 46.82,55.14 46.82,53.4 46.68,53.25 43.71,53.25 43.38,53.58 43.38,54.53 43.47,54.61 44.18,54.61 44.56,54.99 45.23,54.99 45.38,54.84 45.39,54.84 45.48,54.75 45.48,54.2 45.53,54.15 45.7,54.15 45.74,54.2 45.74,55.03 45.98,55.26 46.7,55.26
+3VALW on BOTTOM (solid shape): 22.63,9.98 23.76,9.98 23.83,9.91 23.83,9.34 23.78,9.29 22.67,9.29 22.03,9.93 22.03,9.93 21.79,10.16 21.62,10.16 21.59,10.2 21.05,10.2 21.02,10.16 20.91,10.16 20.84,10.1 20.84,9.16 20.76,9.07 20.58,9.07 20.49,9.16 20.49,10.36 20.59,10.46 21.14,10.46 21.19,10.51 22.1,10.51
+3VALW on BOTTOM (solid shape): 5.58,25.72 5.9,25.72 6.29,25.33 6.29,23.36 6.2,23.25 6.16,23.13 4.62,23.13 4.43,22.93 4.43,22.61 4.22,22.4 3.62,22.4 3.47,22.55 3.47,23.9 3.66,24.09 3.66,25.23 3.64,25.25 3.64,25.42 3.94,25.72 3.96,25.72 4.03,25.79 5.51,25.79
+3VALW on BOTTOM (solid shape): 3.9,17.09 3.9,14.88 3.67,14.65 3.67,13.69 3.43,13.44 2.76,13.44 2.7,13.39 2.51,13.39 2.37,13.52 2.37,14.17 2.46,14.41 2.37,14.64 2.37,16.91 2.71,17.25 3.74,17.25
+3VALW on BOTTOM (solid shape): 166.43,9.29 166.43,9.28 166.71,8.99 166.71,8.17 166.69,8.15 166.69,7.99 166.5,7.79 165.85,7.79 165.79,7.74 165.79,6.97 165.79,6.97 165.79,6.43 165.54,6.17 164.49,6.17 164.45,6.21 164.45,6.42 164.5,6.47 165.2,6.47 165.43,6.7 165.43,7.03 165.19,7.27 165.19,8.28 165.2,8.29 165.69,8.29 165.75,8.35 165.75,9.33 165.93,9.51 166.21,9.51
+3VALW on BOTTOM (solid shape): 10.69,15.85 10.7,15.8 10.65,15.76 10.53,15.76 10.28,15.51 10.28,15.16 10.66,14.78 10.74,14.78 11.22,14.3 11.22,13.06 11.34,12.94 11.6,12.94 11.61,12.93 11.88,12.93 11.98,12.83 11.98,12.28 11.91,12.21 11.28,12.21 10.96,11.89 10.07,11.89 9.41,12.56 9.41,12.87 8.9,13.37 8.9,14.93 9.89,15.92 10.62,15.92
+3VALW on IN1 (solid shape): 4.04,24.27 4.04,22.6 3.83,22.4 3.63,22.4 3.49,22.54 3.49,24.23 3.58,24.32 3.98,24.32
+3VALW on IN1 (solid shape): 60.21,5.71 60.21,5.59 60.16,5.54 59.81,5.54 59.65,5.7 52.86,5.7 52.67,5.89 52.67,6 52.71,6.05 59.87,6.05
+3VALW on IN1 (solid shape): 151.06,40.72 151.06,40.34 151.64,39.76 151.64,39.68 151.42,39.46 150.93,39.46 150.41,39.99 150.41,40.72 150.54,40.85 150.93,40.85
+3VALW on IN1 (solid shape): 157.79,34.83 158.9,34.83 159.18,34.56 159.18,32.43 159.11,32.35 158.78,32.35 158.19,32.94 158.19,33.76 157.33,34.62 157.33,35.08 157.44,35.18
+3VALW on IN1 (solid shape): 285.89,18.32 285.89,17.75 285.8,17.66 284.87,17.66 284.85,17.66 284.73,17.69 284.6,17.65 284.48,17.69 284.35,17.66 284.34,17.66 284.1,17.66 283.72,18.03 282.53,18.03 282.36,18.21 282.36,18.5 282.51,18.65 285.56,18.65
+3VALW on GND1 (solid shape): 151.79,41.37 151.79,41.21 151.17,40.59 150.56,40.59 150.48,40.66 150.48,40.79 151.18,41.5 151.67,41.5
+3VALW on GND1 (solid shape): 253.55,10.91 253.55,10.38 253.35,10.17 252.4,10.17 252.31,10.26 252.31,10.89 252.44,11.03 253.44,11.03
+3VALW on GND1 (solid shape): 159.41,34.81 159.41,32.6 159.2,32.39 158.83,32.39 158.67,32.54 158.67,34.79 158.79,34.91 159.31,34.91
+3VALW on GND3 (solid shape): 151.89,42.25 151.89,41.19 151.78,41.08 151.48,41.08 151.3,41.26 151.3,41.57 151.05,41.83 151.05,42.3 151.12,42.37 151.77,42.37
+3VALW on IN4 (solid shape): 132.98,9.18 136.02,9.18 136.11,9.08 136.11,8.73 135.99,8.61 132.54,8.61 132.15,9 132.15,9.22 132.29,9.35 132.81,9.35
+3VALW on IN4 (solid shape): outline of 141 points within 20.65,22.14 31.33,24.73
+3VALW on VCC: outline of 169 points within 1.27,1.27 289.17,74.73
+3VALWP on TOP (solid shape): 54.8,36.33 54.8,35.72 54.6,35.52 53.46,35.52 53.25,35.72 53.25,36.56 53.38,36.68 54.45,36.68
+3VALWP on TOP (solid shape): 47.94,37.28 47.94,36.28 47.8,36.13 46.9,36.13 46.75,36.28 46.75,37.27 46.95,37.46 47.76,37.46
+3VALWP on BOTTOM (solid shape): 50.01,38.77 50.71,38.77 50.71,39.32 51.21,39.32 51.21,38.77 51.79,38.77 51.87,38.69 52.77,38.69 53.05,38.41 53.77,38.41 53.94,38.24 53.94,36.7 54.19,36.45 54.77,36.45 54.85,36.37 54.85,35.56 54.71,35.42 53.97,35.42 53.38,34.83 53.38,34.58 53.02,34.22 48.73,34.22 48.48,34.47 48.48,35.31 47.81,35.97 47.06,35.97 46.84,36.19 46.84,38 47.61,38.77 49.51,38.77 49.51,39.32 50.01,39.32
+3VLP on TOP (solid shape): 159.41,9.01 159.41,8.6 158.36,7.55 157.75,7.55 157.57,7.73 157.57,8.11 158.56,9.1 159.32,9.1
+3VLP on BOTTOM (solid shape): 50.43,28.79 50.43,27.95 50.35,27.87 49.79,27.87 49.57,28.1 48.4,28.1 48.25,28.25 47.61,28.25 47.54,28.33 47.54,29.21 50.01,29.21
+3VLP on BOTTOM (solid shape): 250.43,11.19 250.43,8.4 249.87,7.84 246.05,7.84 245.29,8.6 245.29,8.8 249.76,8.8 249.76,10.35 246.15,10.35 246.15,8.8 245.29,8.8 245.29,10.38 245.49,10.58 247.69,11.08 248.41,11.33 248.8,11.33 249.01,11.54 249.19,11.6 250.03,11.6
+3VS on TOP (solid shape): 32.72,58.1 32.72,56.6 32.52,56.39 31.48,56.39 31.21,56.66 31.21,57.85 31.56,58.2 32.63,58.2
+3VS on TOP (solid shape): 151.12,48.03 151.12,47.7 151.02,47.6 148.81,47.6 148.71,47.7 148.71,48.17 148.79,48.25 150.89,48.25
+3VS on TOP (solid shape): 20.36,57.11 20.36,55.55 20.23,55.43 19.5,55.43 19.34,55.58 19.34,57.23 19.6,57.49 19.98,57.49
+3VS on TOP (solid shape): 33.24,6.46 33.24,5.46 32.85,5.07 31.24,5.07 31.1,5.2 31.1,6.44 31.36,6.69 33,6.69
+3VS on TOP (solid shape): 137.7,68.71 137.7,66.21 137.59,66.11 137.07,66.11 136.88,66.3 136.88,66.95 136.57,67.26 135.58,67.26 135.49,67.35 135.49,68.87 135.53,68.91 137.49,68.91
+3VS on TOP (solid shape): 260.8,8.24 260.8,4.66 260.54,4.4 259.32,4.4 259.07,4.66 259.07,8.26 259.4,8.59 260.44,8.59
+3VS on TOP (solid shape): 219.22,8.26 219.22,7.7 219.4,7.52 219.4,6.25 219.3,6.15 218.23,6.15 218.07,6.31 218.07,8.02 218.36,8.31 218.61,8.31 218.63,8.34 219.14,8.34
+3VS on TOP (solid shape): 142.52,40.78 142.52,40.22 141.61,39.31 141.61,38.67 141.56,38.63 141.27,38.63 141.14,38.76 141.14,39.92 140.98,40.08 139.59,40.08 139.52,40.15 139.52,40.63 139.56,40.67 141.94,40.67 142.21,40.94 142.36,40.94
+3VS on TOP (solid shape): 32.53,43.01 33.37,42.17 33.42,42.17 33.51,42.15 33.6,42.17 33.88,42.17 33.99,42.05 33.99,42.04 34.14,41.89 34.14,41.18 34.06,41.1 32.68,41.1 31.22,42.55 31.22,43.46 31.53,43.78 32.53,43.78
+3VS on TOP (solid shape): 145.92,54.5 145.92,51.87 145.45,51.39 142.67,51.39 142.5,51.56 142.5,51.91 142.38,52.03 141.76,52.03 141.66,52.13 141.66,52.64 141.7,52.68 143.21,52.68 144.61,54.08 144.61,54.42 144.94,54.75 145.67,54.75
+3VS on TOP (solid shape): 36.31,24.22 36.31,22.56 36.31,22.56 36.31,22.3 35.91,21.9 35.91,18.41 35.58,18.08 34.96,18.08 34.22,18.82 34.22,19.48 34.22,19.48 34.22,19.71 34.27,19.75 34.41,20 34.25,20.25 34.22,20.26 34.22,21.89 34.78,22.45 34.78,22.52 34.78,23.9 35.27,24.39 36.15,24.39
+3VS on TOP (solid shape): outline of 302 points within 265.5,36.35 295.77,43.44
+3VS on BOTTOM (solid shape): 11.55,6.13 11.55,4.96 11.34,4.76 10.81,4.76 10.25,5.32 10.25,6.18 10.38,6.31 11.37,6.31
+3VS on BOTTOM (solid shape): 31.9,58.29 31.9,57.57 31.84,57.51 29.27,57.51 29.15,57.63 29.15,58.39 29.28,58.52 29.55,58.52 29.55,58.53 31.66,58.53
+3VS on BOTTOM (solid shape): 145.3,58.67 145.3,58.61 145.69,58.22 145.69,58.12 145.37,57.8 145.37,57.49 145.28,57.4 144.69,57.4 144.63,57.46 144.63,58.84 144.7,58.91 145.06,58.91
+3VS on BOTTOM (solid shape): 293.19,28.32 293.19,27.85 290.3,24.96 288.58,24.96 288.25,25.29 288.25,25.93 289.02,26.69 289.68,26.69 290.48,27.49 290.48,28.02 290.63,28.17 292.12,28.17 292.55,28.6 292.91,28.6
+3VS on BOTTOM (solid shape): 20.36,10.06 20.36,8.59 20.65,8.31 23.96,8.31 24.17,8.1 24.17,7.54 24.04,7.41 21.88,7.41 21.44,6.98 20.5,6.98 20.01,7.47 20.01,10.04 20.09,10.11 20.31,10.11
+3VS on BOTTOM (solid shape): 293.73,38.5 294.58,38.39 295.44,38.48 295.46,38.48 295.52,38.43 295.52,36.77 295.43,36.68 293.62,36.68 293.53,36.78 293.53,38.32 293.71,38.5
+3VS on BOTTOM (solid shape): 157.33,17.5 157.33,16.18 157.74,15.78 159.57,15.78 159.83,15.52 159.83,10.29 161,9.12 161,8.69 160.97,8.66 160.34,8.66 159.62,9.39 159.58,9.39 159.4,9.46 159.22,9.39 158.16,9.39 158.03,9.52 158.03,10.07 158.74,10.78 158.74,14.56 158.43,14.87 156.86,14.87 156.38,15.35 156.38,16.45 156.41,16.47 156.41,16.78 156.38,16.8 156.38,17.65 156.57,17.84 156.99,17.84
+3VS on BOTTOM (solid shape): 147.41,55.03 147.41,54.59 147.35,54.54 146.37,54.54 146.3,54.62 145.67,54.62 145.57,54.51 145.57,54.26 145.57,54.04 146.03,53.58 146.03,52.98 145.93,52.88 145.48,52.88 145.4,52.96 145.4,53.32 144.73,53.99 144.73,54.32 144.43,54.62 143.92,54.62 143.88,54.58 143.87,54.57 143.77,54.5 143.69,54.4 143.69,54.39 143.64,54.33 143.64,53.25 144.58,52.31 145.7,52.31 146.51,51.5 146.51,48.13 146.47,48.09 145.71,48.09 145.58,48.22 145.58,50.88 145.45,51.01 144.82,51.01 144.69,51.14 143.04,51.14 142.8,51.38 142.8,51.53 142.58,51.74 142.58,52.27 142.3,52.55 141.93,52.55 141.75,52.73 141.75,53.65 141.86,53.76 142.14,53.76 142.4,53.49 142.95,53.49 143.05,53.59 143.05,54.91 143.32,55.18 147.26,55.18
+3VS on IN1 (solid shape): 150.03,61.47 150.03,61.25 149.14,60.36 148.91,60.36 148.53,60.74 148.53,60.89 149.24,61.6 149.9,61.6
+3VS on IN1 (solid shape): 32.55,58.61 32.55,57.36 32.04,56.85 31.54,56.85 29.22,59.16 28.61,59.16 28.58,59.19 23.59,59.19 20.99,56.6 19.56,56.6 19.34,56.82 19.34,58.12 21.61,60.39 25.76,60.39 25.78,60.4 30.76,60.4
+3VS on IN1 (solid shape): outline of 212 points within 141.7,54.11 145.7,63.63
+3VS on IN3 (solid shape): 22.6,7.26 22.6,6.94 22.2,6.54 21.05,6.54 20.95,6.64 20.95,6.97 21.05,7.06 21.96,7.06 22.28,7.38 22.48,7.38
+3VS on GND3 (solid shape): 31.92,58.2 31.92,57.39 31.84,57.31 30.77,57.31 30.67,57.41 30.67,58.15 30.8,58.27 31.84,58.27
+3VS on GND3 (solid shape): 22.18,8.09 23.73,8.09 23.92,7.9 23.92,7.65 23.4,7.13 23.4,6.64 23.17,6.42 21.35,6.42 20.96,6.8 20.96,7.97 21.21,8.22 22.05,8.22
+3VS on IN4 (solid shape): 157.24,17.56 157.1,17.42 156.46,17.42 156.37,17.51 156.37,18.67 156.68,18.98 157.24,18.98
+3VS on IN4 (solid shape): 295.49,38.2 295.49,37.79 295.49,37.78 295.49,36.26 295.25,36.03 294.24,36.03 294,36.28 294,38.11 294.29,38.4 295.29,38.4
+3VS on IN4 (solid shape): 294.75,30.03 294.75,28.38 294.27,27.9 292.69,27.9 292.53,28.06 292.53,28.73 292.74,28.95 293.53,28.95 293.99,29.4 293.99,30.17 294.62,30.17
+3VS on GND1: 35.23,23.57 35.04,23.76 35.04,23.94 34.91,24.06 34.91,35.72 34.7,35.94 34.7,39.09 33.63,40.15 33.63,41.26 33.4,41.49 33.4,41.72 33.62,41.94 34.47,41.94 36.54,39.87 36.54,38.99 38.36,37.18 38.36,27.35 37.8,26.79 37.8,24.69 37.67,24.56 37.67,24.38 36.86,23.57
+3VS on GND1: outline of 130 points within 21.68,2 274.8,40.35
+3VS_CAM on BOTTOM (solid shape): 285.14,28.84 285.14,27.69 285.05,27.6 282.24,27.6 281.61,26.97 281.61,26.59 281.61,26.59 281.61,24.75 281.6,24.75 281.6,24.71 280.21,23.31 278.25,23.31 278.15,23.41 278.15,23.57 278.21,23.62 279.41,23.62 280.38,24.59 280.38,27.85 280.45,27.92 281.4,27.92 281.54,28.06 281.54,28.3 281.54,28.3 281.54,28.57 281.85,28.89 285.1,28.89
+3VS_CR on BOTTOM (solid shape): 284.62,34.11 284.62,33.43 284.76,33.29 285.97,33.29 286.04,33.36 286.83,33.36 286.88,33.31 286.88,33.2 286.83,33.15 285.71,33.15 285.2,32.64 283.71,32.64 283.71,34.49 283.86,34.64 284.09,34.64
+3VS_CR on BOTTOM (solid shape): 292.85,37.62 292.85,36.65 292.9,36.6 292.9,34.96 292.7,34.76 292.7,33.73 292.59,33.62 291.94,33.62 291.86,33.69 291.81,33.77 291.72,33.83 291.27,34.28 291,34.28 290.93,34.35 290.11,34.35 290.08,34.37 290.08,34.5 290.13,34.55 290.98,34.55 291,34.53 291.01,34.53 291.04,34.49 291.34,34.49 291.41,34.49 291.47,34.49 291.65,34.49 291.76,34.61 291.76,34.61 291.86,34.71 291.86,37.46 292.06,37.65 292.81,37.65
+3VS_CR on IN4 (solid shape): outline of 95 points within 282.09,34.03 285.53,38.96
+3VS_CR on IN4 (solid shape): outline of 101 points within 291.3,32.12 293.49,36.84
+3VS_FP on TOP (solid shape): 263.18,7.19 263.18,6.21 263.06,6.09 261.56,6.09 261.43,6.23 261.43,7.24 261.52,7.33 263.04,7.33
+3VS_FP on BOTTOM (solid shape): 281.77,8.05 280.15,6.43 279.01,6.43 278.9,6.53 278.9,6.84 278.94,6.88 278.94,7.69 279.08,7.83 280.65,7.83 281.08,8.26 281.08,8.68 281.16,8.76 281.77,8.76
+3VS_FP on IN4 (solid shape): 281.47,8.56 281.47,8 280.84,7.37 280.46,7.37 280.24,7.58 280.24,7.75 281.21,8.72 281.31,8.72
+3VS_FP on IN4 (solid shape): outline of 650 points within 263.44,6.27 275.64,10.78
+3VS_MUX on TOP (solid shape): 267.91,23.73 267.91,23.6 267.88,23.58 266.46,23.58 266.1,23.22 265.71,23.22 265.67,23.26 265.67,23.63 265.7,23.65 266.14,23.65 266.26,23.78 267.86,23.78
+3VS_MUX on TOP (solid shape): 269.15,30.84 269.15,30.31 269.12,30.27 268.71,30.27 268.29,29.85 268.29,29.19 268.21,29.12 267.72,29.12 267.37,28.77 267.37,27.74 267.3,27.67 266.71,27.67 266.59,27.79 266.59,28.31 266.24,28.65 266.24,29.43 266.41,29.6 267.35,29.6 267.53,29.78 267.53,30.63 267.77,30.87 269.13,30.87
+3VS_MUX on TOP (solid shape): 275.76,29.48 275.76,27.53 275.73,27.5 275.35,27.5 275.07,27.22 275.07,26.18 274.45,25.56 273.14,25.56 273.12,25.58 273.12,25.76 273.15,25.8 273.86,25.8 274.04,25.99 274.04,27.22 274.08,27.36 274.04,27.5 274.04,28.36 274.36,28.67 274.36,29.59 274.51,29.74 275.5,29.74
+3VS_MUX on TOP (solid shape): 273.13,22.67 273.15,22.66 273.18,22.65 273.87,21.96 275.33,21.96 275.33,21.42 275.29,21.38 275.02,21.38 274.92,21.28 274.92,20.45 275.07,20.3 275.07,17.84 275.02,17.79 274.59,17.79 274.55,17.82 274.55,19.18 274.36,19.37 274.36,20.27 273.05,21.57 273.05,21.58 272.85,21.78 272.68,21.78 272.61,21.85 272.61,22.61 272.66,22.67
+3VS_MUX on BOTTOM (solid shape): 274.03,28.59 274.03,24.71 274.46,24.29 277,24.29 277.43,23.86 277.43,21.66 277.29,21.53 266.49,21.53 265.8,22.22 265.8,22.87 266.1,23.17 267.23,23.17 267.9,22.5 272.49,22.5 272.95,22.96 272.95,24.11 272.95,24.12 272.99,24.28 272.95,24.44 272.95,24.45 272.95,27.29 272.97,27.32 272.98,27.36 273.03,27.42 273.1,27.43 273.53,27.77 273.11,28.13 273.04,28.14 273,28.2 272.98,28.25 272.95,28.3 272.95,28.58 273.09,28.73 273.9,28.73
+3VS_MUX_L on TOP (solid shape): 267.31,30.4 267.31,29.78 267.3,29.76 266.3,29.76 265.98,29.45 265.98,29.03 265.89,28.94 265.29,28.94 265.21,29.02 265.21,29.78 265.22,29.85 265.22,30.4 265.24,30.42 267.29,30.42
+3VS_NGFF on TOP (solid shape): 272.12,44.71 272.12,42.51 271.95,42.34 270.4,42.34 270.27,42.47 270.27,43.72 270.39,43.84 270.39,44.75 270.47,44.83 272,44.83
+3VS_NGFF on BOTTOM (solid shape): outline of 233 points within 265.44,39.98 272.17,56.26
+3VS_NGFF on GND1 (solid shape): 271.86,42.46 271.86,41.87 271.58,41.59 271.12,41.59 270.65,42.06 270.65,42.56 270.73,42.65 271.67,42.65
+3VS_NGFF on GND3 (solid shape): 271.95,42.22 271.95,41.63 271.63,41.31 271.11,41.31 271.04,41.38 271.04,42.31 271.17,42.45 271.73,42.45
+3VS_NGFF on IN4 (solid shape): 272.97,55.04 276.55,55.04 276.92,54.68 285.4,54.68 285.63,54.91 286.07,54.91 286.15,54.82 286.15,54.36 285.9,54.11 276.61,54.11 276.23,54.48 272.66,54.48 271.53,55.61 271.53,55.88 271.66,56.01 272.01,56.01
+3VS_NGFF_IN+ on TOP (solid shape): 269.86,46.26 269.86,44.89 269.74,44.76 269.74,43.88 269.65,43.79 269.05,43.79 268.85,44 268.85,46.38 268.95,46.48 269.64,46.48
+3VS_PWRM on TOP (solid shape): 172.08,21.9 172.08,20.83 172.5,20.41 172.5,20.29 172.41,20.2 172.2,20.2 172.12,20.27 171.75,20.27 171.42,19.94 171.42,19.87 171.41,19.78 171.42,19.7 171.42,18.3 170.83,18.3 170.77,18.36 170.77,20.71 170.77,20.72 170.77,20.89 170.58,21.08 170.05,21.08 169.83,21.3 169.83,22.03 169.91,22.12 171.87,22.12
+3VS_TP on BOTTOM (solid shape): 177.76,11.04 177.76,9.63 177.65,9.52 176.52,9.52 176.37,9.68 176.37,11.03 176.49,11.15 177.65,11.15
+3VS_TPM on BOTTOM (solid shape): 176.37,13.29 176.37,12.94 176.3,12.87 175.34,12.87 175.2,13.01 173.95,13.01 173.9,13.07 173.9,13.21 173.95,13.27 175.12,13.27 175.21,13.36 176.3,13.36
+3VS_TPM on BOTTOM (solid shape): 175.11,17.64 175.11,17.24 175.11,17.23 175.11,16.57 174.88,16.35 174.47,16.35 174.18,16.64 174.18,17.35 173.51,18.02 172.89,18.02 172.77,17.9 172.77,17.44 172.66,17.34 172.66,16.11 172.67,16.1 172.56,16 172.51,16 172.43,16.07 172.43,16.95 172.29,17.1 172.29,18.98 172.33,19.02 173.73,19.02
+3VS_TS on BOTTOM (solid shape): 49.71,62.41 49.71,60.52 50.08,60.15 50.08,55.78 49.08,54.78 49.08,54.17 49.28,53.98 51.52,53.98 51.76,53.74 51.76,53.49 51.61,53.33 48.92,53.33 48.46,53.79 48.46,56.26 49.03,56.82 49.03,58.06 49.43,58.46 49.43,60.52 49.45,60.54 49.45,62.39 49.5,62.45 49.67,62.45
+5VALW on TOP (solid shape): 151.91,10.08 151.91,9.09 151.79,8.98 151.42,8.98 150.58,9.82 150.58,10.13 150.72,10.27 150.73,10.27 150.88,10.22 151.03,10.27 151.22,10.27 151.35,10.39 151.6,10.39
+5VALW on TOP (solid shape): 221.99,8.75 221.99,8.67 221.93,8.62 221.22,8.62 221.2,8.59 221.2,8.44 221.22,8.41 221.93,8.41 221.99,8.36 221.99,7.99 221.99,6.92 221.83,6.76 221.2,6.76 220.92,6.48 220.92,5.35 220.73,5.16 219.79,5.16 219.68,5.27 219.68,7.05 220.21,7.58 220.21,8.77 220.28,8.85 221.89,8.85
+5VALW on TOP (solid shape): 220.87,11.86 220.87,11.62 221.25,11.24 221.25,10.88 221.3,10.83 221.93,10.83 221.99,10.78 221.99,10.68 221.93,10.62 221.25,10.62 221.2,10.57 221.2,10.45 221.22,10.42 221.93,10.42 221.99,10.37 221.99,10.22 221.94,10.17 220.31,10.17 219.98,10.5 219.57,10.5 219.49,10.58 219.49,11.81 219.63,11.94 220.78,11.94
+5VALW on TOP (solid shape): 20.39,28.48 20.57,28.48 20.66,28.39 21.55,28.39 21.85,28.09 22.27,28.09 22.44,27.92 24.79,27.92 25.03,27.68 25.03,26.39 24.97,26.33 24.97,26.08 24.96,26.06 24.96,25.81 24.62,25.47 20.11,25.47 19.92,25.66 19.92,26.62 19.64,26.9 19.64,27.16 19.74,27.26 19.74,27.92 19.73,27.93 19.73,28.43 19.79,28.48 20.05,28.48 20.08,28.51 20.36,28.51
+5VALW on TOP (solid shape): 34.15,30.59 34.15,30.4 34.28,30.27 34.65,30.27 34.66,30.26 34.88,30.26 34.98,30.16 35.04,30.16 35.3,30.06 35.52,30.23 35.53,30.26 35.83,30.26 36.19,30.62 36.67,30.62 36.82,30.47 36.82,28.25 36.82,28.25 36.82,27.87 36.73,27.78 36.36,27.78 36.29,27.86 32.84,27.86 32.39,28.3 32.38,28.35 32.34,28.47 32.25,28.57 32.25,29.1 32.25,29.1 32.11,29.23 32.11,30.12 32.28,30.29 32.28,30.66 32.34,30.72 34.03,30.72
+5VALW on BOTTOM (solid shape): 22.46,9.15 23.79,9.15 23.85,9.09 23.85,8.51 23.8,8.45 21.43,8.45 21.02,8.86 21.02,9.36 21.02,9.36 21.02,9.99 21.11,10.07 21.53,10.07
+5VALW on BOTTOM (solid shape): 221.55,11.72 221.55,9.98 222.34,9.19 222.34,5.38 221.9,4.94 220.09,4.94 219.84,5.19 219.84,5.67 220.4,6.23 220.4,8.62 219.57,9.45 219.57,11.84 219.72,12 221.27,12
+5VALW on BOTTOM (solid shape): 292.66,16.8 292.66,11.05 292.49,10.88 291.42,10.88 291.41,10.89 291.24,10.89 290.88,11.25 290.88,13.43 290.62,13.7 289.96,13.7 289.85,13.8 289.85,15.37 289.96,15.48 290.37,15.48 291.32,16.42 291.32,16.89 291.55,17.13 292.33,17.13
+5VALW on BOTTOM (solid shape): 47.26,41.12 47.26,38.67 46.5,37.92 45.56,37.92 45.17,38.3 45.17,38.67 45.25,38.74 45.25,39.22 45.2,39.27 45.09,39.27 45.09,39.3 44.58,39.3 44.58,39.83 43.83,39.83 43.83,39.3 43.38,39.3 43.38,39.83 42.63,39.83 42.63,39.3 42.1,39.3 42.1,39.83 42.1,39.94 41.95,40.09 41.95,41.1 42.08,41.23 47.15,41.23
+5VALW on IN2 (solid shape): outline of 654 points within 17.34,23.96 36.74,30.72
+5VALW on IN3 (solid shape): outline of 148 points within 289.41,11.02 292.89,18.59
+5VALW on IN4 (solid shape): outline of 701 points within 17.15,24.33 32.61,30.46
+5VALW on VCC: 37.5,1.27 37.1,1.67 37.1,22.92 34.74,25.28 32.2,27.85 32.2,28.53 32.02,28.71 32.02,29.98 32.61,30.56 36.74,30.57 38.2,32.03 38.2,40.45 39.13,41.38 46.9,41.38 47.13,41.15 47.13,38.49 45.33,36.69 45.33,27.77 46.14,26.95 46.14,14.51 54.49,6.15 75.08,6.15 78.4,9.48 88.2,9.48 89.22,8.47 147.69,8.47 156.27,8.49 160.16,8.47 161.15,7.47 184.87,7.47 187.69,4.66 217.07,4.66 218.1,5.7 229.27,5.7 229.45,5.52 255.01,5.52 255.18,5.7 257.88,5.85 264.66,12.66 273.2,12.66 275.52,14.98 287.77,14.97 291.15,14.97 292.7,13.41 292.7,8.84 292.27,8.41 279.61,8.41 277.3,6.1 275.55,6.1 274.84,5.37 268.9,5.37 266.77,3.24 266.27,2.74 266.27,1.27 266.13,1.14 183.17,1.14 182.04,2.27 171.36,2.27 171.36,1.27 86.89,1.27 86.37,1.48 85.5,3.61 83.89,4.27 81.89,4.27 80.28,3.61 79.62,2 79.62,1.27
+5VALWP on TOP (solid shape): 41.19,37.53 41.19,33.33 40.84,32.98 40.02,32.98 39.94,33.06 39.94,33.93 39.41,34.46 39.41,37.8 39.66,38.06 40.66,38.06
+5VALWP on BOTTOM (solid shape): 43.25,39.17 43.95,39.17 43.95,39.71 44.45,39.71 44.45,39.17 44.96,39.17 44.96,33.63 44.75,33.42 39.4,33.42 38.6,34.22 38.6,39 38.77,39.17 42.75,39.17 42.75,39.71 43.25,39.71
+5VS on TOP (solid shape): 164.92,15.86 164.92,14.83 164.75,14.66 164.06,14.66 163.91,14.8 163.91,15.98 163.94,16.02 164.76,16.02
+5VS on TOP (solid shape): 228.29,10.74 228.29,5.8 228.72,5.37 228.72,5.03 228.6,4.91 227.76,4.91 227.19,5.48 227.19,9.49 227.39,9.71 227.28,9.99 227.19,10.03 227.08,10.04 226.65,10.47 226.28,10.47 226.24,10.51 226.24,11.39 226.2,11.42 225.67,11.42 225.34,11.75 225.34,12.26 225.38,12.31 226.73,12.31
+5VS on BOTTOM (solid shape): 58.56,48.85 58.56,48.11 57.7,47.25 56.25,47.25 56.12,47.38 56.12,47.48 56.22,47.58 57.29,47.58 57.88,48.17 57.88,48.88 57.9,48.9 58.51,48.9
+5VS on BOTTOM (solid shape): 63.4,58.92 63.4,57.41 62.83,56.84 61.93,56.84 61.89,56.88 61.89,57.5 61.98,57.59 62.37,57.59 63.1,58.31 63.1,58.87 63.22,59 63.32,59
+5VS on BOTTOM (solid shape): 265.85,6.64 265.85,4.48 265.84,4.47 265.84,4.29 265.74,4.19 264.38,4.19 264.1,4.48 264.1,5.72 263.51,6.31 263.03,6.31 262.96,6.38 262.96,6.76 263,6.81 265.68,6.81
+5VS on GND1 (solid shape): 65.17,40.94 65.17,40.31 65.07,40.21 64.44,40.21 64.33,40.11 63.91,40.11 63.73,40.29 63.73,40.76 63.96,40.99 65.11,40.99
+5VS on GND1 (solid shape): 164.87,14.94 164.87,14.3 164.59,14.03 163.9,14.03 163.8,13.93 163.69,13.93 163.38,14.24 163.38,14.67 163.59,14.88 164.1,14.88 164.31,15.09 164.72,15.09
+5VS on IN4 (solid shape): 212.06,7 212.06,6.35 211.54,5.83 210.52,5.83 210.42,5.93 210.42,6.3 211.36,7.25 211.81,7.25
+5VS on IN4 (solid shape): 255.94,6.84 255.94,6.48 254.92,5.45 253.38,5.45 253.23,5.61 253.23,6.13 253.31,6.21 254.59,6.21 255.33,6.94 255.84,6.94
+5VS on IN4 (solid shape): 264.52,5.51 264.52,5.28 264.51,5.27 264.51,5.07 264.33,4.88 263.2,4.88 263.07,5.01 263.07,5.51 263.15,5.58 264.44,5.58
+5VS on IN4 (solid shape): 230.91,5.65 230.91,5.18 230.6,4.87 227.87,4.87 227.85,4.89 227,4.89 226.37,5.52 226.37,5.94 226.45,6.02 230.54,6.02
+5VS on BOTTOM: 211.8,5.05 212.03,4.82 212.03,4.13 212.07,4.1 212.07,3.91 212.26,3.91 212.36,3.8 212.89,3.8 213.12,3.56 213.12,1.72 212.85,1.45 211.66,1.45 211.41,1.71 211.41,2.66 211.11,2.95 211.11,3.89 210.8,4.21 210.8,4.97 210.78,4.98 210.78,5 210.77,5 209.89,5.88 209.89,6.7 209.81,6.77 209.55,6.77 209.29,7.03 209.29,10.38 209.44,10.54 210.67,10.54 210.83,10.37 210.83,6.45 211.62,5.66 211.62,5.5 211.55,5.22 211.78,5.05
+5VS_AUDIO on TOP (solid shape): 279.71,43.04 279.71,40.98 279.54,40.81 279.31,40.81 278.86,41.26 278.86,43.19 278.96,43.29 279.47,43.29
+5VS_AUDIO on TOP (solid shape): 226.74,8.38 226.98,8.14 226.98,6.63 226.76,6.4 225.83,6.4 225.79,6.45 225.79,6.98 226.15,7.35 226.15,8.29 226.24,8.38
+5VS_AUDIO on BOTTOM (solid shape): 273.22,30.79 273.22,30.29 273.08,30.15 271.99,30.15 271.88,30.26 271.88,30.77 272.28,30.95 273.07,30.95
+5VS_AUDIO on BOTTOM (solid shape): 277.9,32.69 277.9,31.99 277.79,31.88 276.74,31.88 276.44,32.19 276.44,32.59 276.62,32.77 277.82,32.77
+5VS_AUDIO on IN1 (solid shape): 228.44,7.5 228.44,7.32 228.06,6.93 227.88,6.93 227.42,7.39 227.02,7.39 226.38,8.03 226.38,8.26 226.6,8.48 227.47,8.48
+5VS_AUDIO on IN1 (solid shape): 263.17,14.06 263.17,13.56 263.04,13.35 263.17,13.12 263.17,12.71 262.88,12.43 262.35,12.43 262.26,12.53 262.26,13.83 262.57,14.15 263.09,14.15
+5VS_AUDIO on GND1 (solid shape): 263.06,14.79 263.06,13.73 262.92,13.6 262.67,13.6 262.5,13.77 262.5,14.02 261.77,14.75 261.77,14.99 261.88,15.09 262.75,15.09
+5VS_AUDIO on IN4 (solid shape): 263.11,16.27 263.11,15.3 262.88,15.06 262.11,15.06 261.91,15.26 261.91,16.27 262.06,16.42 262.96,16.42
+5VS_AUDIO on IN4 (solid shape): 279.69,41.68 279.69,39.85 279.57,39.73 278.9,39.73 278.8,39.82 278.8,41.4 279.28,41.87 279.5,41.87
+5VS_AUDIO on IN4 (solid shape): 272.85,30.85 272.85,30.3 272.7,30.15 271.29,30.15 271.17,30.27 271.17,30.75 271.36,30.94 272.76,30.94
+5VS_AUDIO on IN4 (solid shape): 278.88,32.77 278.88,32.04 278.76,31.92 277.67,31.92 277.61,31.98 277.61,32.72 277.79,32.9 278.48,32.9 278.49,32.91 278.74,32.91
+8.4V_BATT+ on TOP (solid shape): 82.69,11.75 82.69,10.95 82.02,10.28 78.19,10.28 78.1,10.38 78.1,11.82 78.53,12.26 82.18,12.26
+8.4V_BATT+ on BOTTOM (solid shape): 82.37,14.83 82.37,14.5 82.73,14.14 83.64,14.14 83.76,14.02 83.76,12.02 82.05,10.31 78.13,10.31 78.08,10.36 78.08,12.53 78.78,13.23 80.75,13.23 80.86,13.34 80.86,13.8 80.77,13.89 79.44,13.89 79.25,14.08 79.25,14.68 79.71,15.13 82.07,15.13
+AVDD1 on TOP (solid shape): 282.1,56.47 281.47,55.84 278.39,55.84 278.31,55.92 278.31,56.84 280.8,56.84 281.26,57.3 281.26,58.02 281.09,58.2 279.09,58.2 279.09,58.62 279.26,58.79 279.36,58.79 279.68,58.88 279.79,59.19 280.08,59.49 282.1,59.49
+AVDD1 on BOTTOM (solid shape): 277.76,59.21 277.76,58.02 278.13,57.65 278.13,57.55 278.07,57.49 277.95,57.49 277.59,57.85 277.59,58.32 277.56,58.35 277.56,59.21 277.61,59.27 277.71,59.27
+AVDD2 on BOTTOM (solid shape): 277.81,66.48 277.81,65.95 277.79,65.92 277.56,65.92 277.36,65.72 277.36,64.52 277.31,64.47 277.2,64.47 277.15,64.52 277.15,65.9 277.18,65.93 277.18,66.53 277.2,66.55 277.74,66.55
+DVDD on TOP (solid shape): 268.21,11.15 268.98,11.15 269.04,11.08 269.04,11 268.99,10.94 268.12,10.94 267.99,11.07 267.81,11.07 267.73,11.08 267.65,11.07 267.48,11.07 267.35,11.2 267.35,11.63 267.73,11.63
+DVDD on BOTTOM (solid shape): 269.15,12.63 269.15,10.95 269.05,10.85 268.26,10.85 268.19,10.93 268.19,11.54 268.48,11.84 268.48,12.73 269.05,12.73
+DVDD on BOTTOM (solid shape): 270.17,61.86 270.17,60.94 270.43,60.68 272.25,60.68 272.46,60.59 272.67,60.68 272.85,60.68 272.95,60.59 273.98,60.59 274.06,60.51 274.06,60.41 274,60.36 272.99,60.36 272.74,60.11 272.71,60.08 272.68,60.05 272.4,59.77 268.8,59.77 268.24,60.33 268.24,61.68 268.47,61.91 270.12,61.91
+DVDDIO on TOP (solid shape): 276.37,66.17 276.37,65.69 276.24,65.56 274.93,65.56 274.77,65.4 274.77,64.55 274.53,64.31 273.69,64.31 273.68,64.32 273.55,64.32 273.47,64.4 273.47,64.93 273.6,65.06 273.6,66.09 273.88,66.37 276.16,66.37
+PVDD2 on BOTTOM (solid shape): 275.35,59.21 275.35,58.43 275.53,58.25 277,58.25 277.15,58.41 277.15,59.19 277.23,59.27 277.31,59.27 277.36,59.21 277.36,58.36 277.31,58.3 277.31,57.28 277.94,56.65 277.94,55.3 277.84,55.2 277.15,55.2 277.05,55.3 277.05,55.88 275.86,57.07 275.86,57.49 275.68,57.66 275.3,57.66 275.15,57.82 275.15,59.21 275.2,59.27 275.3,59.27
+PVDD2 on GND1 (solid shape): 274.47,56.02 275.22,56.02 275.28,55.95 275.28,55.58 275.22,55.51 274.06,55.51 273.91,55.66 273.91,56.26 274.02,56.37 274.12,56.37
+PVDD2 on IN4 (solid shape): outline of 129 points within 273.72,55.2 277.92,57.25
+V1.8S_EDRAM on TOP (solid shape): 101.36,62.56 101.56,62.35 101.56,61.87 101.42,61.73 101.25,61.73 101.15,61.84 101.15,62.18 100.79,62.54 100.72,62.54 100.72,62.83 100.72,62.84 100.72,63.41 101.36,63.41
+VBUS1_20V on TOP (solid shape): 39.84,20.45 39.84,18.66 39.59,18.42 38.37,18.42 37.92,18.87 37.92,19.21 37.47,19.66 37.47,20.47 37.56,20.56 39.72,20.56
+VBUS1_20V on BOTTOM (solid shape): 37.72,21.16 37.72,20.82 37.97,20.57 39.56,20.57 39.7,20.44 39.7,20.44 39.75,20.39 39.75,18.46 39.64,18.35 38.53,18.35 38.52,18.35 38.28,18.35 38.04,18.59 38.04,19.09 37.94,19.19 37.39,19.19 37.21,19.01 37.21,18.2 37.07,18.07 35.47,18.07 35.36,18.17 35.36,19.06 36.13,19.82 36.13,19.95 36.17,19.99 36.17,20.72 36.5,21.04 36.5,21.27 36.55,21.33 37.54,21.33
+VBUS1_PD_20V on TOP (solid shape): 6.49,48.06 7.76,48.06 7.89,47.93 7.89,47.8 7.76,47.68 6.37,47.68 6.14,47.9 5.48,47.9 5.35,48.03 5.35,48.18 5.43,48.26 6.29,48.26
+VBUS1_PD_20V on TOP (solid shape): 34.56,22.93 34.56,22.51 33.95,21.9 33.95,20.95 33.51,20.51 32.7,20.51 32.5,20.71 32.5,22.28 32.51,22.29 32.51,22.64 32.9,23.03 34.45,23.03
+VBUS1_PD_20V on TOP (solid shape): 6.98,45.57 7.76,45.57 7.89,45.44 7.89,45.28 7.76,45.15 7.05,45.15 6.77,45.43 6.67,45.43 6.55,45.45 6.43,45.43 5.46,45.43 5.35,45.54 5.35,45.62 5.48,45.75 6.21,45.75 6.35,45.88 6.66,45.88
+VBUS1_PD_20V on TOP (solid shape): 14.6,25.11 14.6,24.42 14.59,24.42 14.59,24.21 14.8,24.01 16.04,24.01 16.19,23.86 16.19,22.19 15.94,21.93 14.02,21.93 13.75,22.2 13.75,23 12.99,23.76 12.99,25.01 13.2,25.22 14.5,25.22
+VBUS1_PD_20V on TOP (solid shape): 8.17,41.51 8.25,41.46 8.26,41.37 8.35,41.07 8.66,41.07 8.69,41.1 9.3,40.49 9.33,40.45 9.35,40.42 9.35,39.78 9.3,39.73 7.29,39.73 7,40.02 7,40.03 6.72,40.67 6.33,41.25 6.31,41.26 6.31,41.37 6.45,41.51
+VBUS1_PD_20V on BOTTOM (solid shape): 35.12,21.57 35.42,21.57 35.71,21.27 35.71,20 35.63,19.91 34.79,19.91 34.61,20.09 34.57,20.09 34.32,20.33 32.91,20.33 32.9,20.35 32.88,20.35 32.25,20.97 31.92,20.97 31.79,21.1 31.79,22.45 31.83,22.49 34.2,22.49
+VBUS1_PD_20V on BOTTOM (solid shape): 8.9,48.07 8.9,47.74 8.79,47.63 6.89,47.63 6.88,47.64 6.54,47.64 6.54,47.64 6.31,47.64 6.13,47.46 6.13,46.37 6.5,45.99 6.93,45.99 7.27,45.65 8.63,45.65 8.7,45.58 8.7,45.1 8.63,45.02 7.29,45.02 6.86,45.45 6.2,45.45 6.18,45.44 5.56,45.44 5.23,45.77 5.23,47.9 5.55,48.21 6.44,48.21 6.56,48.17 6.69,48.17 6.82,48.17 6.94,48.21 8.7,48.21 8.7,48.21 8.75,48.21
+VBUS1_PD_20V on BOTTOM (solid shape): 18.98,26.85 18.98,23.11 18.63,22.76 16.78,22.76 16.75,22.73 14.13,22.73 12.92,23.94 12.92,24.91 13.14,25.13 13.89,25.13 14.05,25.02 14.24,24.98 14.42,24.98 14.61,25.02 14.77,25.13 16.27,25.13 16.73,25.02 16.89,25.46 16.88,25.49 16.95,25.56 16.95,26.41 17.44,26.9 17.46,26.89 17.63,26.93 17.77,27.04 18.79,27.04
+VBUS1_PD_20V on GND1 (solid shape): 6.35,48.12 7.85,48.12 7.96,48 7.96,47.79 7.89,47.72 6.63,47.72 6.35,47.44 6.31,47.41 6.25,47.34 6.2,47.15 6.26,46.96 6.26,46.72 6.19,46.52 6.25,46.31 6.26,46.29 6.26,46.27 6.61,45.93 7.72,45.93 7.95,45.69 7.95,45.36 7.79,45.21 7.16,45.21 6.94,45.43 6.82,45.43 6.81,45.43 6.71,45.45 6.62,45.44 6.52,45.45 6.43,45.43 6.42,45.43 5.57,45.43 4.98,46.02 4.92,46.02 4.91,46.03 4.91,48.05 5.11,48.25 6.21,48.25
+VBUS1_PD_20V on IN3 (solid shape): outline of 274 points within 3.03,40.36 7.77,48.16
+VBUS1_PD_20V on GND3 (solid shape): 5.88,47.78 5.88,46.69 6.23,46.35 6.29,46.26 6.39,46.19 6.8,45.77 6.8,45.58 6.67,45.45 6.61,45.45 6.55,45.45 6.49,45.45 5.87,45.45 5.58,45.74 5.43,45.74 4.81,46.35 4.81,47.69 5.02,47.9 5.77,47.9
+VBUS1_PD_20V on VCC: 30.9,16.75 30.57,17.08 13.45,17.08 6.98,23.55 1.58,23.55 1.27,23.86 1.27,29.28 2,29.28 3.25,29.8 3.77,31.05 3.77,35.55 3.25,36.8 2,37.32 1.27,37.32 1.27,42.63 2,43.28 2.27,44.22 2.27,49.22 2.22,49.64 2.07,50.04 8.85,50.04 9.29,49.61 9.29,30.92 16.67,23.53 30.02,23.53 30.02,23.53 32.17,23.52 32.32,23.53 33.73,22.13 33.73,17.52 32.95,16.75
+VBUS2_20V on TOP (solid shape): 45.2,19.16 45.2,18.6 45.12,18.52 40.84,18.52 40.5,18.19 40.35,18.19 40.1,18.43 40.1,18.83 40.1,18.83 40.1,20.44 40.19,20.54 41.75,20.54 41.75,20.55 43.81,20.55
