# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VID0_EDRAM_VR: length 4.1
  TOP w0.095: v4(57.57,30.72) v2(56.53,30.72)
  GND1 w0.254: v3(57.57,31.1) v4(57.57,30.72)
  GND3 w0.254: v4(57.57,30.72) v3(57.57,31.1)
  BOTTOM w0.254: PU1500.9 58.05,31.89 57.57,31.41 v4(57.57,30.72)
VID0_EOPIO_VR: length 6.6
  BOTTOM w0.095: 68.47,32.63 67.58,32.63 v2(67.48,32.73)
  BOTTOM w0.254: PR1515.2 65.41,29.92 66.65,29.92 66.88,30.15 PR1518.1 67.07,30.46 68.02,31.41 68.02,32.19 68.47,32.63 PU1501.9
VID0_PRIM_CORE: length 6.6
  BOTTOM w0.095: v2(163.77,72.26) 163.77,71.61 PR1418.1
  BOTTOM w0.254: PR1418.1 162.93,71.71 161.56,71.71 PR1415.2 161.03,72.22 PR1419.2 160.64,72.24 160.27,71.88 PU1401.9
VID0_VCCIO: length 4.7
  BOTTOM w0.095: PR1405.2 167.2,56.76 167.69,56.76 v2(168.05,56.41)
  BOTTOM w0.254: PR1405.2 166.58,57.32 PR1407.1 165.26,56.46 164.87,56.07 PU1400.9
VID1_EDRAM_VR: length 3.3
  TOP w0.095: v4(58.46,30.72) v2(58.46,29.61)
  GND1 w0.254: v4(58.46,30.72) v3(58.46,31.08)
  GND3 w0.254: v3(58.46,31.08) 58.46,31.08 58.46,30.72 v4(58.46,30.72)
  BOTTOM w0.254: PU1500.8 58.85,31.49 58.46,31.09 v4(58.46,30.72)
VID1_EOPIO_VR: length 4
  BOTTOM w0.254: PU1501.8 69.57,31.5 69.31,31.25 68.61,31.25 67.79,30.43 PR1517.1 66.89,29.36 PR1514.2
VID1_PRIM_CORE: length 10.1
  BOTTOM w0.254: PR1417.1 164.37,73.67 v2(163.89,74.15) 163.44,74.6 161.54,74.6 161,74.05 PR1414.2 PR1420.2 160.39,73.16 160.21,73.33 159,73.33 158.82,73.16 PU1401.8
VID1_VCCIO: length 4.8
  BOTTOM w0.095: PR1406.1 v2(165.65,60.21)
  BOTTOM w0.254: PR1406.1 165.66,59.14 165.66,58.26 PR1404.2 165.66,58.23 164.75,57.32 163.75,57.32 163.5,57.07 PU1400.8
VIDSCLK_R: length 6.7
  TOP w0.127: RC159.1 99.33,69.66 v1(99.64,69.36)
  GND1 w0.127: v3(99.86,68.96) 99.64,69.18 v1(99.64,69.36)
  GND3 w0.127: v3(99.86,68.96) 99.86,69.3 v4(99.93,69.36)
  BOTTOM w0.076: v4(99.93,69.36) 99.93,69.17 100.12,68.98 100.22,68.98 100.34,69.1 100.45,69.1 100.56,68.99 100.56,68.88 100.44,68.76 100.44,68.65 100.55,68.55 100.66,68.55 100.77,68.67 100.88,68.67 100.99,68.56 v2(100.99,68.46) 100.99,68.45 100.87,68.33 100.87,68.22 101.83,67.27 UCPU1.A63
VIDSOUT_R: length 6.7
  BOTTOM w0.076: RC157.1 99.45,69.59 99.45,69.13 101.34,67.24 101.34,65.93 101.54,65.73 101.54,65.07 101.26,64.79 UCPU1.D64
VL:
  vias: v2(37.38,28.37)
VR_SVID_ALERT#: length 92
  TOP w0.203: v7(34.12,47.19) 35.08,47.19 PR1007.1
  IN1 w0.127: v7(34.12,47.19) 33.18,48.12 33.18,53.19 38.39,58.39 39.42,58.39 41.19,56.62 v9(48.83,56.62)
  GND1 w0.127: v9(48.83,56.62) v3(49.34,56.62)
  GND3 w0.127: v6(49.72,56.64) 49.7,56.62 v3(49.34,56.62)
  IN4 w0.076: v5(101.05,69.34) 101.05,69.28 100.79,69.01 99.63,69.01 99.39,69.25 98.47,69.25 96.21,66.98 92.85,66.98 90.27,64.41 86.89,64.41 84.91,66.38 79,66.38 78.68,66.71 61.62,66.71 61.08,67.25 55.84,67.25 51.97,63.38 51.97,62.38 50.46,60.87 50.46,59.65 50.05,59.24 50.05,58.18 50.14,58.09 50.14,57.06 v6(49.72,56.64)
  BOTTOM w0.076: v5(101.05,69.34) 101.32,69.61 101.32,70.57 RC155.2 100.71,71.18 RC154.2
VR_SVID_ALERT#_C: length 2.1
  TOP w0.203: PR1007.2 36.32,46.96 36.64,47.28 PU1000.44
VR_SVID_CLK: length 92.4
  TOP w0.127: v1(98.57,69.46) 98.42,69.61 RC159.2 98.42,71.01 RC158.2 98.43,71.42 98.8,71.79 v2(98.8,72.05)
  TOP w0.203: PR1008.1 34.47,46.08 PR1003.2 34.47,46.25 v7(34.12,46.61)
  IN1 w0.127: v9(48.55,57.34) 48.4,57.5 41.16,57.5 39.68,58.98 38.14,58.98 32.58,53.41 32.58,47.53 33.5,46.61 v7(34.12,46.61)
  GND1 w0.127: v3(98.38,68.91) 98.57,69.11 v1(98.57,69.46) ; v9(48.55,57.34) 48.67,57.23 v3(48.93,57.23)
  GND3 w0.127: v6(97.98,69.39) 98.38,69 v3(98.38,68.91) ; v6(49.3,57.19) 48.98,57.19 v3(48.93,57.23)
  IN4 w0.076: v6(49.3,57.19) 49.4,57.19 49.68,57.47 49.68,57.9 49.59,57.99 49.59,59.43 50,59.84 50,61.06 51.51,62.57 51.51,63.8 55.42,67.71 61.27,67.71 61.81,67.16 78.95,67.16 79.49,67.71 82.23,67.71 82.84,67.09 85.01,67.09 87.16,64.94 90.16,64.94 92.7,67.47 95.93,67.47 96.98,68.52 96.98,68.66 97.71,69.39 v6(97.98,69.39)
VR_SVID_CLK_C: length 2.2
  TOP w0.203: PU1000.45 37.28,46.88 36.51,46.11 36.26,46.11 PR1008.2
VR_SVID_DATA: length 92.1
  TOP w0.203: PR1005.1 35.17,47.71 PR1004.2 34.48,48.32 v7(34.16,48.64)
  IN1 w0.127: v9(48.78,56.04) 40.85,56.04 39.08,57.81 38.63,57.81 33.82,53 33.82,48.98 v7(34.16,48.64)
  GND1 w0.127: v3(49.25,55.87) 49.08,56.04 v9(48.78,56.04)
  GND3 w0.127: v3(49.25,55.87) v6(49.68,55.87)
  IN4 w0.076: v5(98.94,68.78) 98.65,68.78 97.07,67.2 97.07,66.32 96.95,66.2 96,66.2 95.92,66.12 95.92,65.67 95.84,65.6 95.69,65.6 95.62,65.67 95.62,66.12 95.54,66.2 95.39,66.2 95.31,66.12 95.31,65.67 95.23,65.6 95.08,65.6 95.01,65.67 95.01,66.12 94.93,66.2 94.78,66.2 94.7,66.12 94.7,65.67 94.63,65.6 94.47,65.6 94.4,65.67 94.4,66.12 94.32,66.2 94.17,66.2 94.09,66.12 94.09,65.67 94.02,65.6 93.86,65.6 93.79,65.67 93.79,66.12 93.71,66.2 93.34,66.2 91.09,63.95 86.64,63.95 86.22,64.37 86.22,64.37 84.75,65.83 84.75,65.83 84.65,65.93 78.81,65.93 78.49,66.25 61.43,66.25 60.89,66.79 56.06,66.79 52.47,63.2 52.47,62.23 50.91,60.67 50.91,59.46 50.79,59.34 50.79,56.98 v6(49.68,55.87)
  BOTTOM w0.076: 99.58,70.61 99.58,70.77 99.84,71.03 RC157.2
  BOTTOM w0.095: v5(98.94,68.78) 99.09,68.92 RC156.2 99.09,70.12 99.58,70.61
VR_SVID_DATA_C: length 2
  TOP w0.203: PU1000.43 36.5,47.68 36.33,47.84 PR1005.2
VRALERT#: length 16.1
  IN4 w0.076: v8(130.81,49.63) 131.24,50.06 133.68,50.06 134.27,49.47 134.48,49.47 137.13,46.81 137.13,44.1 139.32,41.91 v5(139.43,41.91)
  BOTTOM w0.095: RC81.1 140.62,40.72 v5(139.43,41.91)
  BOTTOM w0.112: UCPU1.AM11 131.15,49.96 v8(130.81,49.63)
VSET_5105: length 11.2
  TOP w0.095: v7(12.32,5.98) 12.44,6.09 RE199.1 CE79.1
  IN1 w0.076: v7(12.32,5.98) 12.4,5.9 13.88,5.9 14.28,6.29 14.28,8.87 14.99,9.58 15.14,9.58 15.41,9.84 15.41,10.22 15.89,10.7 17.08,10.7 17.99,11.61 v7(18.3,11.61)
WLAN_WIGIG60GHZ_DIS#: length 379.2
  TOP w0.095: UE3.L13 15.08,18.02 14.68,17.61 14.2,17.61 13.79,18.02 12.89,18.02 12.66,17.79 11.19,17.79 10.91,18.07 9.9,18.07 v7(9.31,17.48) v2(9.31,18.71)
  IN1 w0.076: v7(9.31,17.48) 9.45,17.62 9.45,20.15 10.36,21.06 10.36,24.77 10.16,24.98 8.32,24.98 7.52,24.17 7.52,23.06 7.15,22.68 5.74,22.68 3.14,20.09 3.14,18.4 3.74,17.81 3.74,13.54 6.49,10.79 6.49,8.12 9.45,5.16 10,5.16 10.91,4.25 13.8,4.25 15.55,6 20.49,6 22,7.5 22,8.86 22.29,9.15 23.94,9.15 25.41,7.68 25.99,7.68 26.67,6.99 27.57,6.99 28.21,7.63 30,7.63 31.12,6.51 32.54,6.51 33.16,5.89 35.73,5.89 36.34,6.5 47.55,6.5 50.77,3.28 53.96,3.28 54.36,3.68 58.17,3.68 58.38,3.47 62.29,3.47 62.98,2.78 68.24,2.78 68.33,2.69 74,2.69 74.29,2.99 77.21,2.99 81,6.78 112.29,6.78 113.08,7.58 115.15,7.58 115.62,8.04 115.92,8.04 118.26,10.38 138.05,10.38 138.68,11.01 144.66,11.01 145.05,10.62 149.85,10.62 152.77,7.71 158.79,7.71 161.01,9.93 164.19,9.93 164.87,9.25 167.73,9.25 169.21,7.78 183.3,7.78 185.21,5.87 215.72,5.87 215.86,6.01 216,6.01 217.6,7.61 221.84,7.61 223.58,5.87 225.63,5.87 227.38,4.12 254.57,4.12 256.01,5.57 256.59,5.57 258.19,7.16 258.19,7.56 259.18,8.55 260.97,8.55 264.81,12.39 273.83,12.39 275.19,13.75 277.32,13.75 278.86,15.29 278.86,18.91 279.67,19.72 279.67,22.17 280.1,22.6 280.1,25.98 279.53,26.56 279.53,27.71 279.64,27.82 279.64,31.99 278.98,32.65 278.98,34.86 279.43,35.31 279.43,39.58 278.58,40.43 278.58,50.07 280.66,52.15 284.63,52.15 v8(284.82,52.34)
  BOTTOM w0.095: v8(284.82,52.34) 285.49,52.34 285.79,52.04 DZ2.1
WLAN_WIGIG60GHZ_DIS#_R: length 4.5
  BOTTOM w0.095: RC181.1 285.37,54.54 285.79,54.12 DZ2.2 285.27,53.91 284.63,54.54 v2(284.44,54.54) 283.9,54.54 283.27,53.91 WL1.28
XCLK_BIASREF: length 2.9
  GND1 w0.095: v1(111.95,62.83) 111.96,62.81 112.37,62.81 v3(112.51,62.68)
  GND3 w0.095: v4(112.51,62.33) v3(112.51,62.68)
  BOTTOM w0.102: v4(112.51,62.33) 112.54,62.33 112.74,62.53 113.08,62.53 113.87,63.32 UCPU1.E42
XDP_BPM#0: length 6.3
  BOTTOM w0.076: UCPU1.C55 106.26,65.29 106.26,65.36 106.23,65.39 106.23,66.3 106.14,66.39 106.14,68.36 105.21,69.29 105.21,69.88 106.05,70.72 RC245.1
XDP_BPM#1: length 7
  BOTTOM w0.076: RC246.1 105.91,70.16 105.51,69.77 105.51,69.45 105.69,69.27 v2(106.4,69.27) 106.45,69.22 106.45,67.72 106.31,67.57 106.31,66.45 106.43,66.33 106.43,65.48 106.52,65.39 106.52,65.09 106.22,64.8 UCPU1.D55
XDP_BPM#2_R: length 4.5
  BOTTOM w0.076: UCPU1.B54 107.05,65.84 107.05,66.36 106.89,66.52 106.83,66.52 106.72,66.63 106.72,67.3 107.11,67.7 107.11,68.74 T50.1
XDP_BPM#3_R: length 3.1
  BOTTOM w0.076: 105.9,66.4 105.9,66.36 105.92,66.35 105.92,65.39 105.65,65.12 UCPU1.C56
  BOTTOM w0.112: T51.1 105.9,67.76 105.9,66.4
XDP_DBRESET#: length 118.3
  TOP w0.095: v7(137.78,72.08) v2(135.84,72.08) 134.97,71.21 134.97,70.45 134.36,69.84 134.36,66.41 135.92,64.85 RC248.2 ; v7(38.97,70.86) 38.97,70.07 JXDP1.48 38.98,68.62 38.39,68.03 CC87.1
  IN1 w0.076: v7(137.78,72.08) 137.37,72.08 135.67,73.78 105.45,73.78 105.1,73.44 102.42,73.44 102,73.86 84.14,73.86 82.43,72.15 80.64,72.15 78.86,73.93 41.31,73.93 38.97,71.6 v7(38.97,70.86)
XDP_ITP_PMODE: length 8.6
  BOTTOM w0.095: RC125.1 132.68,69.68 RC249.2 131.88,68.87 v2(131.57,68.56) 131.18,68.18 131.18,67.35 131.93,66.61 131.93,65.78 132.15,65.55 132.35,65.55 132.54,65.36 132.54,64.09 132.47,64.03 132.47,63.73 132.65,63.56 133.02,63.56 UCPU1.E8
XDP_OBS0_1: length 10.3
  TOP w0.095: 54.41,70.36 54.2,70.36 53.15,71.42 47.31,71.42 47.08,71.65 JXDP1.21
  TOP w0.305: T116.1 54.88,70.35 54.42,70.35 54.41,70.36
XDP_OBS1_1: length 12.4
  TOP w0.095: JXDP1.23 46.48,71.8 47.08,71.2 53.05,71.2 54.63,69.62 54.88,69.62
  TOP w0.305: T115.1 55.37,69.62 54.88,69.62
XDP_PIN1: length 3.6
  TOP w0.095: JXDP1.1 53.08,73.95 53.19,74.05 53.54,74.05 54.31,73.29 54.31,72.56 54.46,72.41 RC253.2
XDP_PRSENT#: length 150.4
  IN1 w0.076: v9(143.94,51) 144.01,51.07 148.17,51.07 148.63,51.54 148.63,56.81 149.64,57.82 150.2,57.82 150.74,58.36 150.74,59.7 151.09,60.05 151.09,62.52 149.21,64.4 149.21,68.56 146.94,70.83 145.13,70.83 144.43,71.53 138.99,71.53 136.53,73.98 105.36,73.98 105.02,73.64 102.5,73.64 102.07,74.08 84.07,74.08 82.35,72.35 80.73,72.35 78.95,74.13 40.67,74.13 39.43,72.9 38.8,72.9 38.33,72.42 38.33,72.08 37.79,71.55 37.79,70.66 37.42,70.29 35.61,70.29 v7(35.38,70.06)
  GND1 w0.095: v9(143.94,51) 143.91,51.03 v3(143.56,51.03)
  GND3 w0.095: v3(143.56,51.03) 143.56,50.88 v4(143.39,50.71)
  BOTTOM w0.095: v4(143.39,50.71) 143.39,50.67 143.59,50.47 v2(143.59,49.71) 143.59,49.22 143.88,48.93 143.88,47.73 144.18,47.43 144.82,47.43 144.92,47.33 RC243.2 RC225.2
XDP_PWRBTN#: length 8.5
  TOP w0.095: v7(42.48,67.46) 42.52,67.42 RC247.2 42.29,66.8 v2(41.45,65.96) ; JXDP1.41 41.08,72.1 41.86,71.32 v7(41.86,71.32)
  IN1 w0.076: v7(42.48,67.46) 42.39,67.55 42.39,70.83 41.9,71.32 v7(41.86,71.32)
XDP_RST#: length 102
  TOP w0.095: JXDP1.46 v7(39.58,70.89)
  IN1 w0.076: v7(39.58,70.89) 39.58,71.92 41.39,73.73 53.31,73.73 53.67,73.36 54.3,73.36 54.64,73.02 56.85,73.02 57.25,73.42 78.58,73.42 80.26,71.74 82.74,71.74 84.41,73.41 94.67,73.41 94.79,73.29 101.51,73.29 103.25,71.55 108.67,71.55 112.52,67.7 121.65,67.7 122.9,66.45 124.76,66.45 127.15,68.84 128.35,68.84 128.69,68.5 129.66,68.5 129.84,68.68 129.84,69.04 129.79,69.08 v9(129.77,69.08)
  GND1 w0.095: v9(129.77,69.08) v3(130.1,69.08)
  GND3 w0.095: v4(130.1,69.68) v3(130.1,69.08)
  BOTTOM w0.095: v2(130.96,70.61) RC249.1 v4(130.1,69.68)
XDP_TCK0: length 57.6
  TOP w0.095: JXDP1.57 36.28,72.45 36.51,72.22 v8(37,72.22)
  IN4 w0.076: v8(37,72.22) 37.29,71.93 37.94,71.93 40.49,74.49 78.8,74.49 80.53,72.76 82.49,72.76 83.84,74.11 v5(85.6,74.11)
  BOTTOM w0.095: RC228.2 87.86,72.3 RC237.2 88.19,72.64 88.19,73.43 87.51,74.11 v2(86.35,74.11) v5(85.6,74.11)
XDP_TCK1: length 69.5
  TOP w0.095: JXDP1.55 36.88,72.93 37.48,72.33 37.74,72.33 v8(37.81,72.39)
  IN4 w0.076: v5(94.82,73.58) 94.82,74.4 94.54,74.68 84.12,74.68 82.41,72.96 80.62,72.96 78.89,74.69 39.93,74.69 37.81,72.57 v8(37.81,72.39)
  BOTTOM w0.095: RC238.2 93.89,67.34 94.55,67.34 94.81,67.59 94.81,69.12 94.42,69.51 94.42,71.54 94.97,72.09 v2(94.97,73.13) 94.97,73.43 v5(94.82,73.58)
XDP_TDI: length 66.7
  TOP w0.095: v8(37.13,70.9) 36.58,70.35 JXDP1.56 36.58,67.6 v2(36.46,67.48)
  GND1 w0.095: v3(92.86,71.73) 92.86,71.38 v1(92.41,70.92)
  GND3 w0.095: v3(92.86,71.73) 92.86,71.75 92.71,71.9 v4(92.56,71.9)
  IN4 w0.076: v8(37.13,70.9) 38.71,70.9 41.7,73.88 78.53,73.88 80.26,72.15 82.76,72.15 83.51,72.91 85.15,72.91 86.52,74.27 91.5,74.27 v5(91.92,73.85)
  BOTTOM w0.095: v5(91.92,73.85) 91.92,73.05 91.46,72.6 91.46,71.82 RC229.2 91.82,71.69 92.03,71.9 v4(92.56,71.9)
XDP_TDO: length 66.6
  TOP w0.095: v2(37.52,68.28) v8(37.52,68.98) 37.78,69.25 ; v1(90.96,71.8) 91.41,71.8 91.57,71.65 RC233.2
  TOP w0.112: JXDP1.52 37.78,69.25
  GND1 w0.095: v3(91.45,72.93) 91.45,72.88 90.96,72.39 v1(90.96,71.8)
  GND3 w0.095: v3(91.45,72.93) 91.57,73.04 91.57,73.77 v4(91.48,73.85)
  IN4 w0.076: v8(37.52,68.98) 37.52,69.36 41.83,73.68 78.44,73.68 80.18,71.95 82.84,71.95 83.6,72.7 85.24,72.7 86.6,74.07 91.27,74.07 v4(91.48,73.85)
  BOTTOM w0.095: v4(91.48,73.85) 91.45,73.83 91.45,72.91 91.23,72.69 91.23,71.32 91.82,70.73 RC227.2
XDP_TMS: length 67
  TOP w0.095: v7(91.38,71.39) 91.38,70.57 91.82,70.12 RC235.2 ; v2(35.98,68.74) JXDP1.58 35.98,70.4 v8(37.09,71.51)
  IN1 w0.076: v9(92.41,71.65) 92.36,71.7 91.54,71.7 91.38,71.53 v7(91.38,71.39)
  GND1 w0.095: v3(92.1,71.95) v9(92.41,71.65)
  GND3 w0.095: v3(92.1,71.95) 92.1,72.08 v4(91.87,72.31)
  IN4 w0.076: v5(92.3,73.89) 91.71,74.47 86.43,74.47 85.07,73.11 83.43,73.11 82.67,72.35 80.35,72.35 78.62,74.08 41.6,74.08 38.87,71.36 37.24,71.36 v8(37.09,71.51)
  BOTTOM w0.095: v4(91.87,72.31) 91.83,72.35 RC231.2 91.82,72.54 92.3,73.01 v5(92.3,73.89)
XDP_TRST#: length 77.4
  TOP w0.095: RC236.2 101.93,71.42 101.93,72.13 100.64,73.42 87.59,73.42 v2(87,72.84) 85.63,71.46 v1(85.18,71.46) ; JXDP1.54 37.18,70.32 39.02,72.17 39.02,72.29 v8(39.09,72.36)
  GND1 w0.095: v1(85.18,71.46) 85.09,71.46 84.99,71.56 v3(84.99,72.29)
  GND3 w0.095: v3(84.99,72.29) 85.02,72.31 85.02,72.46 84.99,72.49 v4(84.99,73.46)
  IN4 w0.076: v4(84.99,73.46) 83.48,73.46 82.58,72.56 80.45,72.56 78.72,74.29 41.02,74.29 v8(39.09,72.36)
  BOTTOM w0.095: RC232.2 87.87,74.46 85.52,74.46 84.99,73.93 v4(84.99,73.46)
XTAL24_IN: length 6.5
  BOTTOM w0.095: RC375.2 118.38,66.98 118.38,65.49 118.29,65.4 118.29,65.09 118.34,65.04 118.34,64.75 118.18,64.59 117.9,64.59 117.73,64.42 117.73,64.16 117.06,63.5 UCPU1.E37
XTAL24_IN_RU: length 8.1
  BOTTOM w0.076: UCPU1.E3 136.48,63.95 136.78,63.65 137.11,63.65 137.27,63.8 137.27,64.06 137.49,64.28 137.77,64.28 138.14,64.65 140.06,64.65 140.88,63.83 140.88,61.81 141.01,61.68 RC377.2
XTAL24_OUT: length 6.4
  BOTTOM w0.095: RC376.2 119.72,68 119.37,67.65 119.07,67.65 118.69,67.27 118.69,65.98 118.9,65.77 118.9,65.12 118.85,65.07 118.85,64.79 118.9,64.74 118.9,64.46 117.94,63.5 UCPU1.E35
XTAL24_OUT_RU: length 9.9
  BOTTOM w0.076: RC378.2 v2(141.24,63.3) 141.24,64.34 140.68,64.9 137.44,64.9 136.74,64.2 136.4,64.2 136.31,64.3 135.77,64.3 135.47,64.6 134.36,64.6 UCPU1.C7
XTAL_25_IN: length 4.6
  IN4 w0.076: v5(19.51,42.95) 19.32,42.95 18.94,42.57 18.94,42.03 17.98,41.07 17.98,39.28 v5(17.87,39.17)
XTAL_25_IN_R: length 2.1
  IN4 w0.076: v5(15.42,39.57) 15.46,39.57 15.91,39.12 v5(16.7,39.12) 16.75,39.17 v5(17.29,39.17)
XTAL_25_OUT: length 4.7
  IN4 w0.076: v5(17.9,38.5) 17.96,38.5 18.45,38.99 18.45,40.7 19.51,41.76 v5(19.51,42.1)
  BOTTOM w0.076: UT2.D23 v5(19.51,42.1)
XTAL_25_OUT_R: length 3
  IN4 w0.076: v5(14.47,38.14) 15.09,38.14 15.35,38.4 16.59,38.4 v5(16.69,38.5) 16.7,38.5 v5(17.32,38.5)
N16374913: length 1.3
  BOTTOM w0.076: 106.68,71.14 RC245.2
  BOTTOM w0.095: T70.1 106.68,71.65 106.68,71.14
N16374925: length 1.4
  BOTTOM w0.076: RC246.2 107.23,70.16 T73.1
N16378567: length 5.8
  TOP w0.095: RC256.2 54.94,73.41 53.86,74.5 50.99,74.5 50.68,74.2 JXDP1.9
N16812268: length 2.6
  TOP w0.095: v2(280.84,18.4) 280.87,18.36 R252.1 282.08,18.09 282.66,17.51 U22.7
N16812288: length 2.2
  TOP w0.095: U22.1 281.57,15.03 C312.1 281.3,14.17 v2(281.73,13.75)
N17750417: length 2.3
  BOTTOM w0.095: UR1.28 291.14,34.04 v2(291.61,33.57) 291.96,33.22 RR9.2
N17806340: length 1.3
  BOTTOM w0.095: v2(160.68,1.62) 161.16,1.62 C1071.2
N17806379: length 5.6
  IN4 w0.076: v4(164.85,5.8) 164.55,5.8 164.38,5.98 164.38,7.06 163.88,7.56 163.88,7.92 v5(163.93,7.97)
  BOTTOM w0.095: v2(162.28,9.37) 162.31,9.39 163.45,9.39 163.72,9.13 R271.1 163.72,8.68 163.93,8.47 v5(163.93,7.97)
N17806392: length 1.5
  BOTTOM w0.095: U10.8 164.85,4.55 R269.1
N17806402: length 2.8
  BOTTOM w0.095: U10.1 162.27,5.3 161.92,4.95 v2(161.92,4.25) 161.92,3.88 161.71,3.66 C1071.1
N17907875: length 4.2
  TOP w0.095: v7(174.92,18.14) 175.4,17.66 176.61,17.66 v2(176.8,17.85)
  IN1 w0.076: v7(173.36,19.33) 173.47,19.33 174.65,18.14 v7(174.92,18.14)
N18201138: length 3.3
  BOTTOM w0.095: YC3.3 144.47,60.92 144.04,61.35 143.76,61.63 CC91.1 143.41,61.59 RC374.2 141.91,61.59 RC377.1
N18201153: length 5.2
  BOTTOM w0.095: YC3.1 145.46,61.96 144.03,61.96 143.49,62.5 CC90.1 RC374.1 141.89,62.5 RC378.1
N18408062: length 4
  TOP w0.095: T58.1 21.12,8.7 21.12,11.92 20.7,12.35 UE3.D6
N18424924: length 42.3
  TOP w0.095: PR341.1 PC350.1 PR328.2 14.01,4.15 v2(13.53,3.66)
  GND1 w0.095: v3(14.05,4.34) 14.32,4.34 v1(14.46,4.2)
  IN2 w0.064: v3(14.05,4.34) 14.05,4.35 10.57,4.35 7.54,7.37 7.54,12.13 9.5,14.09 11.14,14.09 12.42,15.37 12.42,15.88 13.66,17.12 14.56,17.12 17.66,20.23 18.76,20.23 19.5,20.96 23.69,20.96 24.19,20.46 26.43,20.46 27.83,19.06 28.28,19.06 v3(28.38,19.16)
  GND3 w0.095: v4(29.08,19.46) 28.87,19.46 28.56,19.16 v3(28.38,19.16)
N18537697: length 41
  TOP w0.254: PR1153.1 45.91,42.04 47.13,43.26 v8(47.67,43.26) 50.14,43.26 51.22,42.18 PR1152.1
  TOP w0.508: v8(73.61,43.17) 73.14,43.17 72.46,42.48 PR1151.1
  IN2 w0.254: v8(47.67,43.26) 48.03,43.26 48.11,43.34 49.94,43.34 53.09,40.2 61.01,40.2 62.38,41.57 64.07,41.57 64.76,40.87 74.08,40.87 74.79,41.59 74.79,41.95 v8(74.67,42.07)
  BOTTOM w0.254: PL1150.1 72.18,42.07 v8(74.67,42.07)
N18676843: length 9.5
  TOP w0.095: PC131.1 37.06,2.5 38.42,2.5 PR149.2 38.93,3.23 PR153.1 39.37,3.73 v8(39.55,3.73) 39.88,3.73 v2(40.24,3.37)
  BOTTOM w0.095: v8(39.55,3.73) 39.6,3.68 39.96,3.68 39.98,3.7 PQ126.1 40.33,4.44 PU101.4
N18676867: length 9.4
  TOP w0.254: PR106.1 33.19,18.17 PR100.2 PC109.2
  GND1 w0.254: v3(33.38,16.61) 33.38,16.68 v1(33.62,16.91)
  GND3 w0.254: v4(33.04,16.4) 33.25,16.61 v3(33.38,16.61)
  BOTTOM w0.254: v4(33.04,16.4) 33.12,16.48 PQ133.1 33.33,17.81 37.4,17.81 37.62,18.03 PQ100.4
N18676872: length 14.5
  TOP w0.254: PR103.2 39.53,6.11 v2(39.53,5.57) 39.53,5.54 38.7,4.71 PC111.2 38.67,4.5 36.51,4.5 36.36,4.65 36.36,5.42 36.8,5.86 v8(37,5.86)
  BOTTOM w0.254: PQ101.4 35.05,10.83 34.33,10.1 ; 34.33,10.1 PR109.1 ; 34.33,10.1 34.89,9.55 34.89,8.72 34.58,8.41 34.58,7.48 35.19,6.87 35.5,6.87 35.95,6.43 PQ104.1 35.95,6.14 36.21,5.87 36.99,5.87 v8(37,5.86)
N18676880: length 4.3
  TOP w0.095: v8(38.17,5.86) 38.17,5.42 PR107.2
  BOTTOM w0.095: PQ109.6 37.75,8.2 37.25,7.7 37.25,6.91 38.17,5.99 v8(38.17,5.86)
N18676884: length 4.9
  TOP w0.095: v8(38.75,5.9) PR176.1 PR123.2
  BOTTOM w0.095: v2(39.66,5.81) 39.57,5.9 v8(38.75,5.9) 38.71,5.94 38.71,6.08 38.71,7.37 38.54,7.55 PQ109.5
N18676885: length 3.3
  TOP w0.254: v8(40.76,8.21) 40.75,8.2 v2(40.75,5.95) 40.75,5.5 PR115.2
N18676889: length 5.9
  TOP w0.095: PR107.1 36.92,5.04 37.58,5.69 v8(37.58,5.79)
  BOTTOM w0.095: v8(37.58,5.79) 37.58,6.26 36.77,7.07 36.15,7.07 35.3,7.92 PQ104.2 35.3,8.58 35.4,8.68 PR101.2
N18676894: length 6.9
  TOP w0.095: PR133.1 43.03,17.12 v2(42.8,16.89)
  TOP w0.254: PR133.1 43.93,17.13 PR128.2 PC123.2
  GND1 w0.254: v3(44.44,18.02) v1(43.98,18.02)
  GND3 w0.254: v4(44.45,18.44) 44.45,18.03 v3(44.44,18.02)
  BOTTOM w0.254: PQ135.1 46.81,19.12 46.56,18.86 44.71,18.86 44.45,18.61 v4(44.45,18.44)
N18676898: length 37.1
  TOP w0.095: v2(48.08,15.27) 48.97,16.16 v7(49.21,16.16)
  IN1 w0.076: v7(49.21,16.16) 48.32,15.26 42.08,15.26 40.86,16.48 38.58,16.48 36.55,18.52 34.92,18.52 v9(34.39,19.04)
  GND1 w0.095: v3(33.96,19.04) v9(34.39,19.04)
  GND3 w0.095: v6(34.41,18.97) 34.22,18.97 34.14,19.04 v3(33.96,19.04)
  IN4 w0.076: v5(33.81,32.42) 33.81,32.2 33.89,32.12 33.89,28.1 33.62,27.83 33.62,22.83 34.16,22.28 34.16,19.88 34.2,19.84 34.2,19.07 34.3,18.97 v6(34.41,18.97)
  BOTTOM w0.095: v5(33.81,32.42) 33.81,32.6 32.77,33.64 31.52,33.64 30.82,32.95 PR121.1
N18676900: length 10.2
  TOP w0.254: v1(42.52,9.95) 42.74,9.73 42.74,8.34 43.27,7.8 44.39,7.8 PR134.1 45.76,7.55 PR130.2 PC124.2 47.82,7.8 PQ115.1
  GND1 w0.254: v1(42.52,9.95) 42.36,10.11 v3(42.36,10.4)
  GND3 w0.254: v3(42.36,10.4) 42.47,10.51 v4(42.47,10.81)
N18676906: length 7.3
  TOP w0.095: v2(51.81,9.65) 51.81,8.47 PR129.2
  TOP w0.254: PR129.2 50.87,7.65 50.7,7.48 PQ115.2 49.62,7.36 47.75,7.36 PR118.1
N18676911: length 6.4
  TOP w0.095: v2(43.68,2.99) 44.43,2.99 PR139.2 v1(44.9,3.31)
  GND1 w0.095: v1(44.9,3.31) v3(44.59,3.61)
  GND3 w0.095: v3(44.59,3.61) 44.61,3.61 v4(44.93,3.94)
  BOTTOM w0.095: v4(44.93,3.94) 45.07,4.08 45.41,4.08 46.19,4.85 PQ121.3 47.51,4.85 47.61,4.96 47.61,5.4 47.51,5.5 PQ121.2
N18676915: length 5.4
  TOP w0.095: PR118.2 46.65,5.33 46.27,4.95 45.55,4.95 45.13,5.37 44.96,5.37 v1(44.15,6.18)
  GND1 w0.095: v1(44.15,6.18) v3(44.57,6.18)
  GND3 w0.095: v3(44.57,6.18) 44.85,6.18 44.87,6.15 v4(45.12,6.15)
  BOTTOM w0.095: 45.18,6.15 44.95,5.93 44.2,5.93 v2(44.16,5.89) ; 45.18,6.15 PQ121.6 ; 45.18,6.15 v4(45.12,6.15)
N18676918: length 6.9
  TOP w0.095: PR136.2 48.68,6.2 47.82,5.34 PR177.1 47.4,5.29 47.19,5.49 47.19,6.19 v1(47.18,6.2)
  GND1 w0.095: v1(47.18,6.2) v3(46.52,6.2)
  GND3 w0.095: v4(46.17,6.15) 46.47,6.15 v3(46.52,6.2)
  BOTTOM w0.095: v4(46.17,6.15) 46.17,5.8 45.87,5.5 PQ121.5 44.78,5.5 44.06,4.78 v2(44.06,4.57)
N18676946: length 5.2
  TOP w0.095: PR135.1 42.1,5.16 PR179.2 42.08,5.54 42.71,6.18 v1(42.99,6.18)
  GND1 w0.095: v3(43.52,6.18) v1(42.99,6.18)
  GND3 w0.095: v4(43.07,6.08) 43.17,6.18 v3(43.52,6.18)
  BOTTOM w0.095: v2(44.24,7.22) 43.95,7.22 PQ119.2
N18676960: length 5.2
  TOP w0.095: v2(32.25,10.62) 32.25,9.66 PR178.2 31.17,8.58 PR114.1
  GND1 w0.095: v1(32.17,9.49) 31.92,9.49 v3(31.78,9.36)
  GND3 w0.095: v4(31.93,9.81) 31.93,9.5 v3(31.78,9.36)
  BOTTOM w0.095: v4(31.93,9.81) 31.95,9.83 PQ108.2
N18677037: length 3.6
  BOTTOM w0.095: PR215.2 30.86,12.57 31.17,12.26 32.56,12.26 ; 32.56,12.26 32.54,12.29 PQ134.3 ; 32.56,12.26 32.97,12.26 33.19,12.48 PQ134.2
N18677040: length 1.8
  GND1 w0.095: v1(33.38,14.48) 33.38,13.99 v3(33.58,13.79)
  GND3 w0.095: v3(33.58,13.79) v4(33.58,14.21)
  BOTTOM w0.095: v4(33.58,14.21) 33.84,14.47 PQ134.6
N18677045: length 3.5
  TOP w0.095: PR228.1 PR217.2
  GND1 w0.095: v1(32.69,17.02) 32.74,16.98 32.74,16.41 v3(33.19,15.96)
  GND3 w0.095: v4(33.06,15.4) 33.06,15.83 v3(33.19,15.96)
  BOTTOM w0.095: v4(33.06,15.4) 33.19,15.27 PQ134.5
N18677050: length 3.1
  TOP w0.095: PR222.2 v2(50.18,20.2)
  GND1 w0.095: v3(50.05,19.03) 50.05,19.11 v1(50.26,19.31)
  GND3 w0.095: v3(50.05,19.03) 50.28,18.8 v4(50.31,18.8)
  BOTTOM w0.095: PQ136.2 49.93,19.13 50.26,18.8 v4(50.31,18.8) 50.33,18.8 50.58,19.05 PQ136.3
N18677052: length 3.9
  TOP w0.254: v1(47.93,17.65) 47.76,17.82 v2(47.51,17.82) 47.16,17.82 46.65,17.3 PR221.2
  GND1 w0.254: v3(48.29,17.58) 48.22,17.65 v1(47.93,17.65)
  GND3 w0.254: v4(48.66,17.58) v3(48.29,17.58)
  BOTTOM w0.254: PQ136.6 48.79,17.45 v4(48.66,17.58)
N18677057: length 1.9
  TOP w0.095: PR229.1 50.2,17.49 v1(50.2,18.36)
  GND1 w0.095: v3(49.9,17.99) 50.2,18.29 v1(50.2,18.36)
  GND3 w0.095: v4(49.93,17.46) 49.9,17.48 v3(49.9,17.99)
N18677160: length 4.5
  TOP w0.095: v2(54.27,2.67) PC130.1 PR151.2 51.98,1.98 v8(52.24,1.73)
  BOTTOM w0.095: PQ125.2 52.24,1.91 v8(52.24,1.73)
N18677163: length 7.3
  TOP w0.095: PR156.1 PR155.1 49.4,1.72 v8(50.03,1.72)
  BOTTOM w0.095: PQ125.5 50.89,2.59 v8(50.03,1.72) 50.01,1.71 49.48,1.71 49.23,1.96 PQ124.2 49.23,3.04 50.04,3.85 v2(50.04,4.73)
N18677164: length 4.7
  TOP w0.095: PR156.2 48.22,3.05 48.5,3.33 49.58,3.33 v1(49.61,3.31)
  GND1 w0.095: v3(50.07,3.39) 49.98,3.31 v1(49.61,3.31)
  GND3 w0.095: v3(50.07,3.39) 50.07,3.4 v4(50.53,3.4)
  BOTTOM w0.095: v2(51.61,4.54) 51.61,3.84 PQ125.6 50.68,3.24 v4(50.53,3.4)
N18677165: length 7.4
  TOP w0.095: v1(45.81,3.44) 45.83,3.44 PC125.1 47.09,3.32 PR148.1 47.41,3.61 49.95,3.61 v2(50.07,3.5) 50.48,3.08 PR150.1
  GND1 w0.095: v3(45.28,3.61) 45.33,3.56 45.68,3.56 v1(45.81,3.44)
  GND3 w0.095: v4(45.54,3.35) 45.49,3.35 45.28,3.56 v3(45.28,3.61)
  BOTTOM w0.095: PQ123.2 45.76,3.57 v4(45.54,3.35)
N18677185: length 4
  TOP w0.095: v2(52.72,1.42) 52.53,1.42 52.44,1.32 51.99,1.32 51.64,1.67 v8(51.64,1.71) 51.19,2.17 PR150.2
  BOTTOM w0.095: PQ125.3 52.92,1.71 52.52,1.32 52.03,1.32 v8(51.64,1.71)
N18677212: length 4.2
  TOP w0.095: v1(32.25,19.26) PC136.1 32.12,20.28 PR122.2 v2(32.12,22.23)
  GND1 w0.095: v1(32.25,19.26) v3(32.25,18.6)
  GND3 w0.095: v4(31.97,18.99) 32.14,18.83 32.14,18.71 v3(32.25,18.6)
N18677217: length 4.3
  TOP w0.095: PR132.2 50.13,16.09 49.32,15.28 PC137.1 49.2,14.39 v1(49.19,14.38) 49.19,14 v2(48.64,13.46)
  GND1 w0.095: v1(49.19,14.38) 49.34,14.54 v3(49.65,14.54)
  GND3 w0.095: v4(49.49,14.84) 49.49,14.69 v3(49.65,14.54)
N18677243: length 3.6
  TOP w0.095: v2(53.58,13.93) 53.58,14.84 v1(53.48,14.94)
  GND1 w0.095: v1(53.48,14.94) 53.66,14.76 v3(53.79,14.76)
  GND3 w0.095: v4(53.99,14.46) 53.79,14.66 v3(53.79,14.76)
  BOTTOM w0.095: PQ127.6 54.18,13.78 53.99,13.98 v4(53.99,14.46) 54.01,14.43 PQ127.5
N18677245: length 3.6
  TOP w0.095: PR203.2 52.62,14.99 v1(53.48,15.86)
  GND1 w0.095: v1(53.48,15.86) 53.48,16.09 v3(53.58,16.19)
  GND3 w0.095: v3(53.58,16.19) v4(53.25,16.19)
  BOTTOM w0.095: v4(53.25,16.19) 53.23,16.21 PQ122.1 52.71,16.21 PQ127.3
N18677247: length 1.3
  GND1 w0.095: v3(54.12,16.54) 53.76,16.54 53.68,16.62 53.51,16.62 v1(53.48,16.64)
  GND3 w0.095: v3(54.12,16.54) 54.45,16.21 v4(54.61,16.21)
N18677249: length 3.8
  TOP w0.095: PR203.1 51.82,14.97 52.39,14.4 52.39,14.31 PR201.2 ; PR201.2 52.62,13.33 v2(52.31,13.02) ; PR201.2 v1(52.62,14.14)
  GND1 w0.095: v3(52.31,14.76) 52.31,14.45 v1(52.62,14.14)
  GND3 w0.095: v4(52.64,14.48) 52.59,14.48 v3(52.31,14.76)
N18677256: length 4.4
  BOTTOM w0.095: 60.8,7.04 PQ120.6 ; 60.8,7.04 61.35,7.04 61.45,6.93 PQ120.5 ; 60.8,7.04 60.41,7.43 60.41,8.94 PR127.2
N18677258: length 3.2
  BOTTOM w0.095: PQ128.1 62.14,8.07 PQ120.3 62.1,8.86 PR204.2 PR143.2
N18677261: length 22
  TOP w0.095: v1(58.56,1.97) 58.56,2.1 v2(58.16,2.5) 57.73,2.5 54.99,5.25 50.58,5.25 49.62,6.2 PR144.2
  GND1 w0.095: v3(58.65,1.49) 58.7,1.53 58.7,1.83 v1(58.56,1.97)
  GND3 w0.095: v4(59.06,2.49) 58.7,2.12 58.7,1.53 v3(58.65,1.49)
  BOTTOM w0.095: PR204.1 61.45,9.03 PQ120.2 61.45,7.97 62.62,6.8 62.62,5.57 62.37,5.32 60.91,5.32 60.35,4.75 60.35,3.76 59.17,2.58 59.16,2.58 v4(59.06,2.49)
N18677267: length 4.5
  BOTTOM w0.095: PR200.1 64.53,8.64 64.73,8.64 65.07,8.3 65.07,7.84 64.63,7.4 64.12,7.4 63.3,6.57 PQ128.6
N18677269: length 4.9
  BOTTOM w0.095: 66.87,6.64 66.99,6.76 67.67,6.76 68.57,7.66 v2(68.57,8.05) PR171.2 ; 66.87,6.64 PQ117.5 ; 66.87,6.64 66.31,6.64 66.22,6.54 PQ117.6
N18677271: length 2.4
  BOTTOM w0.095: PR196.2 PR205.1 66,9.07 66.87,8.21 PQ117.2
N18677274: length 6.2
  BOTTOM w0.095: PQ128.4 64.6,6.59 64.84,6.83 65.92,6.83 66.14,7.06 67.08,7.06 67.52,7.49 PQ117.3 67.52,8.61 67.65,8.74 PR173.2 PR205.2
N18677277: length 1.9
  BOTTOM w0.095: PQ128.3 64.1,8.57 63.57,8.57 63.21,8.92 PR170.1
N18677285: length 2.9
  TOP w0.095: v1(54.47,19.46) 54.54,19.46 54.93,19.07 54.93,18.28 54.93,18.28 54.93,18.22 54.47,17.77 PR206.2
  GND1 w0.095: v1(54.47,19.46) 54.24,19.23 v3(54.22,19.23)
  GND3 w0.095: v3(54.22,19.23) 54.32,19.34 v4(54.56,19.34)
N18677287: length 4.8
  TOP w0.095: v2(54.61,20.42) 53.67,20.42 PR175.2 PR208.1 54.04,19.01 54.04,18.92 54.41,18.55 PR207.1
  GND1 w0.095: v1(54.4,18.42) 54.55,18.57 v3(54.73,18.57)
  GND3 w0.095: v4(54.04,18.61) 54.69,18.61 v3(54.73,18.57)
  BOTTOM w0.095: v4(54.04,18.61) 54.04,18.61 PQ129.6
N18677294: length 2.9
  TOP w0.095: v1(51.7,19.44) 51.7,20.24 51.45,20.49 v2(51.45,20.82)
  GND1 w0.095: v1(51.7,19.44) v3(51.7,19.92)
  GND3 w0.095: v3(51.7,19.92) v4(52.11,19.92)
  BOTTOM w0.095: PQ129.3 52.12,19.91 v4(52.11,19.92)
N18677306: length 28.2
  TOP w0.095: PR145.2 45.21,4.47 53.84,4.47 v2(53.91,4.55) 54.7,4.55 57.89,1.35 60,1.35 v1(60.26,1.61)
  GND1 w0.095: v3(60.58,1.49) 60.58,1.51 60.48,1.61 v1(60.26,1.61)
  GND3 w0.095: v4(60.85,1.92) 60.85,1.75 v3(60.58,1.49)
  BOTTOM w0.095: PQ128.2 63.95,7.6 62.88,6.53 62.88,5.51 62.46,5.09 61,5.09 60.57,4.66 60.57,3.67 59.48,2.58 59.48,2.04 59.59,1.92 v4(60.85,1.92)
N18677309: length 3.9
  BOTTOM w0.095: PR195.2 64.99,8.77 65.31,8.45 65.31,7.72 64.66,7.07 64.23,7.07 63.95,6.79 PQ128.5
N18677312: length 0.8
  GND1 w0.095: v1(52.69,16.01) 52.71,16.02 v3(52.71,16.39)
  GND3 w0.095: v4(52.72,16.77) 52.71,16.76 v3(52.71,16.39)
N18677317: length 0.7
  GND1 w0.095: v1(54.55,16.73) 54.55,17 v3(54.48,17.06)
  GND3 w0.095: v3(54.48,17.06) v4(54.73,16.82)
N18677319: length 2.4
  GND1 w0.095: v1(53.61,17.66) v3(53.61,18.04)
  GND3 w0.095: v3(53.61,18.04) v4(53.61,18.42)
  BOTTOM w0.095: v4(53.61,18.42) 53.61,19.03 53.38,19.26 PQ129.2
N18677336: length 5.6
  BOTTOM w0.095: PR268.2 181.66,7.88 v2(181.38,7.6)
  BOTTOM w0.254: PR273.1 179.97,9.4 180.46,9.89 181.4,9.89 PQ150.2 182.46,8.82 PR268.2
N18677339: length 5.8
  BOTTOM w0.095: PR266.1 213.91,1.72 v2(213.54,1.35) ; PR266.1 215.1,2.23 216.44,2.23 PR259.2 ; PR266.1 214.59,2.94 214.17,3.36 PQ151.5
N18677341: length 3.4
  BOTTOM w0.305: PR275.1 193.39,3.58 193.39,2.71 PC287.1 ; PC287.1 192.71,2.71 192.33,2.33 PQ156.2 ; PC287.1 193.4,2.7 193.4,1.82 PR271.2
N18677367: length 5.3
  BOTTOM w0.305: PQ153.4 193.76,5.74 194.18,5.32 PC286.2 ; PR260.1 194.33,4.46 194.64,4.77 194.64,5.31 PC286.2 ; PQ158.1 195.52,4.25 PR263.2 PC286.2
N18677371: length 41.4
  IN4 w0.076: v5(194.31,1.68) 194.58,1.68 194.74,1.52 201.02,1.52 203.94,4.44 204.88,4.44 205.29,4.85 209.63,4.85 209.97,5.19 211.41,5.19 211.6,5 212.42,5 212.65,4.77 218.98,4.77 v5(219,4.75)
  BOTTOM w0.254: v5(219,4.75) 219,5.41 219.67,6.07 219.67,8.11 218.83,8.96 218.83,10.25 v2(216.61,12.47) 216.17,12.91 214,12.91 PQ201.1 211.86,14.17 PR141.1
N18677375: length 6.4
  BOTTOM w0.254: PQ150.1 182.27,10.71 182.84,10.14 182.84,9.35 PR274.1 183.43,7.91 PC291.2 PR261.2 185,7.88 185.17,7.7 PQ155.4
N18677393: length 3.3
  BOTTOM w0.095: v2(182.3,12.39) 181.75,12.39 181.31,11.94 PR278.2 PR272.1 180.24,11.94 179.73,12.45 PQ149.5
N18677420: length 2.3
  BOTTOM w0.095: PQ157.1 v2(183.59,9.81)
  BOTTOM w0.254: PQ157.1 184.69,9.12 PR274.2
N18677423: length 5.1
  BOTTOM w0.095: v2(188.79,9.3) 188.2,9.89 PR277.2
  BOTTOM w0.254: PR267.1 186.22,10.83 PQ157.2 186.64,10.46 187.21,9.89 PR277.2
N18677424: length 3.9
  BOTTOM w0.095: 177.94,13.09 177.93,13.1 PQ149.3 ; 177.94,13.09 177.94,12.55 177.84,12.45 PQ149.2 ; 177.94,13.09 178.09,13.24 PR270.2 178.09,14.95 v2(178.41,15.27)
N18677428: length 4.1
  BOTTOM w0.095: v2(179.54,8.4) 179.21,8.73 179.21,9.87 179.66,10.32 PR273.2
  BOTTOM w0.254: PR273.2 179.79,10.44 179.79,11.55 179.73,11.61 179.54,11.8 PQ149.6
N18677440: length 2.6
  BOTTOM w0.095: PR276.2 216.27,3.36 PQ151.2 215.39,3.36 215.21,3.18 215.21,2.8 215.31,2.71 PQ151.3
N18677470: length 18.2
  IN4 w0.076: v5(211.79,5.3) 211.7,5.39 209.89,5.39 209.55,5.05 205.2,5.05 204.8,4.64 203.86,4.64 201.39,2.18 v5(199.67,2.18)
  BOTTOM w0.095: PR262.2 198.12,1.68 v2(199.39,1.68) 199.67,1.96 v5(199.67,2.18) ; v5(211.79,5.3) 211.97,5.3 213.18,4.56 213.21,4.51 213.21,4.05 213.25,4.01 PQ151.6
N18681292: length 3
  TOP w0.095: PC349.1 64.35,6.26 65.28,5.33 v2(65.28,4.95)
  TOP w0.203: PR327.2 65.09,7.11 PC349.1
N18681306: length 13.5
  TOP w0.095: v2(63.48,19.84) 63.48,19.07 v7(63.79,18.75)
  IN1 w0.254: v7(63.79,18.75) 63.65,18.61 63.65,17.06 63.32,16.73 v9(63.32,15.24)
  GND1 w0.254: v3(63.4,14.9) 63.4,15.08 63.32,15.16 v9(63.32,15.24)
  IN3 w0.254: v3(63.4,14.9) 63.33,14.84 63.33,14.24 61.88,12.78 57.93,12.78 57.36,12.22 v3(57.36,11.95)
  GND3 w0.254: v3(57.36,11.95) 57.16,11.75 v4(56.99,11.75)
N18681307: length 14.5
  TOP w0.095: v7(62.4,18.75) 62.4,19.4 62.21,19.59 v2(62.21,19.67)
  IN1 w0.254: v7(62.4,18.75) 62.6,18.55 62.6,17.15 62.94,16.81 v9(62.94,15.21)
  GND1 w0.254: v9(62.94,15.21) 62.94,15.15 62.87,15.07 v3(62.87,14.89)
  IN3 w0.254: v3(62.87,14.89) 62.95,14.8 62.95,14.4 61.72,13.16 57.43,13.16 56.19,11.93 v3(55.65,11.93)
  GND3 w0.254: v4(55.21,11.75) 55.46,11.75 v3(55.65,11.93)
N18681310: length 2.1
  TOP w0.508: PR309.1 v2(56.55,10.8) 56.55,10.09 56.54,10.08
  vias: v1(56.19,9.48) v1(56.49,9.49) v3(56.45,9.14) v4(56.91,9.05)
N18681327: length 1.2
  TOP w0.095: PC330.1 v2(66.18,19.15)
N18681333: length 7.7
  TOP w0.178: PU300.3 66.45,11.41 66.54,11.31 66.57,11.31 66.57,11.31 66.63,11.31 67.11,10.83 v7(67.32,10.83)
  IN1 w0.254: v9(69.2,11.26) 68.77,10.83 v7(67.32,10.83)
  GND1 w0.254: v9(69.2,11.26) v3(69.69,11.26)
  GND3 w0.254: v4(70.09,10.03) 70.06,10.05 70.06,10.07 69.69,10.45 v3(69.69,11.26)
  BOTTOM w0.254: PC341.1 PR318.1 70.02,9.45 70.09,9.52 v4(70.09,10.03)
N18681352: length 1.6
  BOTTOM w0.095: PR311.2 69.53,12.01 70.33,11.21 v2(70.63,11.21)
N18681512: length 2.1
  TOP w0.203: PR332.2 62.4,8.2 63.02,8.81 PU300.26
N18681547: length 1.9
  TOP w0.203: PR322.1 63.42,8.2 PU300.27
N18681577:
  vias: v2(59.29,12.02)
N18683466: length 0.5
  BOTTOM w0.095: 55.37,27.88 v2(55.91,27.88)
N18683478: length 1.6
  BOTTOM w0.254: PU501.9 39.34,23.46 39.57,23.22 PR506.2
N18683485: length 2.2
  BOTTOM w0.254: PU500.12 48.78,26.33 48.28,25.83 48.28,25.37 47.94,25.04 PR503.2
N18683537: length 1.4
  BOTTOM w0.254: PU501.12 36.93,25.03 PR510.2
N18683542: length 2.8
  BOTTOM w0.254: PU501.17 39.34,28.05 v2(39.02,28.37) 38.84,28.55 PC517.1
N18683563:
  vias: v2(43.32,28.66)
N18683566: length 0.9
  BOTTOM w0.305: PC511.2 PR504.1
N18683579: length 2.1
  BOTTOM w0.095: PR511.1 v2(35.96,27.94)
  BOTTOM w0.254: PR511.1 35.93,26.82 PC525.2
N18683583: length 7.2
  IN1 w0.508: 39.41,33.23 39.66,33.23 40.04,32.85 40.04,32.09 39.41,31.45 39.41,27.26 39.03,26.88
  vias: v3(38.79,26.29) v4(38.04,25.93) v4(38.34,25.93) v7(39.09,33.78) v7(39.09,33.48) v9(38.75,26.66) v9(39.09,26.66)
N18684722: length 3.4
  BOTTOM w0.254: PR603.2 PC609.2 117.28,3.26 117.29,3.25 118.02,3.25 PR605.1 118.06,3.39 117.92,3.53 PU600.16
N18684725:
  vias: v2(120.93,4.19)
N18684739: length 1.2
  TOP w0.095: PC602.1 v2(113.49,5.47)
  vias: v1(113.34,6.82) v1(113.63,6.83) v1(114.25,6.88) v1(114.5,6.88) v1(114.76,6.88) v3(113.11,6.51) v3(113.55,6.5) v3(113.98,6.51) v3(114.44,6.5) v3(114.86,6.51) v3(115.27,6.5) v4(113.03,6.16) v4(113.35,6.84) v4(113.28,6.16) v4(113.55,6.15) v4(113.6,6.84) v4(113.81,6.15) v4(114.06,6.15) v4(114.36,6.84) v4(114.31,6.15) v4(114.57,6.15) v4(114.61,6.84) v4(114.87,6.84) v4(114.82,6.15)
N18684756: length 1.7
  BOTTOM w0.254: PC607.1 119.18,3.83 118.82,4.19 PU600.14
N18684795: length 2
  BOTTOM w0.254: PC614.1 116.62,9.05 117.47,8.2 PU600.3
N18684816: length 0.9
  BOTTOM w0.508: PR602.2 PC604.1
N18686200:
  vias: v2(167.18,62.85)
N18686203: length 2.5
  BOTTOM w0.095: PC807.1 151.44,60.84 v2(151.08,61.2)
  BOTTOM w0.508: PC807.1 153.09,60.84 PR803.2
N18686225: length 1.7
  BOTTOM w0.254: PU800.7 159.97,64.09 160.73,64.85 PR806.1
N18686705: length 1.3
  BOTTOM w0.095: PC905.1 v2(153.48,1.56)
N18686709: length 1.8
  BOTTOM w0.095: PR903.2 156.49,14.1 v2(155.39,15.21)
N18686770: length 1.7
  BOTTOM w0.254: PU900.7 158.92,5.69 159.55,5.06 PR906.1
N18687217: length 5.2
  TOP w0.203: PU1000.2 39.37,44.35 39.16,44.15 38.19,44.15 37.41,43.37 PC1004.2
  GND1 w0.254: v3(37.66,43.38) 37.66,43.26 37.4,43 v1(37.32,43)
  GND3 w0.254: v3(37.66,43.38) 37.66,43.29 37.45,43.09 v4(37.45,43.03)
  BOTTOM w0.095: v4(37.45,43.03) 37.45,43.77 v2(37.29,43.94)
N18687233: length 5.3
  TOP w0.203: PU1000.4 40.17,44.15 39.19,43.17 PC1006.2
  GND1 w0.254: v3(39.56,42.96) 39.36,42.96 39.27,42.86 v1(39.23,42.86)
  GND3 w0.254: v3(39.56,42.96) 39.52,43 v4(39.14,43)
  BOTTOM w0.095: PR1018.2 39.21,44.95 v2(39.05,45.1)
N18687239: length 1.9
  BOTTOM w0.095: v2(38.17,41) 38.98,41 PC1007.2
  BOTTOM w0.254: PC1007.2 PR1018.1
N18687245: length 4
  TOP w0.203: PR1035.1 44.59,52.86 PC1020.1 43.73,52.38 43.35,52 42.58,52 42.17,51.58 PU1000.28
N18687260: length 2
  TOP w0.095: PC1023.1 46.28,55.58 v2(46.48,55.79)
  TOP w0.254: PR1032.2 PC1023.1
N18687261: length 5.9
  TOP w0.203: PU1000.29 41.77,51.84 42.25,52.33 42.99,52.33 43.19,52.53 43.19,54.11 PC1021.1
  TOP w0.254: PC1021.1 44.54,54.64 PR1032.1
N18687263: length 1
  TOP w0.254: PR1033.2 40.87,55.65 PC1022.1
N18687264: length 6.6
  TOP w0.095: PR1028.1 42.64,56.33 v2(42.37,56.6)
  TOP w0.203: PU1000.30 41.37,52.38 41.25,52.5 41.25,53.54 41.47,53.75 PR1029.1
  TOP w0.254: PR1029.1 41.78,53.77 PR1033.1 41.78,54.68 PR1028.1
N18687267: length 4.7
  TOP w0.203: PU1000.8 41.77,43.8 42.13,43.44 v1(42.13,42.98)
  GND1 w0.254: v1(42.13,42.98) v3(42.56,42.98)
  GND3 w0.254: v3(42.56,42.98) v4(42.56,43.52)
  BOTTOM w0.254: PC1019.2 43.91,43.24 43.63,43.52 v4(42.56,43.52)
N18687270: length 0.9
  BOTTOM w0.254: PR1031.2 PC1019.1
N18687277: length 4.5
  TOP w0.203: v1(38.34,43.04) 38.34,43.21 38.87,43.74 39.26,43.74 39.77,44.25 PU1000.3
  GND1 w0.254: v1(38.34,43.04) v3(38.65,42.73)
  GND3 w0.254: v4(38.37,42.91) 38.47,42.91 v3(38.65,42.73)
  BOTTOM w0.095: v2(38.58,43.9) 38.29,43.61 PC1005.2
N18687285: length 0.8
  TOP w0.203: PC1010.2 38.82,54.56 PR1024.1
N18687287: length 3
  TOP w0.203: PU1000.33 40.17,52 39.68,52.49 PR1021.1 38.83,52.83 PC1010.1
N18687304: length 3.2
  TOP w0.203: v1(37.39,46.47) 37.39,46.48 PU1000.46
  GND1 w0.254: v3(37.1,46.23) 37.34,46.47 v1(37.39,46.47)
  GND3 w0.254: v3(37.1,46.23) 37.4,46.23 v4(37.71,46.54)
  BOTTOM w0.095: v4(37.71,46.54) 37.29,46.54 v2(36.67,45.92)
N18687317: length 2.3
  TOP w0.203: PR1023.1 38.97,51.84 PU1000.36
N18687330: length 4.6
  TOP w0.203: PU1000.42 37.21,48.08 36.56,48.73 v1(36.21,48.73)
  GND1 w0.254: v3(36.9,48.77) 36.85,48.73 v1(36.21,48.73)
  GND3 w0.254: v4(36.26,48.72) 36.84,48.72 v3(36.9,48.77)
  BOTTOM w0.095: v2(35.97,47.78) 36.21,48.03 PR1001.2
N18687344: length 3.2
  TOP w0.203: v8(45.49,45.66) 45.49,45.66 45.35,45.66 44.93,46.08 PU1000.14
  BOTTOM w0.254: PR1043.1 PC1035.1 45.56,45.6 v8(45.49,45.66)
N18687348: length 33.1
  IN3 w0.254: v3(69.68,57.02) 68.63,55.98 68.63,53.87 68.2,53.43 63.54,53.43 61.14,51.04 61.14,46.39 60.54,45.79 57.37,45.79 56.32,44.74 49.46,44.74 v3(49.15,44.43)
  GND3 w0.254: v3(49.15,44.43) 48.66,43.94 v4(48.38,43.94) ; v3(69.68,57.02) v4(70.03,57.37)
  BOTTOM w0.095: v4(48.38,43.94) v2(48.38,42.88)
  BOTTOM w0.254: PR1041.1 v4(48.38,43.94)
N18687349: length 4.8
  TOP w0.203: PU1000.15 45.49,46.48 v8(45.7,46.27)
  BOTTOM w0.095: v8(45.7,46.27) 45.33,46.64 v2(45.14,46.64)
  BOTTOM w0.254: v8(45.7,46.27) 45.7,46.15 46.5,45.35 46.97,45.35 47.46,44.86 PR1041.2
N18687351: length 3.3
  TOP w0.203: PR1016.1 36.53,50.87 36.74,50.66 36.74,49.7 37.56,48.88 PU1000.40
N18687354: length 3.7
  TOP w0.203: PU1000.39 37.64,49.28 37.09,49.82 37.09,51.07 36.4,51.76 PR1015.1
N18687357: length 4.2
  TOP w0.203: PR1014.1 36.19,52.62 36.58,52.22 36.79,52.22 v2(37.13,51.88) 37.42,51.59 37.42,49.96 37.71,49.68 PU1000.38
N18687362: length 3.2
  TOP w0.203: PR1013.1 38.1,51.82 38.1,50.12 PU1000.37
N18687368: length 3.3
  BOTTOM w0.095: v2(49.76,42.97) 49.76,44.36 PC1039.1
  BOTTOM w0.254: PR1047.2 49.27,45.6 PC1039.1
N18687369: length 6.5
  TOP w0.203: PU1000.16 46.5,46.88 46.74,46.63 46.74,46.41 46.59,46.26 v8(46.32,46.26)
  BOTTOM w0.254: PR1047.1 48.68,45.61 48.46,45.4 47.46,45.4 PC1037.1 46.65,45.93 v8(46.32,46.26)
N18687371: length 3.2
  TOP w0.095: v2(49.71,48.52) 48.49,48.52 47.82,47.85 PC1038.1
  TOP w0.254: PR1045.2 47.56,47.55 PC1038.1
N18687373: length 4.6
  TOP w0.203: v1(46.05,47.55) 45.78,47.28 PU1000.17
  GND1 w0.254: v1(46.05,47.55) 46.52,47.55 v3(46.52,47.56)
  GND3 w0.254: v3(46.52,47.56) 46.31,47.56 v4(46.16,47.71)
  BOTTOM w0.095: PR1042.1 v2(45.1,48.44)
  BOTTOM w0.254: PR1042.1 46.16,48.35 v4(46.16,47.71)
N18687382: length 4.5
  TOP w0.203: v1(45.5,48.7) 45.28,48.48 PU1000.20
  GND1 w0.254: v1(45.5,48.7) 45.44,48.76 v3(45.44,49.1)
  GND3 w0.254: v3(45.44,49.1) 45.44,49.4 v4(45.51,49.47)
  BOTTOM w0.095: v4(45.51,49.47) 45.18,49.47 v2(44.9,49.75)
  BOTTOM w0.254: v4(45.51,49.47) 46.02,49.47 PR1037.1 46.08,50.41 PC1033.1
N18687384: length 2
  BOTTOM w0.095: v2(47.11,51.4) 46.98,51.28 PC1033.2
  BOTTOM w0.254: PR1039.1 47.87,50.43 PC1033.2
N18687414: length 3.2
  TOP w0.203: PU1000.47 37.53,46.08 36.65,45.19 PR1017.2 PR1012.2
N18687427: length 4.3
  TOP w0.203: PU1000.23 44.78,49.68 45.23,50.12 45.23,51.75 v2(45.02,51.95) 45.02,52.38 PR1049.1
N18687435: length 5.1
  TOP w0.203: PU1000.41 37.44,48.48 36.16,49.76 v1(36.16,49.79)
  GND1 w0.203: v3(36.86,50.09) 36.56,49.79 v1(36.16,49.79)
  GND3 w0.203: v3(36.86,50.09) 37.25,49.69 v4(37.35,49.69)
  BOTTOM w0.095: v4(37.35,49.69) 37.21,49.83 v2(36.3,49.83)
N18687438: length 5.2
  TOP w0.203: PU1000.48 37.68,45.68 37.11,45.1 v2(37.11,44.72) 37.11,44.19 36.41,43.49 35.07,43.49 PR1020.2
N18687442: length 5.8
  TOP w0.203: PR1022.2 39.84,41.46 39.84,43.31 40.57,44.04 PU1000.5
  TOP w0.254: PR1019.2 PR1022.2 40.06,41.17 PR1027.2
N18687451: length 47.6
  TOP w0.254: v1(38.31,41.21) 38.29,41.23 38.29,42.05 PR1011.1
  GND1 w0.254: v1(38.31,41.21) v3(38.66,41.21)
  GND3 w0.254: v6(38.79,40.84) 38.79,41.08 v3(38.66,41.21)
  IN4 w0.254: v5(70.74,45.84) 70.64,45.94 69.86,45.94 69.47,45.55 69.47,42 70.54,40.94 70.54,38.7 70.26,38.42 66.07,38.42 64.62,36.98 64.62,36.67 64.23,36.28 62.68,36.28 59.12,39.83 53.83,39.83 50.88,42.79 48.41,42.79 47.74,42.12 46.06,42.12 45.48,42.7 42.12,42.7 39.87,40.45 39.17,40.45 v6(38.79,40.84)
N18687453: length 38.7
  TOP w0.095: v8(71.35,38.82) 71.07,38.82 v2(70.66,38.41)
  IN1 w0.254: v8(71.35,38.82) 71.2,38.97 70.07,38.97 69.85,38.75 66.37,38.75 64.76,37.15 64.76,36.51 64.17,35.91 63.3,35.91 61.45,37.75 61.45,38.55 61.05,38.96 58.91,38.96 58.05,38.09 47.84,38.09 47.41,37.66 43.78,37.66 41.67,39.78 41.67,41.32 41.71,41.37 v9(41.71,41.41)
  GND1 w0.254: v9(41.71,41.41) 41.98,41.68 v3(41.98,41.72)
  GND3 w0.254: v4(42.15,42.04) 42.15,41.9 v3(41.98,41.72)
  BOTTOM w0.254: PH1002.1 v8(71.35,38.82)
N18687460: length 29.2
  TOP w0.095: v7(38.8,57.26) v2(37.77,57.26)
  IN1 w0.254: v9(51.57,52.32) 51.57,50.71 51.24,50.39 49.34,50.39 48.89,49.94 47.7,49.94 47.25,50.39 46.53,50.39 45.6,51.31 45.6,54.17 44.83,54.95 39.4,54.95 38.8,55.55 v7(38.8,57.26)
  GND1 w0.254: v3(51.84,52.63) 51.57,52.35 v9(51.57,52.32)
  GND3 w0.254: v3(51.84,52.63) 52.09,52.87 v4(52.09,52.89)
  BOTTOM w0.254: v4(52.09,52.89) 52.21,53.01 52.21,57.75 53.34,58.88 PH1001.2
N18687461: length 32.4
  IN1 w0.254: v9(48.09,51.11) 48.09,51.54 48.68,52.14 49.33,52.14 52.11,54.91 52.11,58.01 53.41,59.3 55.35,59.3 55.67,58.98 60.21,58.98 61.63,60.41 61.63,63.2 62.82,64.38 66.59,64.38 v9(66.74,64.23)
  GND1 w0.203: v3(67.11,64.37) 67.09,64.37 67.08,64.36 66.87,64.36 66.87,64.36 v9(66.74,64.23)
  GND1 w0.254: v9(48.09,51.11) 48.2,51.11 v3(48.41,50.89)
  GND3 w0.203: v4(67.55,64.03) 67.43,64.03 67.11,64.34 v3(67.11,64.37)
  GND3 w0.254: v3(48.41,50.89) 48.55,50.76 v4(48.78,50.76)
  BOTTOM w0.095: v4(48.78,50.76) v2(48.78,51.8)
  BOTTOM w0.203: v4(67.55,64.03) 67.55,64.7 67.87,65.02 PH1003.2
N18687486: length 3.1
  TOP w0.095: PC1009.2 40.1,39.34 39.66,38.91 38.36,38.91 v2(38.23,39.03)
  TOP w0.254: PC1009.2 PR1022.1
N18687490: length 0.9
  BOTTOM w0.254: PR1042.2 47.03,48.39 PC1034.1
N18687497: length 0.9
  TOP w0.254: PC1015.1 42.64,53.77 PR1028.2
N18687570: length 3.5
  TOP w0.095: PC1008.2 40.82,38.91 40.82,38.14 v2(41.54,37.42)
  TOP w0.254: PC1008.2 40.98,39.68 PR1019.1
N18689541: length 2.6
  TOP w0.127: PC1109.1 71.35,64.12 v2(71.66,64.42)
  TOP w0.508: PR1101.2 70.41,64.09 PC1109.1
N18689543: length 1.1
  TOP w0.095: 69.29,53.31 v2(70.35,53.31)
N18689566: length 44.7
  TOP w0.254: PR1104.1 49.54,49.6 v1(49.82,49.6)
  TOP w0.508: PR1101.1 v2(70.41,58.66) 70.41,58.46 v8(70.88,58)
  GND1 w0.254: v1(49.82,49.6) 49.82,50.09 v3(49.82,50.09)
  IN2 w0.254: v3(49.82,50.09) 49.37,50.55 49.37,50.7 48.02,52.05 48.02,53.86 48.69,54.52 49.57,54.52 49.82,54.27 52.28,54.27 53.43,53.13 59.56,53.13 60.06,52.63 61.45,52.63 62.46,53.64 62.46,57.1 64.22,58.86 66.7,58.86 67.83,57.73 68.66,57.73 70.02,59.08 72.02,59.08 73.03,60.09 73.03,61.25 v8(72.91,61.36)
  BOTTOM w0.254: PL1100.1 v8(72.91,61.36)
N18689603: length 2.7
  BOTTOM w0.254: PC1101.1 62.93,62.86 62.38,62.31 62.38,61.4 62.49,61.3 PU1100.5
N18689605: length 3.1
  BOTTOM w0.254: PR1100.1 61.54,60.97 62,61.43 62,63.18 62.02,63.19 PC1101.2
N18689606: length 2.9
  BOTTOM w0.095: PR1100.2 61.09,59.57 v2(60.52,59)
  BOTTOM w0.254: PU1100.3 62.27,60.3 PR1100.2
N18689649: length 2.2
  BOTTOM w0.095: PC1111.1 v2(62.12,52.61)
  BOTTOM w0.254: PU1101.5 62.6,51.7 62.6,51.7 PC1111.1
N18689651: length 2.2
  BOTTOM w0.095: v2(60.67,49.77) 61.23,50.32 PR1109.1
  BOTTOM w0.508: PC1111.2 61.2,50.86 PR1109.1
N18689652: length 2.7
  BOTTOM w0.095: PR1109.2 61.94,50.63 v2(61.94,49.55)
  BOTTOM w0.254: PR1109.2 62.6,50.83 62.73,50.7 PU1101.3
N18689661: length 4.2
  TOP w0.095: v1(62.09,49.33) 61.56,49.87 v2(60.24,49.87)
  TOP w0.254: PR1103.2 62.11,49.32 v1(62.09,49.33)
  GND1 w0.254: v1(62.09,49.33) 62.59,49.33 v3(62.83,49.57)
  GND3 w0.254: v3(62.83,49.57) 62.96,49.7 v4(63.16,49.7)
N18689690: length 3.8
  TOP w0.095: PR1111.2 v2(62.06,52.57)
  TOP w0.254: PR1111.2 62.07,51.54 PR1108.2 62.07,50.27 v8(62.35,49.99)
  BOTTOM w0.254: PU1101.2 62.73,50.2 62.73,50.2 62.56,50.2 v8(62.35,49.99)
N18690739: length 1.9
  TOP w0.095: PR1151.2 v2(74.21,39.81)
N18690750: length 2
  BOTTOM w0.254: 63.53,43.86 63.62,43.77 63.62,43.41 63.8,43.23 PU1150.5
  BOTTOM w0.508: PC1151.1 63.02,44.37 63.3,44.09 63.3,44.09 63.53,43.87 63.53,43.86
N18690752: length 0.9
  BOTTOM w0.508: PR1150.1 PC1151.2
N18690753: length 1.6
  BOTTOM w0.254: PU1150.3 63.6,42.23 63.05,41.68 PR1150.2
N18695182: length 3.1
  BOTTOM w0.254: PU1401.5 157.32,73.2 157.06,73.45 156.6,73.45 156.34,73.71 PR1422.1 155.26,73.99 PR1421.1
N18695231: length 2.4
  BOTTOM w0.254: PR1409.1 PR1408.2 161.74,57.73 162,57.47 PU1400.5
N18695251: length 4
  BOTTOM w0.095: PR1423.2 161.79,51.91 v2(161.32,51.44)
  BOTTOM w0.254: PR1423.2 162.29,51.91 PR1400.2 163.17,52.32 163,52.49 PU1400.14
N18695252: length 3.9
  BOTTOM w0.254: PR1424.2 159.48,66.94 PR1411.2 158.06,67.41 158.06,68.41 158.3,68.65 158.3,68.65 158.32,68.66 PU1401.14
N18696495: length 3.2
  BOTTOM w0.254: PU1501.5 71.07,31.13 71.5,30.7 PR1531.2 71.1,29.86 70.92,29.86 PR1530.1
N18696540: length 2.6
  BOTTOM w0.254: PU1500.5 60.35,31.72 61.33,30.74 PR1509.1 61.33,30.71 PR1506.2
N18696541: length 2.9
  TOP w0.095: v8(60.08,31.29) v2(60.08,30.74)
  TOP w0.254: PR1526.1 60.35,31.57 v8(60.08,31.29)
  BOTTOM w0.254: PU1500.6 59.85,31.52 v8(60.08,31.29) 60.44,30.94 PR1510.1
N18696557: length 2.4
  BOTTOM w0.254: PR1500.2 58.88,36.61 58.9,36.63 PR1522.2 59.32,36.18 59.27,36.13 59.27,35.7 59.35,35.61 PU1500.14
N18696559: length 3
  BOTTOM w0.254: PR1511.2 PR1523.2 69.75,36.39 70.07,36.08 PU1501.14
N18696560: length 2.7
  BOTTOM w0.254: PR1525.2 PR1524.1 64.21,29.35 PR1515.1 65.09,29.36 PR1514.1
N18696573: length 3.1
  TOP w0.254: PR1520.1 v2(71.64,29.54) 71.93,29.54 v8(72.13,29.34)
  BOTTOM w0.254: PR1519.2 72.17,29.38 v8(72.13,29.34) PR1531.1
N18696576: length 4.8
  TOP w0.095: v1(69.51,29.54) v2(69.51,28.4)
  GND1 w0.254: v1(69.51,29.54) 69.39,29.54 v3(69.08,29.85)
  GND3 w0.254: v4(69.55,30.28) 69.5,30.28 v3(69.08,29.85)
  BOTTOM w0.254: PU1501.6 70.57,30.86 70.42,30.71 PR1530.2 69.55,30.27 v4(69.55,30.28)
N18758153: length 5.1
  BOTTOM w0.095: YC1.3 117.39,72.17 118.29,71.27 118.29,69.44 RC59.2 118.18,69.09 CC6.1 117.67,68.97 RC375.1
N18758183: length 4.2
  BOTTOM w0.095: YC1.1 118.77,70.52 118.63,70.38 118.63,69.93 119.27,69.29 CC7.1 119.27,68.83 119.14,68.7 RC376.1 118.51,68.31 RC59.1
N18759595: length 22.1
  TOP w0.254: PR1158.1 41.47,57 42.54,57 43.35,56.2 44.6,56.2 45.19,56.79 50.32,56.79 v2(51.02,57.49) 52.3,58.77 55.28,58.77 55.99,58.06 55.99,56.33 56.56,55.75 v8(56.79,55.75)
  TOP w0.508: PR1157.1 v8(54.61,57.69)
  BOTTOM w0.254: PL1151.1 56.75,55.8 v8(56.79,55.75)
N18759629: length 2.6
  TOP w0.095: PC1166.1 v2(56.31,53.02)
  TOP w0.508: PC1166.1 55.03,53.02 55.03,53.74 PR1157.2
N18759898: length 0.9
  BOTTOM w0.508: PR1156.1 PC1165.1
N18759902: length 2.2
  BOTTOM w0.254: PU1151.5 53.84,45.83 53.19,45.18 PR1156.2
N18759906: length 3.5
  BOTTOM w0.254: PC1165.2 56.21,45.75 55.09,45.75 54.84,46.01 PU1151.3
N18776555: length 7.9
  TOP w0.095: PR326.1 v2(60.37,5.14)
  TOP w0.203: PR326.1 61.36,6.37 60.76,6.37 PR325.2 60.97,8.08 PC352.1 61.46,9.2 61.84,9.58 62.42,9.58 62.62,9.78 PU300.25
N18960099: length 1.1
  BOTTOM w0.508: PC605.2 121.44,2.38 121.97,2.38 PR612.1
N19171666: length 22.1
  TOP w0.095: v7(294.73,70.69) v2(293.92,70.69) LED6.2 ; v7(288.58,55.94) 288.29,56.23 R288.2
  IN1 w0.076: v7(288.58,55.94) 288.81,55.94 291.84,58.96 291.84,59.52 294.01,61.69 295.13,61.69 295.81,62.37 295.81,66.32 295.34,66.79 295.34,70.09 294.74,70.69 v7(294.73,70.69)
N19330817: length 11.1
  TOP w0.095: R33.1 153.8,26.95 v2(154.32,26.44)
  GND1 w0.095: v3(153.34,27.21) 153.34,26.9 v1(153.29,26.85)
  GND3 w0.095: v3(153.34,27.21) 153.27,27.28 v6(153.27,27.53)
  IN4 w0.076: v5(151.34,34.45) 151.96,33.82 151.96,32.6 153.27,31.29 v6(153.27,27.53)
  BOTTOM w0.095: v5(151.34,34.45) JNGFF1.68
N19331723: length 6.4
  BOTTOM w0.095: R34.2 R35.2 160.69,38.43 161.26,37.87 161.26,35.07 161.11,34.93 161.11,34.91 160.9,34.7 JNGFF1.69
N19584540: length 16.4
  GND1 w0.095: v3(18.82,28.37) 18.82,28.64 v1(18.98,28.81) ; v1(13.27,36.25) 13.41,36.25 v3(13.67,35.98)
  IN3 w0.064: v3(13.67,35.98) 13.67,30.44 14.72,29.39 17.11,29.39 18.08,28.42 18.77,28.42 v3(18.82,28.37)
  GND3 w0.095: v3(18.82,28.37) 18.77,28.42 18.5,28.42 v4(18.3,28.21)
  BOTTOM w0.095: RT51.1 RT56.1 19.47,28.2 19.94,28.67 v2(19.94,30.11)
N19588651: length 2.5
  TOP w0.254: RT96.1 27.63,30.44 v2(27.75,30.44) 28.82,30.44 28.92,30.54 U20.L11
N19588867: length 22.5
  TOP w0.095: v7(24.44,34.24) 24.16,34.53 24.16,35.52 24.54,35.9 24.54,36.14 24.5,36.18 24.5,37.28 24.83,37.62 24.83,38.42 v2(24.84,38.44) 24.87,38.46 RT58.1
  IN1 w0.076: v7(24.44,34.24) 24.44,34.08 24.6,33.91 24.6,32.75 25.16,32.19 25.16,31.34 24.72,30.9 24.72,30.23 25.04,29.9 25.04,29.31 25.22,29.14 25.76,29.14 25.95,29.32 28.32,29.32 29.19,28.45 30.19,28.45 30.42,28.68 30.42,29.92 31.52,31.02 v1(31.52,31.04)
  GND1 w0.095: v3(30.71,30.5) 31.25,31.04 v1(31.52,31.04)
  GND3 w0.095: v3(30.71,30.5) v4(30.71,29.89)
  BOTTOM w0.095: RT62.1 v4(30.71,29.89) RT57.1
