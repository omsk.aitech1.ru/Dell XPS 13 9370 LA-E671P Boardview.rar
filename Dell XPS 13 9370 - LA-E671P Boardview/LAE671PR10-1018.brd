# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1.8VU_PWROK: length 3.9
  BOTTOM w0.095: PR905.1 158.29,8.86 157.84,9.32 157.84,10.43 v2(158.18,10.78)
  BOTTOM w0.203: PU900.4 157.68,7.92 158.29,8.53 PR905.1
3.3V_CAM_EN#: length 228.9
  IN2 w0.064: v3(161.8,10.47) 159.64,10.47 159.01,11.1 159.01,11.93 155.87,15.07 154.7,15.07 154.33,15.07 153.7,15.7 153.18,16.22 153.18,17.22 152.02,18.38 152.02,24.88 150.59,26.32 150.59,28.48 148.1,30.97 v3(147.04,30.97)
  GND3 w0.095: v3(161.8,10.47) 162.16,10.1 162.16,9.56 v6(162.13,9.53) ; v3(147.04,30.97) v6(146.49,30.97)
  IN4 w0.076: v6(162.13,9.53) 162.25,9.41 164.35,9.41 165.05,10.11 169.51,10.11 170.7,8.92 172.88,8.92 175,6.8 184.29,6.8 185.76,5.32 196.68,5.32 196.85,5.5 200.98,5.5 202.68,7.19 203.83,7.19 204.09,7.45 207.14,7.45 209.33,9.63 209.6,9.63 212.51,12.54 216.32,12.54 218.68,10.19 222.84,10.19 225.32,7.71 251.63,7.71 252.33,8.4 255.46,8.4 257.24,10.18 261.43,10.18 265.18,13.93 266.28,13.93 267.2,13.01 271.63,13.01 271.79,12.85 273.8,12.85 275.75,14.8 276.65,14.8 277.1,14.35 279.47,14.35 281.9,11.93 281.9,11.2 282.89,10.2 288.2,10.2 288.32,10.09 292.5,10.09 293.4,10.99 293.4,11.93 295.92,14.46 295.92,18.18 295.4,18.71 293.69,18.71 290.83,21.57 290.83,23.87 290,24.7 v5(289.46,24.7) ; v8(129.82,47.62) 130.24,47.21 130.24,46.38 131.11,45.51 132.72,45.51 138.34,39.9 139.87,39.9 141.4,38.38 141.4,35.39 145.82,30.97 v6(146.49,30.97)
  BOTTOM w0.095: v5(289.46,24.7) 288.42,24.7 287.92,25.2 287.92,25.97 289.09,27.14 QZ1.2 289.09,28.41 289.71,29.03 v2(289.94,29.03) 290.45,29.03 R100.1
  BOTTOM w0.112: UCPU1.AT15 129.68,47.62 v8(129.82,47.62)
3.3V_TS_EN: length 241.5
  TOP w0.095: v7(35.72,13.1) 36.23,13.62 36.23,15.38 36.61,15.75 36.61,18.89 36.41,19.08 36.41,21.82 37.65,23.06 37.65,24.22 37.75,24.32 37.75,26.27 37.98,26.5 37.98,32.41 38.18,32.6 38.18,38.23 36.25,40.16 32.23,40.16 29.41,42.97 28.98,42.97 28.62,43.32 28.62,44.71 30.81,46.9 30.81,52.68 29.55,53.93 29.55,54.27 29.71,54.43 v2(30.03,54.43) 30.77,55.18 30.77,58.05 31.35,58.63 39.69,58.63 46.3,65.24 51.15,65.24 51.26,65.14 51.26,64 51.16,63.9 R76.1 50.65,63.75 UZ1.4
  IN1 w0.076: v7(35.72,13.1) 36.55,12.27 48.32,12.27 52.73,7.87 60.7,7.87 61.27,7.3 66.09,7.3 66.53,6.85 70.66,6.85 71.15,6.36 72.49,6.36 72.78,6.64 75.63,6.64 80.01,11.02 99.37,11.02 102.22,13.88 103.64,13.88 103.97,14.21 v9(104.59,14.21)
  GND1 w0.095: v9(104.59,14.21) v3(104.18,14.21)
  IN3 w0.064: v3(104.18,14.21) 104.7,13.68 109.19,13.68 110.76,15.25 115.34,15.25 116.73,16.63 123.08,16.63 123.73,17.28 125.41,17.28 125.92,16.77 134.79,16.77 134.99,16.98 137.06,16.98 138.05,15.98 143.69,15.98 144.04,16.33 146.81,16.33 147.36,16.87 v8(147.36,17.56)
  IN4 w0.076: v8(147.36,17.56) 147.39,17.56 148.36,18.53 148.36,24.57 148.67,24.88 148.67,28.49 147.34,29.82 147.34,31.18 146.41,32.11 145.36,32.11 141.82,35.65 141.82,38.67 139.9,40.58 139.9,40.88 135.91,44.87 135.91,46.82 v8(134.45,48.28)
  BOTTOM w0.112: v8(134.45,48.28) 134.82,48.66 UCPU1.AP5
3V_FB: length 1.8
  BOTTOM w0.254: PU500.13 48.65,26.78 47.79,25.93 PC511.1
3V_SN: length 3.2
  TOP w0.095: v11(48.15,31.73) PR501.2
  TOP w0.508: PC510.1 49.84,30.36 PR501.2
5V_FB: length 1.5
  BOTTOM w0.254: PU501.13 37.25,25.48 36.89,25.84 PC525.1
5V_SN: length 1.5
  TOP w0.095: PC524.1 v2(38.76,28.2)
+0.6VS:
  vias: v1(120.49,13.98) v1(120.79,13.98) v1(121.1,13.98) v3(120.27,12.95) v3(120.78,12.95) v4(119.05,13.37) v4(119.36,13.37) v4(119.66,13.37) v7(88.2,14.78) v7(91.4,14.78) v7(98.39,15.4) v7(100.73,15.4) v7(107.32,14.95) v7(107.62,14.95) v7(115.94,16.9) v7(115.94,16.53) v11(104.78,14.32)
+1.0V_AMPHYPLL: length 10.4
  TOP w0.457: RC173.2 130.75,68.3 131.2,67.84 v11(131.2,66.99) 131.2,66.5 131.45,66.25 131.45,62.54 130.63,61.71 CC80.1
  TOP w0.508: v8(129.75,60.37) 130.12,60.37 130.63,60.88 CC80.1
  BOTTOM w0.254: UCPU1.L15 129.75,60.26 v8(129.75,60.37) 129.75,60.51 129.48,60.78 UCPU1.K15
+1.0V_APLL: length 14.5
  TOP w0.381: R4.1 141.26,55.07 RC177.2 141.4,55.37 139.4,57.36 v2(137.83,57.36) 137.33,57.36 137.01,57.04 134.84,57.04 134.81,57.07 133.47,57.07 133.44,57.04 132.69,57.04 132.68,57.03 129.79,57.03 v8(129.77,57.01)
  BOTTOM w0.254: UCPU1.V15 129.44,56.68 v8(129.77,57.01)
+1.0V_APLLEBB: length 10.4
  TOP w0.102: v2(127.32,56.78) 126.52,57.58 CC79.1
  IN1 w0.508: 129.01,61.17 128.46,60.63 128.46,59.95 127.65,59.15 ; 129.98,63.23 129.98,63.95 133.46,67.43 133.46,67.97
  GND3 w0.254: v4(127.49,59.11) v3(127.49,58.74)
  vias: v7(126.39,57.75) v7(126.64,57.83) v7(133.25,68.79) v7(133.58,68.79) v9(127.15,58.81) v9(127.15,58.54)
+1.0V_CLK: length 33.5
  TOP w0.381: CC83.1 132.23,67.5 v8(131.84,67.9)
  TOP w0.508: 128.18,64.73 128.44,64.98 RC175.2 ; v7(112.28,65.73) 112.12,65.58 112.12,64.94 111.8,64.61 RC64.2
  IN1 w0.508: v7(112.28,65.73) 112.36,65.81 122.09,65.81 122.5,65.4 125.19,65.4 127.42,67.63 128.19,67.63 128.82,67 v8(129.52,67) 131.11,67 131.84,67.73 v8(131.84,67.9)
  BOTTOM w0.203: UCPU1.A14 129.76,66.76 v8(129.52,67)
  BOTTOM w0.254: v8(131.84,67.9) 132.24,67.5 UCPU1.A10 ; v8(127.15,60.38) 127.15,60.47 UCPU1.K19 ; v8(126.56,60.36) 125.93,60.36 125.54,59.96 UCPU1.L21 ; UCPU1.L19 126.53,59.64 v8(126.53,59.57) 126.19,59.23 UCPU1.N20
  vias: v2(129.76,66.15)
+1.0V_DTS: length 3.2
  BOTTOM w0.254: 138.35,58.19 138.23,58.07 UCPU1.T1
  BOTTOM w0.508: 138.35,58.19 138.91,58.76 v2(139.14,58.76) 140.1,58.76 RC169.2
+1.0V_MPHYAON: length 5
  TOP w0.102: RC168.2 v11(138.49,62.19)
  TOP w0.381: CC64.1 127.81,59.6 v8(127.81,60.37)
  TOP w0.508: RC168.2 137.06,61.37 v8(137.73,60.71)
  BOTTOM w0.254: UCPU1.L1 137.71,60.72 137.71,60.71 v8(137.73,60.71) ; v8(127.81,60.37) 128.14,60.69 UCPU1.K17
+1.0V_MPHYGT: length 2.8
  BOTTOM w0.254: UCPU1.N16 129.04,59.36 v8(129.04,59.53) ; UCPU1.N17 128.44,58.8 v8(128.44,58.68) ; UCPU1.P15 129.44,58.18 v8(129.11,57.85) ; v8(129.11,58.69) 128.79,58.36 UCPU1.P16 ; UCPU1.N15 129.44,59.1 v8(129.85,58.69)
  vias: v8(130.12,71.49) v8(130.48,71.95) v8(130.85,71.48) v8(131.23,71.95) v8(131.64,71.48) v8(132.01,71.95) v11(133.14,71.94)
+1.0V_PRIM_CORE: length 4
  TOP w0.102: v11(148.4,58.3) 147.8,58.3 v8(147.67,58.42)
  TOP w0.305: CC66.1 127.79,54.41 127.16,53.78 v8(127.16,53.66)
  BOTTOM w0.254: UCPU1.V20 126.19,56.68 v8(126.49,56.98) ; v8(127.16,53.66) 127.16,53.57 UCPU1.AF18 ; v8(125.84,56.99) 125.84,56.85 125.59,56.59 UCPU1.V21 ; UCPU1.AF19 126.52,53.56 v8(126.52,53.68)
  vias: v8(147.63,57.83) v8(152.96,65.35) v8(152.97,64.76) v8(153.57,65.36) v8(153.59,64.77) v8(154.23,65.37) v8(154.24,64.75)
+1.0V_PRIM_COREP: length 13.9
  TOP w0.254: v8(156.04,72.78) 152.88,72.78 152.43,72.33 v2(152.43,70.02) 152.43,68.05 152.86,67.61 154.49,67.61 155.16,66.95 v8(155.16,65.21)
  BOTTOM w0.254: v8(156.04,72.78) 155.79,73.03 PR1421.2
+1.0V_SRAM: length 20.8
  TOP w0.102: v2(124.68,57.58) 124.84,57.73 v8(124.84,58.52)
  TOP w0.381: CC78.1 125.63,53.37 125.85,53.6 v8(125.85,53.68)
  IN1 w0.508: v7(132.18,68.9) 132.56,68.52 132.56,67.46 131.35,66.25 129.45,66.25 127.92,64.72 127.92,63.57 127.36,63.01 ; 125.62,59.02 125.9,59.3 125.9,60.75 126.28,61.13
  BOTTOM w0.254: 125.85,53.62 v8(125.85,53.68) ; 125.85,53.62 126.19,53.29 UCPU1.AF20 ; 125.85,53.62 125.85,53.6 125.54,53.28 UCPU1.AF21 124.75,54.02 124.75,58.16 ; UCPU1.T19 UCPU1.T20
+1.0V_VCCST: length 219
  TOP w0.381: v8(125.26,60.37) 124.83,60.8 CC31.1
  TOP w0.508: 33.57,57.34 PR1004.1 33.57,46.72 33.56,46.71 PR1003.1 33.56,45.21 PC1001.1 ; RE147.1 11.81,19.32 10.73,19.32 v8(10.62,19.44) ; v7(55.12,66.52) 54.63,66.03 45.93,66.03 v11(42.78,62.88) 39.42,59.52 35.47,59.52 ; v8(99.65,72.19) 98.85,72.99 87.95,72.99 84.55,69.59 78.17,69.59 77.66,70.1 71.72,70.1 69.7,68.09 v7(68.05,68.09) ; R101.2 137.82,71.4 138.33,71.9 CZ1.1 138.33,72.82 137.57,73.58 126.02,73.58 123.87,71.42 123.87,70.15 124.61,69.4 124.61,68.44 125.22,67.82 126.79,67.82 127.61,67 v8(127.61,66.89) 127.28,66.56 v7(127.28,66.26) 127.26,66.28 CC96.1
  IN1 w0.508: v7(127.28,66.26) 125.07,64.04 125.07,62.49 124.67,62.1 124.67,61.38 125.26,60.79 v8(125.26,60.37) ; v7(55.12,66.52) 56.69,68.09 v7(68.05,68.09) ; 39.16,32.6 39.15,32.6 38.77,32.97 38.77,32.98 38.25,33.5 38.25,38.92 37.31,39.86 37.31,40.5 37.79,40.98 37.79,42.78 37.83,42.83 37.83,43.68 37.04,44.47 35.67,44.47 35.49,44.65 33.74,44.65 33.57,44.83
  GND1 w0.508: v3(5.45,27.95) v1(5.83,27.95)
  IN3 w0.508: v3(5.45,27.95) 5.13,27.63 5.13,26.45 9.36,22.22 10.17,22.22 10.62,21.78 v8(10.62,19.44) 10.62,19.38 12.15,17.84 13.78,17.84 14.12,18.18 14.12,18.2 14.17,18.26 14.17,18.76 14.12,18.82 v8(14.12,19.56)
  GND3 w0.254: v4(38.57,32.26) 38.7,32.26 39.03,31.93 v3(39.03,31.83) 39.02,31.85 v4(38.57,31.85)
  IN4 w0.254: v8(125.26,60.37) 124.41,60.37 124.06,60.02 123.24,60.02 120.85,57.62 113.55,57.62 111.88,59.29 109.49,59.29 109.18,59.6 109.18,60.64 107.77,62.04 107.02,62.04 105.8,63.26 105.8,63.72 105.64,63.89 105.64,64.62 105.49,64.77 105.49,67.96 104.81,68.64 104.81,68.96 105,69.14 105,69.76 104.34,70.42 103.94,70.42 v5(103.85,70.5)
  BOTTOM w0.178: v8(127.61,66.89) 127.61,66.64 127.28,66.31 UCPU1.A18
  BOTTOM w0.254: UCPU1.K20 UCPU1.K21 125.54,60.64 v8(125.26,60.37)
  BOTTOM w0.508: v8(14.12,19.56) 17.49,19.56 18.53,20.6 21.17,20.6 22.16,21.58 24.11,21.58 25.9,23.37 27.45,23.37 27.75,23.07 28.28,23.07 30.05,24.84 33.79,24.84 33.79,24.84 33.92,24.84 34.76,25.69 34.76,27.85 35.9,28.98 35.9,30.99 36.87,31.96
  vias: v7(33.37,57.72) v7(33.47,45.28) v7(33.67,57.74) v7(33.65,45.08) v7(34.67,59.72) v7(34.67,59.38) v9(39.03,32.21) v9(39.28,32.21)
+1.0V_VCCSTG: length 275.3
  TOP w0.508: v7(69.21,67.16) 69.81,67.16 v11(71.97,69.32) 72.12,69.47 77.39,69.47 77.91,68.96 84.83,68.96 88.23,72.36 94.07,72.36 ; 140.71,74.2 140.66,74.24 125.77,74.24 123.14,71.62 123.14,69.98 122.21,69.05 122.21,66.87 122.51,66.57 124.28,66.57 CC29.1 124.39,66.67 124.39,67.36 v8(124.59,67.56) 125.03,67.11 RC153.2
  IN1 w0.508: v8(53.63,60.41) 53.63,63.59 57.2,67.16 v7(69.21,67.16) ; v8(124.59,67.56) 124.59,68.06 125.02,68.49 125.02,69.98 v8(124.71,70.29) ; 141.42,74.23 141.42,74.22 143.94,74.22 145.68,72.48 147.57,72.48 148.83,71.22 151.71,71.22 v8(151.72,71.21) ; v9(153.94,60.41) 153.94,58.12 153.72,57.9 153.72,52.49 156.63,49.59 159.33,49.59 162.62,46.3 162.62,40.21 163.36,39.46 163.99,39.46 166.39,37.07 167.63,37.07 169.98,34.71 169.98,29.04 165.87,24.93 155.65,24.93 151.83,21.1 151.83,20.46 150.95,19.59 149.6,19.59 149,18.99 149,18.71 147.98,17.69 v8(147.98,17.36)
  GND1 w0.508: v3(153.75,60.96) 153.87,60.83 153.87,60.48 v9(153.94,60.41)
  IN2 w0.508: v3(40.63,39.53) 40.18,39.98 40.18,49.8 41.24,50.87 43.08,50.87 43.96,51.75 43.96,54.35 46.96,57.35 48,57.35 49.16,58.5 51.01,58.5 52.92,60.41
  IN3 w0.508: v3(40.63,39.53) 42.34,37.82 47.86,37.82 48.45,38.41 55.72,38.41 59.19,34.94 60.45,34.94 63.51,31.88 v8(63.51,31.01)
  GND3 w0.508: v6(153.35,61.12) 153.59,61.12 v3(153.75,60.96)
  IN4 w0.508: v6(153.35,61.12) 153.35,61.28 153.43,61.36 153.43,62.61 152.28,63.76 152.28,70.64 v8(151.72,71.21)
  BOTTOM w0.178: v8(124.59,67.56) 124.59,66.92 124.8,66.7 UCPU1.A22
  BOTTOM w0.381: 97.94,73.67 97.58,74.03 94.58,74.03 94.03,73.48 RC239.2 RC240.2 RC242.1 ; v8(63.51,31.01) 63.29,30.79 PR1525.1
  BOTTOM w0.508: v8(98.12,72.12) 98.27,72.28 98.27,72.79 98.45,72.97 98.45,73.67 ; 97.94,73.67 98.45,73.67 ; 98.45,73.67 98.78,74 102.96,74 104.61,72.34 RC230.2 105.98,72.04 108.42,74.48 122.49,74.48 124.48,72.49 124.48,70.51 v8(124.71,70.29) ; v8(147.98,17.36) 148.01,17.34 148.01,16.83 148.05,16.79 148.05,15.73 148.07,15.7 CZ5.1 149.51,15.01 149.62,14.9 R102.2
  vias: v7(141.45,74.17) v7(141.71,74.17)
+1.0V_VCCSTG_R: length 4.4
  TOP w0.254: RC153.1 125.36,65.13 126.62,63.87 v2(126.62,63.55) v8(126.21,63.14)
  BOTTOM w0.254: UCPU1.G20 126.21,62.66 v8(126.21,63.14)
+1.0VA: length 127.6
  TOP w0.254: v7(138.17,63.69) 138.07,63.59 RC168.1
  TOP w0.381: v8(126.49,54.52) 126.53,54.57 126.59,54.63 126.59,55.14 CC67.1
  IN1 w0.305: 140.3,58.67 139.78,59.19 139.78,61.13 138.17,62.74 v7(138.17,63.69) ; v8(127.16,56.18) 127.16,56.04 127.56,55.64 128.07,55.64 128.53,56.1 130.55,56.1 131.04,56.59 132.87,56.59 133.31,57.03 136.36,57.03 136.88,57.55 139.27,57.55 140.18,58.46 140.39,58.24
  IN1 w0.483: 40.66,65.95 40.66,66.76 39.8,67.62 39.8,69.8 40.08,70.08 40.08,71.84 41.56,73.32 53.14,73.32 53.5,72.96 54.13,72.96 54.47,72.61 57.02,72.61 57.42,73.02 78.41,73.02 80.09,71.34 82.95,71.34 84.62,73 94.5,73 94.63,72.88 101.34,72.88 103.09,71.13 108.52,71.13 112.35,67.3 121.48,67.3 122.74,66.05 124.93,66.05 127.23,68.35 v7(128.21,68.35)
  BOTTOM w0.254: UCPU1.AB20 126.49,54.62 v8(126.49,54.52) 126.53,54.57 126.84,54.87 UCPU1.AB19 ; UCPU1.P18 127.49,58.23 v8(127.86,57.85) ; v8(127.16,56.18) 127.49,55.85 UCPU1.Y18 127.49,55.57 UCPU1.AB17
  BOTTOM w0.508: v8(142.25,59) 141.73,59 RC169.1
  vias: v1(140.32,72.36) v1(140.54,72.5) v3(140.18,72.77) v3(145.9,14.25) v3(146.32,14.25) v3(146.75,14.27) v3(147.18,14.25) v3(147.62,14.25) v3(148.05,14.25) v3(148.47,14.25) v3(148.89,14.25) v4(145.85,12.9) v4(146.11,12.9) v4(146.44,12.97) v4(146.71,13.28) v4(146.71,12.97) v4(147.22,13.02) v4(147.5,13.02) v4(147.78,13.02) v4(148.05,13.02) v4(148.32,13.02) v4(148.59,13.02) v4(148.72,12.74) v4(148.87,13.01) v4(149.02,12.73) v4(149.13,13.01) v5(126.19,50.73) v7(39.9,65.79) v7(40.19,65.79) v7(143.06,55.89) v7(143.35,55.9) v8(125.42,71.72) v8(126.04,71.73) v11(126.23,68.41)
+1.0VA_XDP: length 116.9
  TOP w0.305: JXDP1.43 40.48,70.86 40.18,70.56 JXDP1.44 40.18,69.63 39.71,69.16 v11(39.71,68.59) 39.71,68.41 40.32,67.79 CC85.1
  TOP w0.356: CC85.1 CC86.1 39.7,66.99 RC251.2
  TOP w0.508: v7(105.75,72.85) 104.12,74.49 86.58,74.49 83.86,71.77 v7(83.86,71.06) ; v8(41.49,66.73) 41.4,66.64 RC251.2 ; v7(121.35,68.39) 121.27,68.39 120.9,68.76 v7(118.45,68.76)
  IN1 w0.508: v8(129.19,68.94) 129.19,69.59 127.83,70.95 123.91,70.95 v7(121.35,68.39) ; v8(41.49,66.73) 41.98,67.22 41.98,70.47 41.2,71.24 41.2,72.08 41.82,72.7 52.78,72.7 53.53,71.95 57.35,71.95 57.79,72.39 78.16,72.39 79.83,70.72 83.51,70.72 v7(83.86,71.06) ; v7(105.75,72.85) 108.86,72.85 112.96,68.76 v7(118.45,68.76)
  IN4 w0.381: v8(129.19,68.94) 129.19,68.95 129.19,69.6 129.8,70.2 132.06,70.2 132.37,70.52 v4(132.75,70.52)
  BOTTOM w0.508: RC226.1 129.19,68.95 v8(129.19,68.94)
+1.0VAP: length 4.1
  BOTTOM w0.305: PC706.1 136.82,11.39 PR702.1 137.33,11.41 138.26,12.34 139.65,12.34
  vias: v1(140.24,11.7) v1(140.5,11.7) v1(140.76,11.69) v1(141.02,11.68) v1(141.29,11.69) v1(141.56,11.69) v2(139.99,10.78) v3(140.03,12.46) v3(141.04,12.47) v3(141.59,12.47) v3(142.14,12.47) v4(140.01,12.13) v4(140.28,12.13) v4(140.62,12.13) v4(140.89,12.13) v4(141.15,12.12) v4(141.42,12.13) v4(141.68,12.12) v4(141.95,12.12)
+1.0VS_VCCIO: length 204.3
  TOP w0.102: RC8.1 v11(106.52,62.32)
  GND1 w0.254: v1(122.84,51.14) v3(122.84,50.79)
  IN3 w0.508: v8(5.75,29.52) 6.7,30.47 6.7,31.55 8.32,33.17 8.32,35.64 7.43,36.53 7.43,37.5 9.11,39.17 9.11,40.17 9.97,41.04 9.97,42.61 9.46,43.13 9.46,46.08 10.26,46.88 10.26,49.72 12.12,51.58 12.12,53.92 13.76,55.56 13.76,60.92 14.57,61.73 14.57,61.75 14.6,61.75 14.66,61.82 v8(16.62,61.82)
  IN4 w0.254: 131.96,74.38 109.46,74.38 109.09,74.01 96.19,74.01 94.95,72.77 94.27,72.77 93.77,73.27 91.24,73.27 90.94,73.57 86.81,73.57 85.44,72.21 83.82,72.21 83.06,71.45 79.96,71.45 78.23,73.18 61.43,73.18 61.07,72.82 58.95,72.82 58.38,73.38 42.81,73.38 40.16,70.74 40.16,69.93 37.53,67.3 34.28,67.3 27.72,60.73 19.82,60.73 18.73,61.82 v8(16.62,61.82)
  IN4 w0.508: 107.85,61.09 108.49,60.45 108.49,59.55 109.29,58.75 111.38,58.75 112.79,57.34 112.79,53.29 113.26,52.83 ; 119.45,53.31 120.28,54.15 120.28,55.08 121.78,56.58 121.78,57.44 122.21,57.88 125.17,57.88 125.71,58.41 125.71,59.01 125.88,59.19 125.88,60.6 126.39,61.11 127.38,61.11 127.51,60.98 130.68,60.98
  BOTTOM w0.254: UCPU1.AM42 114.27,49.57 v8(114.35,49.57) 114.34,49.58 114.34,50.42 UCPU1.AL42
  BOTTOM w0.508: QE13.1 12.93,27.93 11.91,28.96 6.13,28.96 5.75,29.33 v8(5.75,29.52)
  vias: v1(107.62,62.2) v1(107.86,62.35) v3(107.87,61.88) v3(112.85,50.72) v3(113.28,50.73) v3(113.7,50.72) v3(114.15,50.73) v3(119.82,50.38) v3(120.25,50.36) v3(120.67,50.35) v3(121.13,50.34) v3(127.64,49.99) v3(127.84,50.37) v5(132.81,74.17) v5(132.89,71.3) v5(133.08,74.17) v5(133.25,71.27) v6(107.64,61.6) v6(107.64,61.33) v8(112.88,51.7) v8(119.82,49.57) v8(120.73,51.1) v8(120.73,49.57) v8(122.32,51.78) v8(152.29,50.93) v8(152.31,50.33) v8(152.83,49.71) v8(152.93,50.31) v8(153.32,49.19) v8(153.43,49.77)
+1.0VS_VCCIOP: length 12.7
  IN1 w0.254: v9(157.84,52.75) 156.75,53.84 156.75,57.35 157.44,58.04 160.12,58.04 v9(160.13,58.05)
  GND1 w0.254: v9(157.84,52.75) 157.93,52.67 v3(158.2,52.67) ; v9(160.13,58.05) 160.38,58.05 v3(160.48,58.16)
  GND3 w0.254: v4(160.82,58.25) 160.57,58.25 v3(160.48,58.16) ; v3(158.2,52.67) 158.2,52.62 v4(157.75,52.17)
  BOTTOM w0.102: 156.69,51.61 v2(156.69,49.45)
+1.2V_DDR: length 259.5
  TOP w0.095: v8(103.28,18.64) 103.38,18.74 UD41.F2
  TOP w0.203: UD44.E12 122.75,27.23 123.08,27.56 123.08,28.31 v8(123.26,28.49)
  TOP w0.254: UD44.L5 126.54,21.7 v8(126.23,22.02) 126.23,21.96 UD44.K5 125.57,21.95 v8(125.57,22.02) 125.89,22.34 UD44.K6 ; UD41.P4 108.57,20.82 108.36,21.04 108.36,21.4 UD41.P5 108.58,21.7 v8(108.9,22.03) 108.58,22.35 UD41.P6 ; UD41.H8 104.68,23.95 104.95,23.68 v8(104.95,23.59) ; v8(124.27,22.03) 124.59,21.7 UD44.H5 ; v8(124.27,22.03) 123.94,21.7 UD44.G5 ; v8(124.27,22.03) 124.27,22.1 UD44.H6 ; UD44.J6 125.24,22.36 v8(124.92,22.03) 124.92,21.95 UD44.J5 ; UD43.N8 143.41,23.95 v8(143.74,23.63) ; UD42.L2 91.11,18.94 v8(91.3,18.75) 91.33,18.75 91.76,19.18 UD42.M2 ; v8(146.48,26.13) 146.33,26.13 146.04,26.43 UD43.U11 ; UD42.K12 UD42.L12 ; UD42.K12 90.46,28.08 90.15,28.4 v8(89.85,28.4) 89.62,28.4 89.36,28.14 89.36,27.43 UD42.H12 ; UD42.K12 UD42.K11 ; UD43.E8 138.21,23.95 v8(138.54,23.63) ; v8(92.25,23.48) 92.41,23.64 UD42.N8 ; UD42.E12 87.12,27.23 86.81,27.54 86.81,28.12 v8(87.28,28.6) 87.63,28.95 88.32,28.95 ; UD41.G12 UD41.H12 UD41.H11 ; v8(87.63,18.73) 87.86,18.96 UD42.F2 ; v8(124.27,19.63) 124.59,19.95 UD44.H3 ; UD44.P6 128.49,22.35 128.17,22.03 v8(128.17,22.03) 128.17,22.03 128.49,21.7 UD44.P5 128.49,21.55 128.17,21.23 v8(128.17,21.22) 128.18,21.22 128.49,20.9 UD44.P4 ; UD42.R12 93.96,27.47 93.96,28 v8(93.7,28.26) ; UD41.U8 110.65,24.15 110.65,24.66 110.53,24.78 UD41.U9 v8(111.08,24.83) ; UD41.N8 107.93,23.95 v8(108.26,23.63) ; UD41.H5 104.68,21.7 v8(104.36,22.03) 104.03,21.7 UD41.G5 ; v8(119.09,23.55) 118.48,23.55 117.92,22.99 CD53.1 ; v8(119.09,23.55) 119.57,23.55 UD44.A8 ; v8(119.09,23.55) 119.09,24.26 119.65,24.83 UD44.A9 ; v8(122.46,23.53) 122.64,23.71 UD44.E8 ; CD59.1 97.06,25.83 96.6,25.83 95.79,26.63 v8(95.66,26.63) 95.22,26.63 UD42.U11 ; UD41.J5 105.33,21.7 v8(105.66,22.03) 105.98,22.35 UD41.K6 ; UD41.J6 105.33,22.36 v8(105,22.03) ; UD43.E12 138.21,27.23 137.18,28.27 v8(137.13,28.27) ; v8(90.8,22.04) 91.11,21.72 UD42.L5 ; v8(90.8,22.04) 90.46,21.7 UD42.K5 ; v8(90.8,22.04) 90.46,22.37 UD42.K6 UD42.K8 ; v8(123.02,18.72) 123.29,18.99 UD44.F2 ; UD41.J10 105.33,25.53 v8(105.02,25.22) ; UD42.D5 86.24,21.3 v8(86.24,21.23) 86.56,20.9 UD42.D4 86.89,21.15 v8(86.89,21.23) 86.56,21.55 UD42.D5 ; UD42.D5 86.24,21.95 v8(86.24,22.03) 86.24,22.1 UD42.D6 ; UD42.D5 86.56,21.7 v8(86.89,22.03) ; UD43.A11 135.48,26.56 135.48,26.69 135.48,26.7 135.48,26.79 v8(135,27.27) 134.92,27.27 134.29,26.63 CD30.1 ; v8(127.12,18.63) 127.19,18.7 UD44.M2 ; CD27.1 98.79,28.03 99.34,28.58 100.85,28.58 101.26,28.18 101.26,27.41 101.43,27.24 UD41.C12 ; v8(126.38,18.63) 126.38,18.83 126.54,18.99 UD44.L2 ; UD42.E8 87.21,23.95 v8(86.89,23.63) ; UD42.N12 92.41,27.83 91.92,28.32 v8(91.83,28.32) ; UD43.P6 144.06,22.35 v8(144.39,22.03) 144.06,21.7 UD43.P5 144.06,21.55 v8(144.39,21.23) 144.06,20.9 UD43.P4 ; UD44.D4 121.99,20.9 v8(122.32,21.23) 121.99,21.55 UD44.D5 121.99,21.7 v8(121.67,22.03) 121.99,22.35 UD44.D6 ; UD44.U9 130.86,24.83 v8(130.97,24.72) ; v8(89.49,22.03) 89.16,21.7 UD42.H5 ; v8(89.49,22.03) 89.81,21.7 UD42.J5 ; v8(89.49,22.03) 89.81,22.35 UD42.J6 ; UD41.L5 106.63,21.7 v8(106.31,22.03) 105.98,21.7 UD41.K5 ; UD43.M2 142.76,19.18 v8(142.32,18.73) 142.11,18.94 UD43.L2 ; UD42.H9 UD42.J9 89.81,24.9 v8(90.14,25.23) 89.81,25.55 UD42.J10 89.16,26.28 UD42.H11 ; v8(123.95,18.69) 123.94,18.7 UD44.G2 ; UD41.J9 105.33,24.75 v8(105.01,24.43) 104.68,24.75 UD41.H9 ; v8(92.74,21.24) 93.06,20.92 UD42.P4 ; UD43.G2 139.51,19.15 v8(139.19,18.83) 138.86,19.15 UD43.F2 ; v8(103.06,23.6) 102.73,23.92 UD41.E8 ; v8(104.07,18.67) 104.03,18.71 UD41.G2 104.27,19.46 104.27,19.61 UD41.H3 ; UD44.K8 125.89,24.09 125.64,24.34 125.64,24.43 UD44.J9 125.24,24.71 v8(124.94,24.41) ; UD41.D6 102.08,22.35 v8(101.76,22.03) 102.08,21.7 UD41.D5 102.08,21.55 v8(101.76,21.23) 101.97,21.01 102.08,20.9 UD41.D4 ; UD42.P6 93.06,22.35 v8(92.73,22.03) 93.06,21.7 UD42.P5 ; UD44.H11 124.59,26.35 v8(124.91,26.03) 125.24,25.7 UD44.J10 ; UD41.M2 UD41.L2 106.73,19.12 106.73,18.16 v8(106.83,18.05) ; UD43.H3 140.16,20.1 v8(139.84,20.43) ; v8(124.94,24.41) 124.59,24.06 UD44.H8 ; v8(124.94,24.41) 124.59,24.76 UD44.H9 ; UD42.C12 85.91,27.69 v8(85.86,27.74) ; v8(88.84,20.44) 89.16,20.11 UD42.H3 ; v8(136.59,26.82) 136.91,27.14 UD43.C12 ; UD42.G5 88.75,21.86 88.75,22.01 UD42.H6 89.16,23.35 v8(89.31,23.5) 89.16,23.65 89.16,24.02 UD42.H8 ; v8(84.25,26.81) 84.61,26.45 UD42.A11 ; UD43.U8 146.39,24.03 v8(146.51,24.15) 146.51,24.33 UD43.U9 ; UD42.G2 88.51,19.3 v8(88.84,19.62) ; v8(105.66,24.43) 105.98,24.1 UD41.K8 ; UD41.U11 v8(111.1,26.43)
  TOP w0.305: UD41.H12 104.68,27.73 v8(105.55,28.61) 106.07,28.09 106.07,27.57 105.98,27.47 UD41.K12 105.81,27.05 105.81,26.6 UD41.K11 ; UD42.G12 88.48,27.26 88.48,28.79 88.3,28.96 88.3,30.23 CD61.1 ; v8(103.8,28.89) 102.73,27.82 UD41.E12 ; v8(127.85,28.28) 127.85,28.28 127.84,28.27 UD44.N12 ; 126.34,27.23 126.34,26.87 UD44.K11 ; 126.34,27.23 UD44.K12 125.89,27.58 ; 126.34,27.23 UD44.L12 ; CD20.1 123.01,30.27 123.01,28.73 v8(123.26,28.49) 123.29,28.45 124.16,28.45 124.59,28.02 UD44.H12 ; UD41.R12 109.23,28.78 108.64,29.37 ; UD41.A11 99.73,26.43 98.8,27.35 98.8,27.35 CD27.1 ; UD41.L12 106.63,27.94 v8(107.15,28.46) 107.76,27.86 107.76,27.39 UD41.N12 ; UD44.R12 129.14,28.28 128.79,28.63 128.46,28.63 126.89,30.2 ; UD44.N8 127.84,23.9 128.07,23.67 128.07,23.38 v8(128.1,23.38) ; v8(111.1,26.43) 113.51,28.83 CD13.1 ; UD44.A11 118.92,27.55 117.9,28.57 ; CD24.1 121.32,29.95 121.34,29.92 121.34,29.65 v8(120.35,28.66) 120.35,28.65 120.53,28.65 120.67,28.52 120.84,28.52 121.18,28.18 121.18,27.39 UD44.C12 ; UD41.H6 105,22.1 v8(105,22.03) ; UD42.U9 95.28,24.83 95.69,24.41 95.69,23.95 v8(95.56,23.82) 95.16,23.82 95.01,23.97 UD42.U8 ; UD42.A9 84.28,24.83 83.96,24.5 83.96,23.37 v8(84.1,23.23) 84.61,23.74 UD42.A8 ; UD44.H12 UD44.G12 ; UD44.H12 UD44.H11 ; UD41.A8 99.94,24.03 99.11,23.2 98.43,23.2 98.12,23.5 CD64.1 98.58,23.71 98.98,24.12 98.98,24.57 99.24,24.83 UD41.A9 ; CD21.1 131.45,27.78 v8(130.99,27.32) 130.99,26.97 UD44.U11
  TOP w0.32: v8(147.5,27.8) 147.84,27.8 148.12,27.52 CD67.1 ; v8(148.92,23.81) 148.87,23.86 148.46,23.86 CD66.1 ; v8(113.41,47.01) 113.06,46.65 CC49.1 ; CC45.1 CC36.1 119.79,43.09 v8(119.69,42.99)
  TOP w0.381: CD23.1 103.04,29.65 v8(103.8,28.89) ; v8(107.21,29.5) 107.49,29.78 CD19.1 ; v8(137.13,28.27) 138.65,29.79 CD71.1 ; v8(114.76,26.66) 115.97,26.66 CD52.1 117.9,28.57 ; CD27.1 CD58.1 ; v8(83.39,27.82) 83.27,27.71 CD51.1
  TOP w0.457: CD54.1 111.96,30.21 111.71,30.46 CD43.1 110.92,28.75 v8(111.16,28.5) 112.62,29.96 CD54.1 ; CD54.1 112.67,30.26 CD13.1 ; CD69.1 99.07,31.26 CD17.1 100,28.89 100.31,28.58 ; CD69.1 97.76,31.13 95.98,31.13 95.31,30.46 CD15.1 95.27,29.83 v8(93.7,28.26) ; CD69.1 97.95,31.32 97.95,33.13 98.97,34.15 RD9.1 ; v8(87.28,28.6) 86.88,29.01 86.07,29.01 85.49,29.58 CD31.1 ; v8(107.21,29.5) 107.34,29.37 108.64,29.37 ; 125.89,27.58 125.89,27.66 126.69,28.45 v8(127.16,28.45) 127.12,28.45 127.12,29.06 126.89,29.28 CD26.1 ; 91.09,29.12 91.09,28.64 91.43,28.3 91.81,28.3 v8(91.83,28.32) ; v8(105.55,28.61) 106.55,29.6 CD25.1 107.46,30.31 CD19.1 ; CD60.1 82.55,18.65 v8(82.98,19.08)
  TOP w0.508: CD29.1 82.91,23.1 v8(83.31,23.5) ; CD56.1 112.67,22.66 CD50.1 114.09,22.66 v8(114.79,23.35) ; v8(120.35,28.66) 119.8,28.66 119.12,29.34 119.12,29.67 118.99,29.8 CD8.1 ; CD7.1 v8(90.76,16.47) ; CD4.1 113.88,17.51 v8(114.27,17.12) ; CD5.1 90.11,16.02 v8(90.11,16.47) ; CD49.1 131.44,17.62 v8(131.23,17.42) ; 91.09,29.12 91.09,29.58 CD63.1 91.84,30.92 91.18,31.58 RD14.1 90.77,32.21 90.27,32.71 RD13.1 ; v8(83.08,26.42) 82.75,26.75 CD34.1 ; CD46.1 112.08,17.51 v8(111.95,17.64) ; RC162.1 115.19,51.38 115.19,51.75 v8(115.14,51.79) ; CD28.1 112.26,18.4 112.14,18.28 v8(112.07,18.28) ; CD11.1 148.25,18.08 148.06,18.08 147.56,18.58 v8(147.56,18.65) ; v8(95.56,23.82) 95.71,23.67 97.06,23.67 CD18.1 CD64.1 ; CD24.1 120.93,32.21 117.15,35.99 117.15,41.99 117.12,42.01 ; CD22.1 85.41,30.42 CD31.1 ; CD33.1 135.73,30.11 v8(134.85,29.22) 134.29,28.66 CD68.1
  BOTTOM w0.178: v8(125.03,42.78) 124.74,43.08 124.74,43.76 124.71,43.81 UCPU1.BB23 ; v8(111.06,43.16) 111.12,43.22 111.12,43.92 UCPU1.BB47 ; UCPU1.BB51 108.66,43.01 v8(108.64,42.98) ; UCPU1.BB32 119.74,43.99 119.74,43.05 v8(119.69,42.99) ; UCPU1.BB41 114.78,42.93 114.65,42.81 114.65,42.82 v8(114.66,42.82)
  BOTTOM w0.254: UCPU1.AU42 113.72,46.71 v8(113.41,47.01) ; v8(120.73,47.01) 121.03,46.71 UCPU1.AU28 ; UCPU1.AU23 123.77,46.71 v8(123.47,47.01) ; v8(117.07,47.01) 117.37,46.71 UCPU1.AU35
  BOTTOM w0.508: 121.27,15.58 121.56,15.86 121.79,15.86 v8(122.16,16.22) ; 121.27,15.58 121.84,15.01 122.09,15.01 CD32.1 ; 121.27,15.58 120.77,15.07 CD65.1 120.77,14.69 120.36,14.28 118,14.28 CC92.1 117.01,15.07 115.63,15.07 114.87,14.31 UC9.5
  vias: v8(128.53,16.38) v8(129.11,16.38) v8(129.69,16.38) v8(130.28,16.38) v8(130.63,17.41) v8(130.86,16.38) v8(131.45,16.38) v8(132.03,16.36) v8(133.24,16.26) v8(134.1,16.27) v8(137.24,22.03) v8(137.24,21.24) v8(137.89,22.03) v8(139.84,22.04) v8(140.49,25.23) v8(140.49,24.43) v8(140.49,23.63) v8(141.14,24.43) v8(141.14,22.03) v8(141.79,23.63) v8(141.8,21.23) v8(142.94,29.02) v8(144.12,28.45) v11(117.67,43.67)
+1.2V_DDRP: length 31.2
  TOP w0.254: PC610.1 126.27,10.95 126.27,12.86 126.53,13.11 129.7,13.11 130.2,12.61 130.2,9.22 129.18,8.19 129.18,4.3 128.13,3.26 116.23,3.26 v1(116.17,3.31)
  GND1 w0.254: v3(115.76,3.2) 116.04,3.2 116.15,3.31 v1(116.17,3.31)
  GND3 w0.254: v3(115.76,3.2) 115.76,2.68 v4(115.78,2.66)
  BOTTOM w0.254: PC609.1 PR603.1 116.03,2.35 115.78,2.6 v4(115.78,2.66)
  vias: v1(126.96,11.49) v1(127.24,11.5) v1(127.5,11.49) v1(127.77,11.5) v1(127.93,12.4) v1(128.18,12.4) v1(128.19,11.5) v1(128.44,12.4) v1(128.63,11.5) v1(128.7,12.4) v1(128.95,12.4) v1(128.88,11.5) v1(129.21,12.4) v1(129.46,12.4) v3(126.25,12.38) v3(126.48,11.13) v3(126.68,12.36) v3(126.94,11.13) v3(127.1,12.38) v3(127.4,11.13) v3(127.89,11.14) v3(128.44,11.13) v3(128.92,11.13) v4(126.35,11.47) v4(126.62,11.46) v4(126.97,11.47) v4(127.24,11.47) v4(127.44,12.37) v4(127.5,11.47) v4(127.71,12.37) v4(127.76,11.47) v4(127.97,12.38) v4(128.02,11.47) v4(128.26,12.38) v4(128.28,11.47) v4(128.54,12.38) v4(128.54,11.47) v4(128.82,12.39) v4(129.08,12.38) v11(128.18,10.32)
+1.2V_MEM_CPUCLK: length 2
  TOP w0.127: v8(115.24,49.57) 115.27,49.54 115.27,49.44 v11(115.62,49.08)
  TOP w0.254: RC162.2 115.47,49.8 v8(115.24,49.57)
  BOTTOM w0.254: UCPU1.AM40 114.85,49.96 v8(115.24,49.57)
+1.8V_3.3V_ALW_VTR3: length 12.1
  GND1 w0.508: v3(22.62,22.26) v1(23.13,22.26)
  GND3 w0.508: v3(22.62,22.26) 22.65,22.23 v6(23.13,22.23)
  IN4 w0.254: v5(31.15,18.04) 31.15,18.08 29.58,19.65 29.58,20.83 29.02,21.39 23.97,21.39 v6(23.13,22.23)
  BOTTOM w0.508: v5(31.15,18.04) 30.9,18.29 RE183.2
  vias: v2(23.5,21.15)
+1.8V_PGPP: length 8
  TOP w0.381: v8(129.05,53.66) 129.05,53.8 129.49,54.24 v11(129.97,54.24) 130.54,54.24 130.74,54.05 134.82,54.05 135.31,53.56 RC176.2
  BOTTOM w0.254: UCPU1.AF16 129.05,53.5 v8(129.05,53.66)
+1.8VA: length 384.7
  TOP w0.254: R2.1 99.92,67.6 101.14,67.6 102.74,69.19 102.74,71.56 102.81,71.63 102.54,71.9 102.66,72.01
  TOP w0.508: 102.66,72.01 v11(101.33,73.34) 100.82,73.85 86.85,73.85 84.56,71.56 84.56,70.8 84,70.24 78.42,70.24 77.92,70.74 71.46,70.74 69.52,68.8 v7(68.53,68.8) ; RC384.1 139.6,50.39 139.84,50.15 v1(140.08,50.15) ; RH57.2 RH59.2 RH55.2 RH51.2 RH53.2 142.03,47.96 v8(142.66,47.33) ; v7(54.83,67.28) 54.23,66.68 46.99,66.68 45.75,67.93 43.61,67.93 43.52,68.02 41.25,68.02 40.43,68.84 v8(40.43,69.09)
  IN1 w0.508: v9(209.21,8.25) 212.69,11.73 215.72,11.73 218.18,9.27 219.63,9.27 220.49,10.12 225,10.12 225.46,9.66 225.46,8.41 227.65,6.22 228.91,6.22 229.44,5.7 250.26,5.7 ; v7(54.83,67.28) 56.35,68.8 v7(68.53,68.8) ; v8(166.83,38.35) 166.01,38.35 163.25,41.1 163.25,46.72 159.64,50.33 157.53,50.33 154.55,53.31 v8(154.55,57.05) 154.55,57.64 v8(154.54,57.65) ; 146.04,53.01 146.78,53.75 146.78,56.62 147.26,57.1 147.76,57.1 148.53,57.87 148.53,58.63 149.58,59.68 149.84,59.68 150.45,60.3 150.45,62.11 148.1,64.46 144.25,64.46 141.97,66.74 141.97,68.25 140.23,69.99 138.44,69.99 135.8,72.64 124.7,72.64 120.19,68.12 112.69,68.12 108.85,71.97 103.95,71.97 103.95,71.98
  GND1 w0.381: v3(140.81,50.74) 140.81,50.53 140.43,50.15 v1(140.08,50.15)
  GND1 w0.508: v9(209.21,8.25) 209.18,8.28 v3(208.88,8.28)
  IN2 w0.508: v3(7.79,24.7) 7.86,24.63 9.68,24.63 10.1,24.21 11.57,24.21 11.94,23.84 11.94,23.02 12.33,22.63 15.22,22.63 15.64,23.04 19.17,23.04 19.5,23.38 22.7,23.38 v8(23.05,23.73) ; v8(14.83,61.09) 15.04,61.3 15.9,61.3 16.76,60.44 25.73,60.44 28.42,63.12 28.42,66.59 30.21,68.37 38.53,68.37 38.93,68.77 40.11,68.77 v8(40.43,69.09)
  IN3 w0.508: v3(7.79,24.7) 7.64,24.84 7.64,27.04 8.28,27.68 8.28,28.7 7.33,29.65 7.33,31.28 8.96,32.9 8.96,36.9 9.04,36.99 9.04,38.21 9.74,38.91 9.74,39.91 10.64,40.82 10.64,43.59 10.36,43.88 10.36,44.77 10.89,45.31 10.89,49.45 12.75,51.31 12.75,53.51 14.39,55.15 14.39,60.65 v8(14.83,61.09)
  GND3 w0.381: v3(140.81,50.74) 141.05,50.5 v6(141.05,50.3)
  GND3 w0.508: v4(208.84,7.78) 208.84,8.18 208.88,8.23 v3(208.88,8.28)
  IN4 w0.356: v8(140.15,55.06) 140.15,54.86 139.18,53.9 139.18,53.2 139.85,52.52 139.85,51.89 141.05,50.7 v6(141.05,50.3) 141.05,49.5 142.66,47.89 v8(142.66,47.33)
  IN4 w0.508: 199.24,10.49 194.02,10.49 193.75,10.23 188.14,10.23 185.88,12.49 184.43,12.49 182.95,13.97 181.9,13.97 172.41,23.46 172.41,23.68 169.03,27.06 169.03,36.14 v8(166.83,38.35)
  BOTTOM w0.508: v4(208.84,7.78) 208.48,8.14 208.43,8.14 205.44,11.13 200.86,11.13
  BOTTOM w1.016: 151.87,56.53 149.73,54.39 149.73,52.58 CC61.1
  vias: v1(251.28,5.67) v1(251.56,5.68) v5(199.72,10.93) v5(199.98,10.93) v7(25.06,23.71) v7(25.44,23.71) v7(29.12,23.66) v7(29.11,23.33) v7(103.47,71.98) v7(103.51,72.4) v8(139.52,55.06) v8(147.16,52.62) v8(147.62,52.2)
+1.8VAP: length 19.5
  TOP w0.254: v8(155.52,57.58) 155.52,57.73 155.06,58.18 154.1,58.18 153.33,58.96 v2(153.33,60.87) 153.33,62.28 154.28,63.23 v8(154.28,63.33)
  IN1 w0.457: v8(157.42,59.86) 158.24,59.04 159.97,59.04 v8(160.47,59.54)
  BOTTOM w0.254: v8(160.47,59.54) 160.39,59.54 160.23,59.7 159.97,59.95 PU800.14 ; PR806.2 159.65,65.18 158.33,65.18 157.92,64.77 155.5,64.77 PR802.1 PC801.1 154.32,63.29 v8(154.28,63.33)
+1.8VS_AUDIO: length 84.8
  TOP w0.203: U6.17 267.91,10.65 267.83,10.73 v8(267.73,10.73)
  TOP w0.508: 259.72,12.6 259.72,12.6 v11(259.72,10.32) 259.72,9.47 258.69,8.44 258.69,7.76 257.47,6.54 R95.2 257.47,4.99 C103.1
  IN1 w0.508: 276.4,66.62 276.02,66.62 275.63,66.22 272.35,66.22 271.9,66.68 268.82,66.68 267.25,65.11 267.25,52.95 267.55,52.65 267.55,50.38 266.1,48.94 266.1,42.62 266.06,42.57 v8(266.06,40.18)
  GND3 w0.508: v4(260.25,13.17) 260.37,13.29 v3(260.64,13.29)
  IN4 w0.508: v5(258.04,13.2) 258.07,13.17 v4(260.25,13.17)
  BOTTOM w0.508: v8(266.06,40.18) 266.06,39.46 265.45,38.85 265.45,25.39 263.24,23.18 263.24,19.04 258.04,13.84 v5(258.04,13.2) ; v4(260.25,13.17) 260.37,13.29 263.12,13.29 264.32,12.08 265.9,12.08 266.08,12.26
  vias: v1(259.64,13.2) v1(259.84,13.43) v7(276.43,67.02) v7(276.66,67.15)
+1.8VU: length 58
  TOP w0.254: UD43.A6 135.61,22.42 v8(135.23,22.04) 135.61,21.65 UD43.A5 ; UD42.U10 95.29,25.63 v8(95.66,26) ; v8(114.15,21.96) 113.3,21.96 CD44.1 ; UD41.A10 99.88,25.37 v8(99.66,25.37) ; UD41.U10 111.02,25.63 v8(111.04,25.64) ; UD44.A6 119.87,22.43 v8(119.49,22.05) 119.91,21.63 UD44.A5 ; v8(94.69,22.02) 94.69,22.1 UD42.U6 95.01,22.38 v8(95.39,22) 95.02,21.63 UD42.U5 95.01,21.55 v8(95.34,21.23) 95.01,20.9 UD42.U4 95.13,20.7 95.13,20.15 UD42.U3 ; UD41.A4 100.13,20.75 v8(100.46,20.43) 100.44,20.43 100.13,20.11 UD41.A3 ; UD44.U3 130.44,20.1 v8(130.77,20.43) 130.44,20.75 UD44.U4 130.44,20.84 v8(130.79,21.19) 130.44,21.54 UD44.U5 130.44,21.7 v8(130.77,22.03) 130.44,22.35 UD44.U6 ; UD43.A3 135.61,20.1 v8(135.94,20.43) 135.61,20.75 UD43.A4 ; UD42.A10 84.13,25.63 v8(83.99,25.48) ; UD42.A4 84.61,20.75 v8(84.94,20.43) 84.94,20.41 84.61,20.08 UD42.A3 ; UD44.A3 120.04,20.1 v8(120.37,20.43) 120.04,20.75 UD44.A4 ; UD42.A5 84.5,21.63 v8(84.08,22.05) 84.46,22.43 UD42.A6 ; UD41.A5 100,21.63 v8(99.58,22.05) 99.95,22.43 UD41.A6 ; v8(119.53,26.12) 120.02,25.63 UD44.A10 ; UD43.A10 135.09,25.63 134.7,25.24 132.86,25.24 CD10.1 132.51,25.62 ; v8(147.24,25.38) 146.26,25.38 UD43.U10 ; UD41.U3 110.53,20.1 v8(110.86,20.43) 110.53,20.75 UD41.U4 110.53,20.9 v8(110.86,21.23) 110.53,21.55 UD41.U5 110.53,21.7 v8(110.86,22.03) 110.53,22.35 UD41.U6
  TOP w0.305: CD41.1 97.67,22 v11(96.81,22) v8(95.39,22) ; UD42.U3 96.97,20.02 CD45.1 96.6,20.66 95.17,20.66 UD42.U4
  TOP w0.381: CD3.1 132.38,20.43 v8(130.77,20.43) ; CD41.1 98.06,21.62 98.06,20.94 98.48,20.52 v8(98.63,20.52) ; CD1.1 132.22,22.03 v8(130.77,22.03)
  TOP w0.457: CD40.1 118.21,20.47 119.33,21.59 119.33,21.89 v8(119.49,22.05)
  TOP w0.508: CD42.1 82.19,20.92 82.32,21.04 CD47.1 ; v8(83.21,22.14) 82.76,22.14 CD47.1 ; CD41.1 97.71,21.68 97.11,21.08 CD45.1 ; v8(99.66,25.37) 98.7,25.37 98.2,25.87 CD48.1 ; CD47.1 82.76,21.26 83.48,21.26 84.08,21.86 v8(84.08,22.05) ; CD2.1 82.65,24.4 83.73,25.48 v8(83.99,25.48)
  TOP w0.762: v8(147.24,25.38) 147.24,23.1 v8(146.81,22.67)
  vias: v8(130.82,26.04) v8(145.7,22.02) v8(145.7,21.23)
+1.8VUP: length 26.6
  TOP w0.305: v1(161.24,4.86) 161.24,4.79 160.1,3.65 155.45,3.65 v2(154.47,4.62) v1(154.47,7.06)
  GND1 w0.305: v3(161.82,4.86) v1(161.24,4.86) ; v3(154.05,7.06) v1(154.47,7.06)
  GND3 w0.305: v4(161.53,5.1) 161.75,4.88 161.8,4.88 v3(161.82,4.86) ; v4(153.63,7.14) 153.96,7.14 v3(154.05,7.06)
  IN4 w0.305: v5(154.76,11.85) 159.39,11.85 159.74,11.51 v5(160.56,11.51)
  BOTTOM w0.305: v5(160.56,11.51) 160.56,10.14 161.45,9.25 161.45,8.51 161.14,8.2 PR902.1 PC901.1 161.03,7.31 161.33,7.01 161.33,6.02 160.77,5.46 PR906.2 160.81,5.1 v4(161.53,5.1)
+3.3V_1.8V_ESPI: length 3.1
  BOTTOM w0.095: RC24.1 v2(133.64,37.65)
  BOTTOM w0.381: RC21.1 132.63,38.82 133.64,38.82 RC24.1 134.51,38.82 RC386.2
+3.3V_1.8V_PGPPA: length 32.3
  GND1 w0.508: v3(139.36,49.22) v1(139.36,49.59)
  IN2 w0.381: v3(139.36,49.22) 139.36,49.62 139.84,50.1 140.37,50.1 140.76,49.72 140.76,48.22 139.99,47.45 138.34,47.45 137.96,47.07 137.96,46.57 v3(137.71,46.31)
  IN3 w0.381: v3(136.01,42.32) 136.01,43.28 137.67,44.95 137.67,45.9 137.71,45.93 v3(137.71,46.31) ; v3(139.36,49.22) 139.33,49.2 136.49,49.2 136.15,48.85 135.29,48.85 134.9,49.24 134.9,49.36 134.65,49.62 134.35,49.62 133.5,50.46 130.88,50.46
  IN4 w0.381: v5(138.22,38.87) 137.63,38.28 135.96,38.28 v5(135.01,39.23)
  BOTTOM w0.095: v5(135.01,39.23) 134.96,39.23 134.96,39.4 134.66,39.71 RC386.1 ; RH87.2 141.52,38.23 v2(141.52,37.65)
  BOTTOM w0.254: v8(129.89,51.18) 129.44,50.73 UCPU1.AK15
  BOTTOM w0.381: v5(138.22,38.87) 138.22,38.6 138.5,38.31 140.44,38.31 140.88,38.75 RH87.2
  vias: v4(134.69,41.47)
+3.3V_EC5105: length 96.3
  TOP w0.102: RE119.2 v2(10.23,16.36)
  TOP w0.254: UE3.G8 v8(19.5,14.42) ; v8(18.7,18.45) 18.7,18.47 18.35,18.82 UE3.M9 ; RE112.2 RE111.2
  TOP w0.381: RE113.2 29.28,12.3 29.2,12.22 28.29,12.22 27.89,12.63 RE272.2
  TOP w0.508: v8(10.96,17.23) 10.71,17.48 RE119.2 ; RE130.2 11.52,10.45 v8(11.47,10.5) ; RE133.2 26.81,5.76 v8(26.81,5.15) ; RE124.2 13.86,6.9 v8(13.13,7.63) ; RE111.2 28.13,23.58 28.01,23.7 v8(28.01,23.7) ; RE280.2 29.54,7.7 v1(29.54,7.07) ; v8(28.74,11.64) 29.12,11.26 RE231.2 29.48,12.1 29.33,12.25 RE113.2
  GND1 w0.508: v1(29.54,7.07) v3(29.21,7.07)
  IN2 w0.508: v8(10.96,17.23) 10.96,17.99 12.04,19.07 12.04,21.18 v3(11.51,21.72) ; v8(26.81,5.15) 25.41,6.55 21.78,6.55 v8(20.89,5.65) 19.8,6.74 19.8,8.13 19.27,8.66 14.16,8.66 v8(13.13,7.63)
  IN3 w0.254: 16.89,16.06 15.06,16.06 13.79,17.33 11.19,17.33 11.09,17.23 v8(10.96,17.23)
  IN3 w0.508: v8(18.7,18.45) 18.7,19 18.65,19.05 18.65,20.41 18.14,20.92 v8(17.33,20.92)
  GND3 w0.508: v3(29.21,7.07) v4(28.88,7.07)
  IN4 w0.508: v8(13.13,7.63) 11.83,7.63 11.45,8 11.45,10.48 v8(11.47,10.5) 11.34,10.63 11.34,12.47 11.65,12.77 11.65,14.68 11.25,15.08 11.25,15.52 11.6,15.87 11.6,16.59 v8(10.96,17.23) ; 12.46,21.87 12.47,21.88 16.82,21.88 17.33,21.37 v8(17.33,20.92) ; v8(28.74,11.64) 28.33,11.23 26.72,11.23 25.12,12.82 25.12,13.53 25.62,14.03 25.62,15.21 v8(25.36,15.46)
  BOTTOM w0.254: RE109.2 27.42,16.71 RE243.2
  BOTTOM w0.508: v8(17.33,20.92) 17.64,21.23 20.59,21.23 v8(21.58,22.22) 23.68,22.22 25.48,24.02 27.69,24.02 v8(28.01,23.7) ; v8(25.36,15.46) 25.48,15.46 25.8,15.78 26.75,15.78 26.87,15.91 RE243.2 ; v8(26.81,5.15) 26.97,5.15 v4(28.88,7.07) 28.88,7.7 27.84,8.74 RE105.2 RE107.2 29.04,9.63 29.8,10.39 RE242.2 29.8,10.79 28.95,11.64 v8(28.74,11.64)
  vias: v1(11.39,22.03) v1(11.66,22.03) v6(11.86,21.88) v6(11.85,21.61)
+3.3V_PGPP: length 11.6
  TOP w0.102: v8(128.47,57.01) v2(128.47,57.65)
  TOP w0.305: v8(129.76,53.66) 129.82,53.6 CC57.1 129.82,52.78 129.15,52.11 v8(129.15,51.98)
  TOP w0.381: CC59.1 130.25,56.06 129.8,55.61 v8(129.8,55.41) ; v8(128.47,57.01) CC58.1 v8(128.47,55.31)
  TOP w0.508: RC167.2 133.07,53 133.25,53.18 133.25,53.41 v8(133.26,53.42)
  BOTTOM w0.254: v8(129.15,51.98) 129.44,52.27 UCPU1.AG15 ; v8(128.47,57.01) 128.79,57.32 UCPU1.T16 ; v8(129.76,53.66) 129.76,53.72 129.44,54.04 UCPU1.AD15 129.83,54.48 129.83,55.38 v8(129.8,55.41) 129.46,55.76 UCPU1.Y15 129.36,55.84 128.87,55.84 UCPU1.Y16 128.47,55.44 v8(128.47,55.31)
+3.3V_SPI: length 2.7
  TOP w0.254: RC170.2 130.18,52.2 130.17,52.19 130,52.19 v2(129.63,51.82) 129.62,51.81 129.62,51.71 v8(129.08,51.16)
  BOTTOM w0.254: UCPU1.AJ16 128.79,51.56 129.08,51.27 v8(129.08,51.16)
+3.3VDX_SSD: length 41.1
  TOP w0.102: U24.C1 v7(173.36,18.43) ; v7(156.35,27.31) v11(156.35,22.92) 156.35,21.76 158.83,19.28 158.83,18.61 v7(159,18.44)
  IN1 w0.095: v7(173.36,18.43) 173.08,18.43 172.85,18.2 169.78,18.2 169.22,18.76 159.32,18.76 v7(159,18.44) ; v7(146.79,36.08) 147.71,35.16 148.26,35.16 148.54,34.88 153.45,34.88 156.3,32.03 156.3,27.37 v7(156.35,27.31)
  vias: v1(149.2,37.36) v1(149.22,37.07) v1(149.22,36.81) v1(149.26,36.41) v1(149.26,36.13) v1(149.48,37.36) v1(149.5,37.07) v1(149.52,36.79) v1(149.52,36.42) v1(149.52,36.14) v3(149.89,37.41) v3(149.89,36.98) v3(149.89,36.56) v3(149.89,36.13) v3(149.89,35.7) v3(149.91,35.28) v4(150.22,37.45) v4(150.22,37.17) v4(150.24,36.89) v4(150.23,36.62) v4(150.22,36.35) v4(150.22,36.07) v4(150.22,35.8) v4(150.38,35.58) v4(150.45,36.48) v4(150.45,36.22) v4(150.45,35.94) v8(154.03,21.12) v8(154.03,20.52) v11(148.2,37.14) v11(154.5,19.87)
+3.3VDX_SSD_IN+: length 41.6
  TOP w0.102: v7(158.42,18.45) 158.6,18.63 158.6,19.18 155.94,21.84 v7(155.94,27.32) ; U24.D1 v7(173.86,18.43)
  IN1 w0.095: v7(146.86,34.68) 146.98,34.8 148.11,34.8 148.39,34.53 153.3,34.53 155.94,31.88 v7(155.94,27.32) ; v7(158.42,18.45) 158.81,18.06 159.12,18.06 159.47,18.41 169.07,18.41 169.64,17.85 173,17.85 173.22,18.08 173.56,18.08 173.86,18.37 v7(173.86,18.43)
  vias: v2(148.38,34.96)
+3V_LDO: length 475.8
  TOP w0.254: v8(48.5,18.17) 48.5,18.72 49.04,19.26 PR222.1
  TOP w0.508: v8(47.16,1.71) 47.94,1.71 PR155.2 47.92,1.99 47.52,2.39 PR148.2 47.09,2.41 PC125.2 44.76,2.41 PR139.1 43.87,1.52 41.77,1.52 41.19,2.1 PR115.1 ; v7(281.6,24.24) 281.6,28.39 276.55,33.44 274.73,33.44 274.72,33.43 273.91,33.43 273.88,33.45 273.29,33.45 271.56,31.72 267.94,31.72 267.47,32.19 266.26,32.19 265.66,31.58 R272.1 265.22,31.49 264.83,31.11 264.83,29.85 ; v8(48.5,18.17) 48.5,17.39 48.13,17.02 48.13,16.6 47.79,16.27 42.38,16.27 39.49,13.37 39.49,12.6 v1(37.03,10.14) ; 145.25,13.71 144.81,14.15 139.19,14.15 138.36,13.33 130.2,13.33 129.91,13.62 122.87,13.62 121.34,12.08 117.01,12.08 115.35,10.43 114.57,10.43 112.71,8.57 112.71,4.3 111.78,3.36 97.4,3.36 94.2,6.57 91.49,6.57 81.84,16.22 80.57,16.22 79.13,17.66 v11(79.13,18.7) 79.13,20.16 v8(79.85,20.89)
  IN1 w0.508: v7(287.72,17.97) 287.72,18.84 285.08,21.48 282.3,21.48 281.6,22.18 v7(281.6,24.24) ; v9(177.87,13.51) 177.34,14.04 175.11,14.04 174.28,13.21 169.53,13.21 168.7,14.04 163.78,14.04 163.4,13.66 149.7,13.66 149.27,13.24 v7(145.67,13.24) ; v8(30.46,3.36) 30.46,2.97 30.99,2.43 40.89,2.43 41.8,1.52 46.98,1.52 v8(47.16,1.71)
  GND1 w0.508: v3(36.22,9.65) 36.42,9.65 36.91,10.14 v1(37.03,10.14) ; v3(178.34,13.98) 178.34,13.97 v9(177.87,13.51)
  IN2 w0.254: v3(36.89,26.37) 36.89,26.22 34.76,24.1 32.02,24.1 31.56,23.64 28.72,23.64 v3(28.58,23.78)
  IN3 w0.508: v8(79.85,20.89) 79.62,21.11 79.62,23.86 79.93,24.17 79.93,27.77 79.81,28.39 78.56,29.64 76.64,30.44 67.95,30.44 67.53,30.02 63.02,30.02 61.1,31.95 59.77,31.95 58.05,33.67 58.05,34.9 55.41,37.55 49.09,37.55 48.08,36.53 46.45,36.53 46.05,36.94 41.9,36.94 40.55,38.28 39.41,38.28 37.67,36.55 37.67,36.31 ; v8(47.16,1.71) 47.79,2.34 57.86,2.34 58.12,2.07 64.62,2.07 v3(64.94,1.75) ; 37.67,36.31 37.67,28.09 36.89,27.31 v3(36.89,26.37) 36.89,26.32 39.6,23.61 39.6,21.3 40.12,20.78 41.51,20.78 43.68,18.61 48.05,18.61 v8(48.5,18.17) ; 37.67,36.31 36.33,36.31 35.46,37.18 v3(35.34,37.18)
  GND3 w0.254: v4(28.58,24.23) v3(28.58,23.78)
  GND3 w0.508: v4(179.02,14.14) 178.49,14.14 v3(178.34,13.98) ; v4(264.8,27.9) 264.8,28.05 264.39,28.47 v3(264.39,28.63) ; v3(64.94,1.75) v4(64.94,2.51) ; v4(34.52,36.86) 35.02,36.86 v3(35.34,37.18)
  IN4 w0.508: 207.32,11.5 206.18,10.36 203.14,10.36 201.76,10 199.89,8.12 195.76,8.12 195.59,7.95 186.85,7.95 184.29,10.52 181.36,10.52 179.7,12.17 179.7,13.46 v4(179.02,14.14) ; v6(35.79,9.6) 35.49,9.6 34.58,10.52 31.72,10.52 v5(31.05,11.18) ; v5(30.82,32.28) 31.38,32.84 v5(31.38,35.09)
  BOTTOM w0.254: PR112.2 28.2,24.6 v4(28.58,24.23)
  BOTTOM w0.508: v4(264.8,27.9) 264.8,25.73 262.56,23.49 262.56,19.46 259.95,16.85 257.59,16.85 257.58,16.84 253.44,13.94 250.38,12.42 247.59,11.44 243.32,10.48 232.67,10.48 231.2,11.95 225.98,11.95 221.94,15.98 220.08,15.98 219.64,15.54 216.39,15.54 215.18,16.76 212.21,16.76 211.16,15.71 211.16,14.07 ; 211.16,12.7 209.09,12.7 208.36,11.97 208.24,11.97 ; 211.16,12.7 211.16,14.07 ; 211.16,12.7 211.46,12.4 215.92,12.4 218.27,10.05 218.27,7.07 217.93,6.73 217.93,5.94 PR276.1 ; v8(30.46,3.36) 30.46,4.02 29.68,4.79 29.06,4.79 28.76,5.09 28.76,6.05 29.61,6.89 29.61,9.29 31.05,10.74 v5(31.05,11.18) 31.05,11.6 PR215.1 ; 23.86,34.37 24.59,35.09 v5(31.38,35.09) 34.13,35.09 34.54,35.5 34.54,36.82 34.52,36.84 v4(34.52,36.86) ; 211.16,14.07 PR141.2 ; PT105.1 47.86,1.71 v8(47.16,1.71) 46.89,1.71 PQ123.3 46.68,2.63 PQ124.3 ; PU301.5 65.17,2.27 v4(64.94,2.51)
  vias: v1(264.47,29.2) v1(264.52,28.94) v5(207.72,12.03) v5(207.75,11.69)
+3V_LDOP:
  vias: v2(42.53,1.85)
+3V_PCH: length 158.9
  TOP w0.305: RH71.1 135.23,50.41 136.12,49.52 RC29.2
  TOP w0.381: v8(127.16,51.14) 127.16,50.52 126.94,50.3 126.1,50.3 RA65.1 ; CC68.1 126.48,56.22 v8(126.54,56.17) ; v7(142.65,58.12) RC18.2 RC20.2 142.12,57.16 142.23,57.16 v8(142.71,56.68) 142.99,56.97 RC395.1
  TOP w0.508: RC29.2 RC46.1 136.12,47.71 RC45.1 136.83,47 RC118.1 ; v8(141.11,33.55) 140.25,32.69 137.3,32.69 136.96,32.34 129.8,32.34 126.11,36.04 v1(126.11,40.7) 126.11,41.36 RC83.1 ; v8(170.95,24.11) 170.47,23.63 R282.1
  TOP w1.016: 148.74,30.32 151.42,30.32 153.39,28.34 157.61,28.34 158.61,27.34 159.3,27.34 159.3,27.34
  IN1 w0.254: 143.04,54.16 143.34,53.86 145.86,53.86 146.27,54.26 146.27,57.95 147.28,58.96 148.13,58.96 149.38,60.2 v9(149.51,60.2)
  IN1 w0.381: v8(140.65,68.51) 140.66,68.51 140.66,60.37 141.44,59.6 v1(142.51,59.6) 142.8,59.3 142.8,58.27 v7(142.65,58.12)
  IN1 w1.016: 164.82,35.67 164.95,35.54 165.89,35.54 166,35.44 167.05,35.44 168.11,34.38 168.11,33.6 167.12,32.61 ; 149.18,47.81 150.25,48.88 152.28,48.88 153,48.16 153.85,48.16 157.96,44.05 159.01,44.05 159.91,43.15 159.91,41.8 ; 160.35,39.39 160.53,39.39 163.77,36.15 163.77,35.9 ; 161.38,27.66 161.39,27.65 165.79,27.65 166.81,28.67 166.81,30.35
  GND1 w0.254: v1(126.11,40.7) 126.12,40.72 126.41,40.72 126.43,40.74 v3(126.47,40.74) ; v3(128.38,50.49) 128.54,50.33 v1(128.74,50.33) ; v3(149.85,60.54) v9(149.51,60.2)
  GND3 w0.254: v3(126.47,40.74) 126.49,40.76 126.49,40.79 126.75,41.05 v4(126.75,41.28) ; v4(128.14,50.73) 128.14,50.73 v3(128.38,50.49) ; v3(149.85,60.54) 150.25,60.13 v4(150.38,60.13) ; v3(164.44,34.47) 163.79,34.47 v4(163.6,34.28)
  GND3 w0.381: v3(141.88,59.6) 141.98,59.7 v4(142.23,59.7)
  IN4 w0.381: 142.53,53.46 142.53,52.55 v4(142.01,52.03)
  IN4 w0.508: 140.5,44.22 140.5,42.42 141.19,41.73 141.19,40.91 v5(142.38,39.72) 143.1,39.72 144.64,38.18 v5(144.64,37.77)
  BOTTOM w0.203: RC36.1 163.01,40.34
  BOTTOM w0.254: v8(127.16,51.14) 127.13,51.11 125.79,51.11 125.54,51.37 UCPU1.AJ21 ; v8(126.54,56.17) 126.54,56.29 UCPU1.V19
  BOTTOM w0.381: RC55.2 136.58,70.56 137.28,71.26 138.27,71.26 138.65,70.88 RH81.1 139.82,70.54 140.65,69.7 v8(140.65,68.51)
  BOTTOM w0.508: v8(166.51,31.88) 167.66,31.88 169.76,29.78 169.76,26.49 170.74,25.51 170.74,24.32 v8(170.95,24.11) 171.57,23.5 171.57,20.94 ; R19.1 171.57,20.94 ; 171.57,20.94 171.62,20.99 173.25,20.99 173.61,20.63 173.61,19.68 175.5,17.79 RH75.1 ; RC55.2 135.45,70.56 RC54.2 135.1,70.57 135.06,70.52 RC53.2 RC56.2 ; v8(141.11,33.55) 142.77,33.55 144.64,35.42 v5(144.64,37.77)
  vias: v1(141.41,44.76) v1(141.67,44.69) v3(141.46,44.4) v3(161.08,40.37) v4(141.1,44.42) v4(141.26,44.69) v4(160.93,40.7) v4(161.2,40.69) v5(142.56,53.92) v7(160.38,30.72) v7(160.41,27.72) v7(160.39,27.31) v7(160.7,30.71) v7(160.7,27.72) v7(160.73,27.32) v8(123.36,54.9) v8(123.96,54.89) v8(131.96,51.39) v8(138.16,48.57) v8(147.26,46.84) v8(147.74,46.49) v9(160.86,40.71) v9(161.15,40.72) v9(164.41,35.18) v9(164.41,34.87) v11(145.79,47.56)
+3V_PCH_DSW: length 33.6
  TOP w0.305: v8(127.78,53.65) 127.8,53.64 127.8,53.37 127.97,53.2 127.97,52.38 v1(127.95,52.36)
  TOP w0.508: CC81.1 140.68,38.18 139.89,37.39 139.89,35.24 139.28,34.63 v2(135.55,34.63) 134.06,36.12 131.74,36.12 131.51,36.35 131.51,40.19 RC73.1 131.25,40.45 RC82.2 ; CC81.1 142.04,38.18 RC174.2 ; CC81.1 140.19,39.03 CC82.1 139.01,39.62 RC80.2 139.02,40.08 v1(139.02,40.84) 139.02,40.95 RC74.1
  GND1 w0.254: v1(127.95,52.36) 127.89,52.3 v3(127.89,51.98)
  GND1 w0.508: v1(139.02,40.84) v3(138.78,41.07)
  IN2 w0.381: v3(138.78,41.07) 138.3,41.56 137.76,41.56 135,44.32 135,45.89
  GND3 w0.254: v3(127.89,51.98) 127.89,51.83 128.14,51.59 v4(128.14,51.56)
  BOTTOM w0.254: UCPU1.AD17 128.14,53.98 127.81,53.65 v8(127.78,53.65) 127.78,53.78 UCPU1.AD18
+3V_TBT: length 5.6
  IN4 w0.254: v5(21.24,48.85) 20.92,49.17 19.73,49.17 18.95,49.96 18.95,51.41 18.65,51.7 17.84,51.7 v4(17.73,51.81)
  vias: v1(17.57,52.66) v1(17.57,52.03) v3(17.2,52) v4(17.78,52.15) v8(13.71,52.56) v8(13.72,51.97) v8(27.83,55.86) v8(28.44,55.86) v11(28.13,56.42)
+3V_TBT_S0: length 1.1
  TOP w0.102: v8(28.11,57.16) v2(28.11,58.25)
  vias: v1(23.93,47.38) v1(23.93,46.74) v1(24.68,47.11) v3(24.27,47.23) v3(24.25,46.66) v4(24.49,46.9) v4(24.69,47.17) v8(27.47,57.15)
+3V_VC_A: length 7.1
  IN3 w0.508: v8(22.96,32.82) 18.4,32.82 17.72,33.51 17.72,34.21 18.22,34.72 v3(18.34,34.72)
  vias: v1(17.58,34.65) v1(17.86,34.65) v2(22.09,34.58) v7(20.98,33.31)
+3V_VC_B: length 22.7
  TOP w0.254: R266.2 33.52,37.41 U20.B1 ; U20.H1 30.52,36.62 30.14,37 C152.1 30.1,36.99 v8(29.5,36.99)
  IN1 w0.508: v9(25.44,33.01) 25.44,33.66 25.7,33.92 25.7,34.66 27.25,36.21 27.25,38.35 28.28,39.38 28.93,39.38 29.06,39.25 29.77,39.25 30.06,38.95 30.06,38.53 29.5,37.97 v8(29.5,36.99)
  IN2 w0.508: 30.04,36.63 30.05,36.62 33.15,36.62 v3(34.35,37.81)
  BOTTOM w0.102: R5758.2 25.26,32.16 v2(25.26,31.52)
  vias: v1(33.94,37.84) v1(34.08,38.07) v3(25.19,32.68) v4(24.82,32.62)
+3V_VC_C: length 9.8
  TOP w0.102: v2(286.29,15.96) 286.82,16.49 R5767.2
  IN2 w0.508: v3(284.71,14.89) 285.47,15.66 285.47,16.93 v3(285.37,17.03) 284.49,17.91 v3(283.36,17.91)
  GND3 w0.254: v3(284.71,14.89) 284.71,14.76 285.02,14.45 v4(285.02,14.32) ; v4(283.82,17.96) 283.42,17.96 v3(283.36,17.91)
  BOTTOM w0.203: v4(283.82,17.96) 283.55,17.96 C165.1 283.75,17.31 284.61,17.31 284.63,17.33 U21.H1
  vias: v1(285.76,17.14) v1(285.87,16.91)
+3VA_TBT: length 12.4
  GND1 w0.254: v1(22.04,56.78) v3(22.04,57.17)
  GND3 w0.254: v3(22.04,57.17) 21.97,57.23 v4(21.97,57.63)
  IN4 w0.254: v5(15.2,51.72) 16.35,52.87 19.63,52.87 22.45,55.68 22.45,56.66 21.97,57.13 v4(21.97,57.63)
  BOTTOM w0.305: UT2.F8 20.59,49.5 v8(20.27,49.82)
  vias: v2(23.18,56.32) v8(24.28,55.76) v8(26.45,55.79)
+3VA_TBT_LC: length 0.4
  GND3 w0.254: v4(24.49,50.15) 24.49,50.15 v3(24.75,50.41)
  vias: v1(24.75,51.39) v1(24.8,50.88) v1(25.56,50.55) v2(25.62,51.4)
+3VALW: length 208.2
  TOP w0.203: U14.4 252.37,7.45 v1(251.73,7.45)
  TOP w0.254: PR158.2 60.01,5.7 v1(60.02,5.68)
  TOP w0.305: PR175.1 52.69,20.53 53.08,20.91 54.83,20.91 55.07,20.67 55.07,19.79 55.26,19.61 55.26,18.18 55.25,18.18 55.25,18.09 55.06,17.89 55.06,16.37 54.54,15.86 PR142.1 PR124.1
  TOP w0.381: UC5.5 7.24,22.03 8.12,22.9 9.21,22.9 9.68,23.38 UC8.5 9.19,23.9 v8(9.14,23.95)
  TOP w0.508: 149.83,40 148.81,38.98 147.16,38.98 146.8,38.62 143.88,38.62 RC174.1 ; v1(71.2,6.72) 71.2,4.32 72.29,3.23 R274.1 76.16,3.23 C1077.1 76.38,3.43 U26.2 ; UC6.5 9.57,31.85 v7(8.94,31.22) ; v8(10.17,12.26) 10.38,12.26 10.7,12.58 RE156.2 ; v8(51.98,20.66) 52.29,20.35 PR175.1 ; R5837.2 269.9,58.01 269.9,52.18 269.52,51.8 ; RE194.1 11.2,15.26 10.81,15.65 v8(10.12,15.65) 9.72,15.65 Q4.2 8.41,14.9 v8(7.95,15.36)
  IN1 w0.508: 157.67,34.59 156.71,35.56 154.49,35.56 152.67,37.38 152.67,38.24 150.97,39.94 ; v7(8.94,31.22) 8.94,29.03 v7(8.02,28.11) 8.02,27.75 7.61,27.34 6.2,27.34 3.76,24.89 3.76,24.14
  GND1 w0.254: v1(60.02,5.68) 59.77,5.68 v3(59.68,5.6) ; v1(160.57,28.71) v3(161.13,28.71)
  GND1 w0.381: v1(251.73,7.45) 252.06,7.78 v3(252.06,8.12)
  GND1 w0.508: v1(71.2,6.72) 71.67,7.2 v3(71.68,7.2)
  IN2 w0.254: v8(51.55,39.99) 52.39,39.15 58.49,39.15 59.39,38.25 v3(59.39,38.09) 60.03,38.09 61.28,39.35 63.15,39.35 63.75,39.95 65.19,39.95 65.79,39.35 67.81,39.35 70.11,37.05 v3(70.16,37.05)
  IN2 w0.508: v3(52.54,6.09) 52.51,6.09 52.02,6.57 48.76,6.57 v3(48.37,6.18)
  IN3 w0.508: v8(9.98,19.4) 9.98,21.32 v8(9.96,21.34)
  GND3 w0.254: v3(162.52,39.11) 162.36,38.94 v4(162.19,38.94) ; v3(70.16,37.05) 70.4,37.29 v4(70.4,37.37) ; v3(59.39,38.09) 59.32,38.03 v4(59.32,37.55) ; v4(30.09,11.84) 30.09,11.64 v3(30.39,11.33) ; v4(31.47,30.23) v3(31.47,30.58)
  GND3 w0.381: v6(29,18.23) 28.73,18.23 28.4,18.56 v3(28.38,18.56) ; v4(218.32,12.22) 218.33,12.22 218.51,12.22 v3(218.66,12.22) ; v4(60.23,5.76) 60.2,5.79 59.96,5.79 59.77,5.6 v3(59.68,5.6)
  GND3 w0.508: v3(26.68,4.2) v4(26.68,3.56)
  IN4 w0.381: v5(69.62,9.96) v5(68.57,9.96)
  IN4 w0.508: v5(57.49,29.9) 57.01,30.39 57.01,31.48 57.77,32.24 57.77,35.92 56.3,37.4 55.5,37.4 54.92,37.98 53.56,37.98 v8(51.55,39.99) ; v8(29.97,16.3) 29.56,16.71 29.56,16.81 29.36,17.01 29.36,17.87 v6(29,18.23) ; v5(9.83,25.98) 10.46,26.61 11.72,26.61 12.45,25.88 v5(12.45,25.08)
  BOTTOM w0.254: PR1523.1 70.03,37.73 v4(70.4,37.37) ; PC606.1 120.05,3.58 119.27,4.36 PU600.13 ; 132.86,9.62 PR706.1
  BOTTOM w0.356: UE5.5 30.79,16.68 30.43,16.33 30,16.33 v8(29.97,16.3)
  BOTTOM w0.381: v4(31.47,30.23) 31.69,30.23 PR120.2 ; PR1404.1 167.09,58.25 v8(167.25,58.41) 167.5,58.16 PR1405.1 ; PR173.1 68.54,9.99 v5(68.57,9.96) ; PR174.1 51.55,20 51.98,20.43 v8(51.98,20.66) ; PR143.1 61.41,10.59 61.68,10.87 62.1,10.87 62.67,11.43 65.36,11.43 65.78,11.02 69.15,11.02 69.62,10.55 v5(69.62,9.96) ; v4(218.32,12.22) 218.32,13.66 217.79,14.2 PR140.2 216.57,14.45 216.31,14.71 216.02,14.71 215.11,15.62 214.31,15.62 PR137.2 ; PR1423.1 162.29,50.71 v8(162.68,50.32) ; v8(21.78,24.04) 22.26,24.52 PR111.2 22.26,25.01 PR110.2 ; PR127.1 60.19,9.94 59.87,9.62 59.87,7.35 60.23,6.99 v4(60.23,5.76) ; v5(12.45,25.08) RE283.2 12.23,23.98 QH2.5 QH2.2 12.23,21.04 11.93,20.74 11.36,20.74 11.33,20.77 11.32,20.77 10.93,21.15 U16.5 ; QH1.2 8.88,24.21 v8(9.14,23.95) 9.93,23.95 10.19,24.21 QH1.5
  BOTTOM w0.508: PR1424.1 159.76,66.03 v8(160.1,65.68) ; RE286.2 9.23,16.94 RE287.2 6.96,16.94 6.6,16.58 6.6,15.7 6.99,15.31 7.9,15.31 v8(7.95,15.36) ; v8(24.76,31.71) 24.44,31.71 24.32,31.83 R265.1 ; v8(9.14,23.95) 9.45,24.26 9.45,24.86 9.83,25.24 v5(9.83,25.98) ; 120.72,1.58 120.74,1.59 120.74,2.79 120.23,3.29 PC606.1 ; 120.72,1.58 115.36,1.58 PR604.1 ; 120.72,1.58 128.15,1.58 128.58,2 128.58,3.6 128.93,3.95 128.93,6.21 130.19,7.47 130.19,9.7 130.43,9.94 132.56,9.94 PR706.1 ; v8(163,73.9) 162.87,74.03 PR1414.1 ; RE195.1 11.47,18.7 10.35,18.7 9.98,19.07 v8(9.98,19.4) ; v8(9.96,21.34) 10.15,21.15 U16.5 ; PR1415.1 v8(162.65,71.18) ; RE202.1 10.62,16.15 v8(10.12,15.65) ; UC4.5 165.73,10.66 RC382.1 166.03,9.77 166.31,9.49 166.31,9.07
  vias: v1(28.04,18.65) v1(28.05,18.36) v1(33.95,38.97) v1(34.2,38.82) v1(48.52,64.05) v1(48.74,63.91) v1(150.63,40.72) v1(150.89,40.72) v1(158.85,34.68) v1(158.84,34.37) v1(158.85,34.07) v1(158.82,33.79) v1(158.83,33.5) v1(158.84,33.2) v1(158.83,32.89) v1(158.82,32.61) v1(252.98,10.31) v1(252.98,10.6) v1(253.24,10.3) v1(253.4,10.52) v1(285.77,18.06) v1(285.84,17.81) v3(11.98,9.74) v3(23.15,9.77) v3(33.91,38.62) v3(48.6,63.56) v3(60.81,10.78) v3(136.26,9.18) v3(151.58,41.29) v3(159.18,32.58) v3(159.21,34.69) v3(159.18,34.27) v3(159.19,33.85) v3(159.19,33.42) v3(159.19,33) v3(163.14,8.3) v3(165.56,10.55) v3(252.63,10.83) v3(253.23,10.82) v3(282.14,37.55) v3(282.14,37.07) v3(285.44,17.93) v4(11.98,10.24) v4(12.23,10.24) v4(23.57,9.81) v4(23.59,9.52) v4(48.24,5.85) v4(48.52,5.85) v4(60.64,10.42) v4(60.93,10.4) v4(135.74,8.87) v4(136,8.87) v4(151.26,42.23) v4(151.26,41.97) v4(162.99,7.78) v4(163.25,7.78) v4(165.9,10.54) v4(166.21,10.54) v4(281.88,37.87) v4(281.84,37.24) v5(132.32,9.21) v5(132.32,8.94) v7(268.17,49.05) v7(268.17,48.77) v7(269.01,49.12) v7(269.01,48.84) v7(282.67,18.36) v7(283.27,18.36) v8(2.61,13.89) v8(3.75,22.64) v8(17.5,61.09) v8(18.12,61.14) v8(18.64,4.06) v8(18.75,61.1) v8(19.25,4.04) v8(21.2,24.05) v8(30.47,24.23) v8(31.07,24.22) v8(46.58,55.01) v8(46.59,54.42) v8(47.82,41.26) v8(47.79,40.57) v8(47.92,39.33) v8(48.05,39.99) v8(48.38,40.57) v8(48.4,41.26) v8(48.5,39.33) v8(48.63,39.99) v8(48.72,41.85) v8(48.96,40.57) v8(48.99,41.26) v8(49.21,39.99) v8(49.37,41.84) v8(49.57,41.26) v8(49.54,40.57) v8(49.8,39.99) v8(49.99,41.83) v8(50.16,41.24) v8(50.13,40.57) v8(50.38,39.99) v8(50.97,39.99) v8(266.46,51.93) v8(266.44,51.17) v8(266.44,50.36) v8(266.89,52.42) v8(266.94,51.57) v8(266.93,50.75) v9(52.93,5.92) v9(53.21,5.92) v11(22.47,58.43) v11(150.2,40.44) v11(154.68,33.53)
