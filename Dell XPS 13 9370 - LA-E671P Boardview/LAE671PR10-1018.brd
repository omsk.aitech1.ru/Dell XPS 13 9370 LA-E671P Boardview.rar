# Allegro board LAE671PR10-1018.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
H_1P2X1P7N
  oval 1.194x1.702 hole 1.194x1.702 unplated: (0,0)
H_1P8-G
  round 2.311 hole 1.803: 1(0,0)
H_1P8N
  round 1.803 hole 1.803 unplated: (0,0)
H_1P8X2P3N
  oval 1.803x2.311 hole 1.803x2.311 unplated: (0,0)
H_2P0-G
  round 2.515 hole 2.007: 1(0,0)
H_2P0N
  round 2.007 hole 2.007 unplated: (0,0)
H_2P6-G
  round 3.099 hole 2.591: 1(0,0)
H_3P3-G
  round 3.81 hole 3.302: 1(0,0)
HRS_BM20B0P810DS0P4V51_10P-T
  oval 0.203x0.559 smd: 1(0,0) 2(0,-2.33) 3(-0.4,0) 4(-0.4,-2.33) 5(-0.8,0) 6(-0.8,-2.33) 7(-1.2,0) 8(-1.2,-2.33) 9(-1.6,0) 10(-1.6,-2.33)
  rect 0.305x0.889 smd: 11(1.21,-2.165) 12(1.21,-0.165) 13(-2.81,-0.165) 14(-2.81,-2.165)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INTEL_8260PD2WMLGPNVQ_108P
  oval 0.508x0.305 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 9(0,-4) 10(0,-4.5) 11(0,-5) 12(0,-5.5) 13(0,-6) 14(0,-6.5) 15(0,-7) 16(0,-7.5) 17(0,-8) 18(0,-8.5) 19(0,-9) 20(0,-9.5) 21(0,-10) 22(0,-10.5) 23(0,-11) 24(0,-11.5) 25(0,-12) 26(0,-12.5) 27(0,-13) 28(0,-13.5) 49(11.2,-13.5) 50(11.2,-13) 51(11.2,-12.5) 52(11.2,-12) 53(11.2,-11.5) 54(11.2,-11) 55(11.2,-10.5) 56(11.2,-10) 57(11.2,-9.5) 58(11.2,-9) 59(11.2,-8.5) 60(11.2,-8) 61(11.2,-7.5) 62(11.2,-7) 63(11.2,-6.5) 64(11.2,-6) 65(11.2,-5.5) 66(11.2,-5) 67(11.2,-4.5) 68(11.2,-4) 69(11.2,-3.5) 70(11.2,-3) 71(11.2,-2.5) 72(11.2,-2) 73(11.2,-1.5) 74(11.2,-1) 75(11.2,-0.5) 76(11.2,0)
  oval 0.305x0.508 smd: 29(0.85,-14.35) 30(1.35,-14.35) 31(1.85,-14.35) 32(2.35,-14.35) 33(2.85,-14.35) 34(3.35,-14.35) 35(3.85,-14.35) 36(4.35,-14.35) 37(4.85,-14.35) 38(5.35,-14.35) 39(5.85,-14.35) 40(6.35,-14.35) 41(6.85,-14.35) 42(7.35,-14.35) 43(7.85,-14.35) 44(8.35,-14.35) 45(8.85,-14.35) 46(9.35,-14.35) 47(9.85,-14.35) 48(10.35,-14.35) 77(10.35,0.85) 78(9.85,0.85) 79(9.35,0.85) 80(8.85,0.85) 81(8.35,0.85) 82(7.85,0.85) 83(7.35,0.85) 84(6.85,0.85) 85(6.35,0.85) 86(5.85,0.85) 87(5.35,0.85) 88(4.85,0.85) 89(4.35,0.85) 90(3.85,0.85) 91(3.35,0.85) 92(2.85,0.85) 93(2.35,0.85) 94(1.85,0.85) 95(1.35,0.85) 96(0.85,0.85)
  rect 0.711x0.711 smd: 97(0.1,0.75) 98(0.1,-14.25) 99(11.1,0.75) 100(11.1,-14.25)
  rect 2.997x2.997 smd: 101(3.95,-1.8) 102(3.95,-5.1) 103(3.95,-8.4) 104(3.95,-11.7) 105(7.25,-1.8) 106(7.25,-5.1) 107(7.25,-8.4) 108(7.25,-11.7)
ISL88738HRTZ-T_TQFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
ISL95829AHRTZ-T_TQFN48_6X6
  oval 0.94x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.05,-4.4) 26(6.05,-4) 27(6.05,-3.6) 28(6.05,-3.2) 29(6.05,-2.8) 30(6.05,-2.4) 31(6.05,-2) 32(6.05,-1.6) 33(6.05,-1.2) 34(6.05,-0.8) 35(6.05,-0.4) 36(6.05,0)
  oval 0.203x0.94 smd: 13(0.825,-5.225) 14(1.225,-5.225) 15(1.625,-5.225) 16(2.025,-5.225) 17(2.425,-5.225) 18(2.825,-5.225) 19(3.225,-5.225) 20(3.625,-5.225) 21(4.025,-5.225) 22(4.425,-5.225) 23(4.825,-5.225) 24(5.225,-5.225) 37(5.225,0.825) 38(4.825,0.825) 39(4.425,0.825) 40(4.025,0.825) 41(3.625,0.825) 42(3.225,0.825) 43(2.825,0.825) 44(2.425,0.825) 45(2.025,0.825) 46(1.625,0.825) 47(1.225,0.825) 48(0.825,0.825)
  rect 4.394x4.394 smd: 49(3.025,-2.2)
JAE_DX07SA24XJ2_24P-T
  round 0.762 hole 0.762 unplated: (-0.85,-0.66)
  oval 0.94x0.762 hole 0.94x0.762 unplated: (6.35,-0.66)
  custom 0.275x0.275 hole 0.61x1.6: 1(-1.85,-5.06) 4(7.35,-5.06)
  oval 1.092x2.108 hole 0.61x1.6: 2(-1.85,-2.06) 3(7.35,-2.06)
  rect 1.499x1.6 smd: 7(0.75,-5.91) 8(4.75,-5.91)
  oval 0.305x1.092 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  round 0.61 hole 0.406: B1(5.55,-1.31) B2(5.15,-2.01) B3(4.35,-2.01) B4(3.95,-1.31) B5(3.55,-2.01) B6(3.15,-1.31) B7(2.35,-1.31) B8(1.95,-2.01) B9(1.55,-1.31) B10(1.15,-2.01) B11(0.35,-2.01) B12(-0.05,-1.31)
JAE_DX07SD24JJ3_24P-T
  round 0.66 hole 0.66 unplated: (-0.975,-2.7)
  oval 0.838x0.66 hole 0.838x0.66 unplated: (6.225,-2.635)
  custom 0.325x0.325 hole 0.711x2.007: 1(-1.695,-5.75) 4(6.945,-5.75)
  oval 1.194x2.311 hole 0.61x1.905: 2(-1.695,-0.7) 3(6.945,-0.7)
  oval 1.651x1.092 hole 1.245x0.711: 5(-1.37,-1.3) 6(6.62,-1.3)
  oval 0.279x0.889 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  oval 0.279x0.787 smd: B1(5.25,-1.6) B2(4.75,-1.6) B3(4.25,-1.6) B4(3.75,-1.6) B5(3.25,-1.6) B6(2.75,-1.6) B7(2.25,-1.6) B8(1.75,-1.6) B9(1.25,-1.6) B10(0.75,-1.6) B11(0.25,-1.6) B12(-0.25,-1.6)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JXT_FP225H-010G1AM_10P
  oval 0.305x0.991 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.991x2.007 smd: 11(-2.1,-3.1) 12(6.6,-3.1)
L2N7002WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L_5X5X3_M_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
LED_27-11-T1D-CP1Q1RY-3C_2P
  rect 0.991x0.991 smd: 1(0,0) 2(1.9,0)
LED_HT-F196BP5_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LOTES_APCI0146-P004A_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.775) 77(19.6,-0.775)
MAG_MMD-04BZ-1R0M-V1_2P
  rect 1.397x2.311 smd: 1(0,0) 2(3.555,0)
MAG_MMD-05CZN1R5M-V1L_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
MAX34407EWE-T_WLP_16P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) C1(0,-1) C2(0.5,-1) C3(1,-1) C4(1.5,-1) D1(0,-1.5) D2(0.5,-1.5) D3(1,-1.5) D4(1.5,-1.5)
MC74VHC1G08DFT2G_SC70-5
  oval 0.381x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MC74VHC1G09DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MEC5105_WFBGA_169P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A6(4,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B6(4,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C6(4,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D6(4,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E6(4,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F6(4,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G6(4,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H6(4,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J6(4,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K6(4,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L6(4,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M6(4,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N6(4,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601)
MMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15BB220SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX181SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX330SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX600SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM18EG221SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
NEC_MPCH0730LR15_2P
  rect 2.692x2.591 smd: 1(0,0) 2(6.2,0)
NPCT650JAAYX_QFN32_5X5-S
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
R0201_0OHM
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
R_2512
  rect 1.803x2.997 smd: 1(0,0) 2(6.2,0)
RB751V40_SC76-2
  rect 0.61x0.61 smd: 1(0,0) 2(2.2,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT9069-33GB_SOT23-5
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0,2.6)
RTS5242-GR_QFN32_4X4-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
SE30AFB-M3-6A_SMA2
  rect 1.194x1.524 smd: 1(0,0) 2(4.32,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI1303DL-T1-E3_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
SKL-U_BGA_1356P-T
  round 0.356 smd: A3(-0.965,0) A70(-40.166,0) B2(-0.483,0.483) B71(-40.629,0.462) BA1(0,22.166) BA71(-40.629,22.166) BB2(-0.462,22.628) BB70(-40.166,22.628) C1(0,0.965)
  round 0.33 smd: A4(-1.615,0) A69(-39.516,0) AY1(0,21.516) AY71(-40.629,21.516) B3(-1.118,0.635) B70(-39.999,0.63) BA2(-0.629,21.999) BA70(-39.999,21.999) BB3(-1.113,22.628) BB69(-39.516,22.628) C2(-0.635,1.118) C71(-40.629,1.113) D1(0,1.615)
  round 0.305 smd: A5(-2.266,0) A68(-38.866,0) AA2(-0.975,10.804) AA4(-1.951,10.804) AA63(-35.427,10.719) AA64(-36.077,10.719) AA65(-36.727,10.719) AA66(-37.377,10.719) AA67(-38.028,10.719) AA68(-38.678,10.719) AA69(-39.328,10.719) AA70(-39.978,10.719) AA71(-40.629,10.719) AB4(-1.951,11.467) AB6(-2.729,11.181) AB7(-3.379,11.181) AB8(-4.029,11.181) AB9(-4.679,11.181) AB10(-5.33,11.181) AB11(-5.98,11.181) AB12(-6.63,11.181) AB13(-7.28,11.181) AB15(-8.126,11.305) AB16(-8.776,11.305) AB17(-9.426,11.305) AB18(-10.077,11.305) AB19(-10.727,11.305) AB20(-11.377,11.305) AB21(-12.027,11.305) AB62(-34.958,11.176) AC3(-1.626,12.13) AC63(-35.427,11.633) AC64(-36.077,11.633) AC65(-36.727,11.633) AC66(-37.377,11.633) AC67(-38.028,11.633) AC68(-38.678,11.633) AC69(-39.328,11.633) AC70(-39.978,11.633) AC71(-40.629,11.633) AD4(-1.951,12.792) AD6(-2.729,12.248) AD7(-3.379,12.248) AD8(-4.029,12.248) AD9(-4.679,12.248) AD10(-5.33,12.248) AD11(-5.98,12.248) AD12(-6.63,12.248) AD13(-7.28,12.248) AD15(-8.126,12.143) AD16(-8.776,12.143) AD17(-9.426,12.143) AD18(-10.077,12.143) AD19(-10.727,12.143) AD20(-11.377,12.143) AD21(-12.027,12.143) AD62(-34.958,12.09) AE62(-34.958,13.005) AE63(-35.427,12.547) AE64(-36.077,12.547) AE65(-36.727,12.547) AE66(-37.377,12.547) AE67(-38.028,12.547) AE68(-38.678,12.547) AE69(-39.328,12.547) AF2(-0.975,13.455) AF4(-1.951,13.455) AF6(-2.729,13.315) AF7(-3.379,13.315) AF8(-4.029,13.315) AF9(-4.679,13.315) AF10(-5.33,13.315) AF11(-5.98,13.315) AF12(-6.63,13.315) AF13(-7.28,13.315) AF15(-8.126,12.982) AF16(-8.776,12.982) AF17(-9.426,12.982) AF18(-10.077,12.982) AF19(-10.727,12.982) AF20(-11.377,12.982) AF21(-12.027,12.982) AF63(-35.427,13.462) AF64(-36.077,13.462) AF65(-36.727,13.462) AF66(-37.377,13.462) AF67(-38.028,13.462) AF68(-38.678,13.253) AF69(-39.328,13.253) AG4(-1.951,14.118) AG15(-8.126,13.82) AG16(-8.776,13.82) AG17(-9.426,13.82) AG18(-10.077,13.82) AG19(-10.727,13.82) AG20(-11.377,13.82) AG21(-12.027,13.82) AG62(-34.958,13.919) AG69(-39.003,13.916) AH3(-1.626,14.781) AH6(-2.729,14.381) AH7(-3.379,14.381) AH8(-4.029,14.381) AH9(-4.679,14.381) AH10(-5.33,14.381) AH11(-5.98,14.381) AH12(-6.63,14.381) AH13(-7.28,14.381) AH63(-35.427,14.376) AH64(-36.077,14.376) AH65(-36.727,14.376) AH66(-37.377,14.376) AH67(-38.028,14.376) AJ4(-1.951,15.444) AJ15(-8.126,14.658) AJ16(-8.776,14.658) AJ17(-9.426,14.658) AJ18(-10.077,14.658) AJ19(-10.727,14.658) AJ20(-11.377,14.658) AJ21(-12.027,14.658) AJ62(-34.958,14.833) AK6(-2.729,15.321) AK7(-3.379,15.321) AK8(-4.029,15.321) AK9(-4.679,15.321) AK10(-5.33,15.321) AK11(-5.98,15.321) AK12(-6.63,15.321) AK13(-7.28,15.321) AK15(-8.126,15.496) AK16(-8.776,15.496) AK17(-9.426,15.496) AK18(-10.077,15.496) AK19(-10.727,15.496) AK20(-11.377,15.496) AK21(-12.027,15.496) AK22(-12.719,15.323) AK23(-13.633,15.323) AK25(-14.547,15.323) AK27(-15.462,15.323) AK28(-16.376,15.323) AK30(-17.291,15.323) AK32(-18.205,15.323) AK33(-19.119,15.323) AK35(-20.034,15.323) AK37(-20.948,15.323) AK38(-21.863,15.323) AK40(-22.777,15.323) AK42(-23.691,15.323) AK43(-24.606,15.323) AK45(-25.52,15.323) AK46(-26.435,15.323) AK48(-27.349,15.323) AK50(-28.263,15.323) AK52(-29.178,15.323) AK53(-30.092,15.323) AK55(-31.007,15.323) AK56(-31.921,15.323) AK58(-32.835,15.323) AK60(-33.75,15.323) AK62(-34.774,15.458) AK63(-35.427,15.291) AK64(-36.077,15.291) AK65(-36.727,15.291) AK66(-37.377,15.291) AK67(-38.028,15.291) AK68(-38.678,15.143) AK69(-39.653,15.143) AL2(-0.975,16.107) AL4(-1.951,16.107) AL23(-13.176,15.788) AL25(-14.09,15.788) AL27(-15.005,15.788) AL28(-15.919,15.788) AL30(-16.833,15.788) AL32(-17.748,15.788) AL33(-18.662,15.788) AL35(-19.577,15.788) AL37(-20.491,15.788) AL38(-21.405,15.788) AL40(-22.32,15.788) AL42(-23.234,15.788) AL43(-24.149,15.788) AL45(-25.063,15.788) AL46(-25.977,15.788) AL48(-26.892,15.788) AL50(-27.806,15.788) AL52(-28.721,15.788) AL53(-29.635,15.788) AL55(-30.549,15.788) AL56(-31.464,15.788) AL58(-32.378,15.788) AL60(-33.293,15.788) AL61(-34.207,15.788) AL63(-35.427,16.159) AL64(-36.077,16.159) AL65(-36.727,16.159) AL66(-37.377,16.159) AM4(-1.951,16.77) AM5(-2.66,16.261) AM7(-3.575,16.261) AM8(-4.489,16.261) AM10(-5.403,16.261) AM11(-6.318,16.261) AM13(-7.232,16.261) AM15(-8.147,16.261) AM16(-9.061,16.261) AM18(-9.975,16.261) AM20(-10.89,16.261) AM21(-11.804,16.261) AM22(-12.719,16.261) AM23(-13.633,16.261) AM25(-14.547,16.261) AM27(-15.462,16.261) AM28(-16.376,16.261) AM30(-17.291,16.261) AM32(-18.205,16.261) AM33(-19.119,16.261) AM35(-20.034,16.261) AM37(-20.948,16.261) AM38(-21.863,16.261) AM40(-22.777,16.261) AM42(-23.691,16.261) AM43(-24.606,16.261) AM45(-25.52,16.261) AM46(-26.435,16.261) AM48(-27.349,16.261) AM50(-28.263,16.261) AM52(-29.178,16.261) AM53(-30.092,16.261) AM55(-31.007,16.261) AM56(-31.921,16.261) AM58(-32.835,16.261) AM60(-33.75,16.261) AM61(-34.664,16.261) AM68(-38.353,16.37) AM69(-39.003,16.37) AN3(-1.626,17.433) AN5(-2.66,16.911) AN7(-3.575,16.911) AN8(-4.489,16.911) AN10(-5.403,16.911) AN11(-6.318,16.911) AN13(-7.232,16.911) AN15(-8.147,16.911) AN16(-9.061,16.911) AN18(-9.975,16.911) AN20(-10.89,16.911) AN21(-11.804,16.911) AN22(-12.719,16.911) AN23(-13.633,16.911) AN25(-14.547,16.911) AN27(-15.462,16.911) AN28(-16.376,16.911) AN30(-17.291,16.911) AN32(-18.205,16.911) AN33(-19.119,16.911) AN35(-20.034,16.911) AN37(-20.948,16.911) AN38(-21.863,16.911) AN40(-22.777,16.911) AN42(-23.691,16.911) AN43(-24.606,16.911) AN45(-25.52,16.911) AN46(-26.435,16.911) AN48(-27.349,16.911) AN50(-28.263,16.911) AN52(-29.178,16.911) AN53(-30.092,16.911) AN55(-31.007,16.911) AN56(-31.921,16.911) AN58(-32.835,16.911) AN60(-33.75,16.911) AN61(-34.664,16.911) AN63(-35.579,16.911) AN65(-36.493,16.911) AN66(-37.407,16.911) AN68(-38.678,17.033) AN69(-39.328,17.033) AP4(-1.951,18.096) AP5(-2.66,17.561) AP7(-3.575,17.561) AP8(-4.489,17.561) AP10(-5.403,17.561) AP11(-6.318,17.561) AP13(-7.232,17.561) AP15(-8.147,17.561) AP16(-9.061,17.561) AP18(-9.975,17.561) AP20(-10.89,17.561) AP21(-11.804,17.561) AP22(-12.719,17.561) AP23(-13.633,17.561) AP25(-14.547,17.561) AP27(-15.462,17.561) AP28(-16.376,17.561) AP30(-17.291,17.561) AP32(-18.205,17.561) AP33(-19.119,17.561) AP35(-20.034,17.561) AP37(-20.948,17.561) AP38(-21.863,17.561) AP40(-22.777,17.561) AP42(-23.691,17.561) AP43(-24.606,17.561) AP45(-25.52,17.561) AP46(-26.435,17.561) AP48(-27.349,17.561) AP50(-28.263,17.561) AP52(-29.178,17.561) AP53(-30.092,17.561) AP55(-31.007,17.561) AP56(-31.921,17.561) AP58(-32.835,17.561) AP60(-33.75,17.561) AP61(-34.664,17.561) AP63(-35.579,17.561) AP65(-36.493,17.561) AP66(-37.407,17.561) AP68(-38.353,17.646) AP70(-39.572,17.646) AR5(-2.66,18.211) AR7(-3.575,18.211) AR8(-4.489,18.211) AR10(-5.403,18.211) AR11(-6.318,18.211) AR13(-7.232,18.211) AR15(-8.147,18.211) AR16(-9.061,18.211) AR18(-9.975,18.211) AR20(-10.89,18.211) AR21(-11.804,18.211) AR22(-12.719,18.211) AR23(-13.633,18.211) AR25(-14.547,18.211) AR27(-15.462,18.211) AR28(-16.376,18.211) AR30(-17.291,18.211) AR32(-18.205,18.211) AR33(-19.119,18.211) AR35(-20.034,18.211) AR37(-20.948,18.211) AR38(-21.863,18.211) AR40(-22.777,18.211) AR42(-23.691,18.211) AR43(-24.606,18.211) AR45(-25.52,18.211) AR46(-26.435,18.211) AR48(-27.349,18.211) AR50(-28.263,18.211) AR52(-29.178,18.211) AR53(-30.092,18.211) AR55(-31.007,18.211) AR56(-31.921,18.211) AR58(-32.835,18.211) AR60(-33.75,18.211) AR61(-34.664,18.211) AR63(-35.579,18.211) AR65(-36.493,18.211) AR66(-37.407,18.211) AR68(-38.678,18.26) AR69(-39.328,18.26) AT2(-0.975,18.759) AT4(-1.951,18.759) AT5(-2.66,18.862) AT7(-3.575,18.862) AT8(-4.489,18.862) AT10(-5.403,18.862) AT11(-6.318,18.862) AT13(-7.232,18.862) AT15(-8.147,18.862) AT16(-9.061,18.862) AT18(-9.975,18.862) AT20(-10.89,18.862) AT21(-11.804,18.862) AT22(-12.719,18.862) AT23(-13.633,18.862) AT25(-14.547,18.862) AT27(-15.462,18.862) AT28(-16.376,18.862) AT30(-17.291,18.862) AT32(-18.205,18.862) AT33(-19.119,18.862) AT35(-20.034,18.862) AT37(-20.948,18.862) AT38(-21.863,18.862) AT40(-22.777,18.862) AT42(-23.691,18.862) AT43(-24.606,18.862) AT45(-25.52,18.862) AT46(-26.435,18.862) AT48(-27.349,18.862) AT50(-28.263,18.862) AT52(-29.178,18.862) AT53(-30.092,18.862) AT55(-31.007,18.862) AT56(-31.921,18.862) AT58(-32.835,18.862) AT60(-33.75,18.862) AT61(-34.664,18.862) AT63(-35.579,18.862) AT65(-36.493,18.862) AT66(-37.407,18.862) AT68(-38.353,18.823) AT69(-39.003,18.823) AU4(-1.951,19.422) AU5(-2.66,19.512) AU7(-3.575,19.512) AU8(-4.489,19.512) AU10(-5.403,19.512) AU11(-6.318,19.512) AU13(-7.232,19.512) AU15(-8.147,19.512) AU16(-9.061,19.512) AU18(-9.975,19.512) AU20(-10.89,19.512) AU21(-11.804,19.512) AU22(-12.719,19.512) AU23(-13.633,19.512) AU25(-14.547,19.512) AU27(-15.462,19.512) AU28(-16.376,19.512) AU30(-17.291,19.512) AU32(-18.205,19.512) AU33(-19.119,19.512) AU35(-20.034,19.512) AU37(-20.948,19.512) AU38(-21.863,19.512) AU40(-22.777,19.512) AU42(-23.691,19.512) AU43(-24.606,19.512) AU45(-25.52,19.512) AU46(-26.435,19.512) AU48(-27.349,19.512) AU50(-28.263,19.512) AU52(-29.178,19.512) AU53(-30.092,19.512) AU55(-31.007,19.512) AU56(-31.921,19.512) AU58(-32.835,19.512) AU60(-33.75,19.512) AU61(-34.664,19.512) AU63(-35.579,19.512) AU65(-36.493,19.512) AU66(-37.407,19.512) AV3(-1.626,20.113) AV68(-38.343,20.026) AV69(-39.328,20.215) AV70(-39.978,20.215) AW1(0,20.866) AW5(-2.534,20.226) AW6(-3.184,20.353) AW7(-3.75,20.678) AW8(-4.328,20.353) AW9(-4.898,20.678) AW10(-5.561,20.353) AW11(-6.171,20.678) AW12(-6.749,20.353) AW13(-7.319,20.678) AW14(-7.982,20.353) AW15(-8.592,20.678) AW16(-9.17,20.353) AW17(-9.74,20.678) AW18(-10.403,20.353) AW20(-11.012,20.678) AW21(-11.59,20.353) AW22(-12.16,20.678) AW23(-12.849,20.353) AW25(-13.486,20.678) AW26(-14.05,20.353) AW27(-14.713,20.678) AW28(-15.326,20.353) AW29(-15.94,20.678) AW30(-16.603,20.353) AW31(-17.167,20.678) AW32(-17.83,20.353) AW33(-18.467,20.678) AW34(-19.031,20.353) AW35(-19.694,20.678) AW36(-20.307,20.353) AW37(-20.921,20.678) AW38(-21.584,20.353) AW39(-22.148,20.678) AW41(-22.785,20.353) AW42(-23.423,20.678) AW43(-23.986,20.353) AW44(-24.649,20.678) AW45(-25.263,20.353) AW46(-25.876,20.678) AW47(-26.477,20.353) AW48(-27.041,20.678) AW49(-27.669,20.353) AW50(-28.298,20.678) AW51(-28.862,20.353) AW52(-29.463,20.678) AW53(-30.076,20.353) AW54(-30.69,20.678) AW55(-31.352,20.353) AW56(-31.916,20.678) AW57(-32.554,20.353) AW59(-33.191,20.678) AW60(-33.755,20.353) AW61(-34.418,20.678) AW62(-35.032,20.353) AW63(-35.645,20.678) AW64(-36.308,20.353) AW65(-36.872,20.678) AW66(-37.407,20.215) AW67(-38.332,20.685) AW68(-38.936,20.936) AW69(-39.581,20.85) AW70(-39.999,21.349) AW71(-40.629,20.866) AY2(-0.629,21.348) AY3(-1.286,21.342) AY4(-2.04,21.357) AY5(-2.649,21.003) AY8(-4.328,21.003) AY12(-6.749,21.003) AY16(-9.17,21.003) AY21(-11.59,21.003) AY26(-14.05,21.003) AY27(-14.713,21.328) AY29(-15.94,21.328) AY30(-16.603,21.003) AY34(-19.031,21.003) AY35(-19.694,21.328) AY37(-20.921,21.328) AY38(-21.584,21.003) AY43(-23.986,21.003) AY44(-24.649,21.328) AY46(-25.876,21.328) AY47(-26.477,21.003) AY51(-28.862,21.003) AY52(-29.463,21.328) AY54(-30.69,21.328) AY55(-31.352,21.003) AY60(-33.755,21.003) AY61(-34.418,21.328) AY63(-35.645,21.328) AY64(-36.308,21.003) AY66(-37.535,21.003) AY68(-38.85,21.581) B5(-2.266,0.65) B6(-2.847,0.975) B10(-5.325,0.975) B14(-7.803,0.975) B18(-10.281,0.975) B22(-12.759,0.975) B26(-15.237,0.975) B30(-17.715,0.975) B34(-20.194,0.975) B39(-22.672,0.975) B44(-25.15,0.975) B48(-27.628,0.975) B53(-30.106,0.975) B58(-32.584,0.975) B62(-35.062,0.975) B66(-37.54,0.975) B69(-39.349,0.63) BA3(-1.279,21.999) BA5(-2.599,21.94) BA8(-4.328,21.653) BA12(-6.749,21.653) BA16(-9.17,21.653) BA21(-11.59,21.653) BA23(-12.849,21.572) BA28(-15.326,21.572) BA32(-17.83,21.572) BA36(-20.307,21.572) BA41(-22.785,21.572) BA45(-25.263,21.572) BA49(-27.669,21.653) BA53(-30.076,21.572) BA57(-32.554,21.572) BA62(-35.032,21.572) BA68(-39.349,21.999) BB4(-1.763,22.628) BB68(-38.866,22.628) C4(-1.699,0.978) C5(-2.266,1.3) C7(-3.523,1.3) C8(-4.086,0.975) C9(-4.65,1.3) C11(-6.001,1.3) C12(-6.564,0.975) C13(-7.128,1.3) C15(-8.479,1.3) C16(-9.042,0.975) C17(-9.606,1.3) C19(-10.957,1.3) C20(-11.52,0.975) C21(-12.084,1.3) C23(-13.435,1.3) C24(-13.998,0.975) C25(-14.562,1.3) C27(-15.913,1.3) C28(-16.476,0.975) C29(-17.04,1.3) C31(-18.391,1.3) C32(-18.954,0.975) C33(-19.518,1.3) C36(-20.869,1.3) C37(-21.433,0.975) C38(-21.996,1.3) C40(-23.347,1.3) C41(-23.911,0.975) C42(-24.474,1.3) C45(-25.825,1.3) C46(-26.389,0.975) C47(-26.952,1.3) C50(-28.303,1.3) C51(-28.867,0.975) C52(-29.43,1.3) C54(-30.781,1.3) C55(-31.345,0.975) C56(-31.908,1.3) C59(-33.259,1.3) C60(-33.823,0.975) C61(-34.386,1.3) C63(-35.737,1.3) C64(-36.301,0.975) C65(-36.864,1.3) C67(-38.799,1.015) C68(-38.936,1.693) C70(-39.999,1.28) D3(-0.975,1.706) D4(-1.624,1.646) D5(-2.224,1.951) D6(-2.873,1.991) D7(-3.523,1.951) D8(-4.086,1.626) D9(-4.65,1.951) D10(-5.325,1.991) D11(-6.001,1.951) D12(-6.564,1.626) D13(-7.128,1.951) D14(-7.803,1.991) D15(-8.479,1.951) D16(-9.042,1.626) D17(-9.606,1.951) D18(-10.281,1.991) D19(-10.957,1.951) D20(-11.52,1.626) D21(-12.084,1.951) D22(-12.759,1.991) D23(-13.435,1.951) D24(-13.998,1.626) D25(-14.562,1.951) D26(-15.237,1.991) D27(-15.913,1.951) D28(-16.476,1.626) D29(-17.04,1.951) D30(-17.715,1.991) D31(-18.391,1.951) D32(-18.954,1.626) D33(-19.518,1.951) D34(-20.194,1.991) D36(-20.869,1.951) D37(-21.433,1.626) D38(-21.996,1.951) D39(-22.672,1.991) D40(-23.347,1.951) D41(-23.911,1.626) D42(-24.474,1.951) D44(-25.15,1.991) D45(-25.825,1.951) D46(-26.389,1.626) D47(-26.952,1.951) D48(-27.628,1.991) D50(-28.303,1.951) D51(-28.867,1.626) D52(-29.43,1.951) D53(-30.106,1.991) D54(-30.781,1.951) D55(-31.345,1.626) D56(-31.908,1.951) D58(-32.584,1.991) D59(-33.259,1.951) D60(-33.823,1.626) D61(-34.386,1.951) D62(-35.062,1.991) D63(-35.737,1.951) D64(-36.301,1.626) D65(-36.864,1.951) D66(-37.54,1.991) D67(-38.213,1.3) D68(-39.582,1.779) D69(-38.876,2.343) D71(-40.629,1.763) E1(0,2.274) E2(-0.65,2.274) E3(-1.3,2.274) E5(-2.66,2.723) E6(-3.575,2.723) E8(-4.489,2.723) E10(-5.403,2.723) E11(-6.318,2.723) E13(-7.232,2.723) E15(-8.147,2.723) E16(-9.061,2.723) E18(-9.975,2.723) E20(-10.89,2.723) E21(-11.804,2.723) E22(-12.719,2.723) E23(-13.633,2.723) E25(-14.547,2.723) E27(-15.462,2.723) E28(-16.376,2.723) E30(-17.291,2.723) E32(-18.205,2.723) E33(-19.119,2.723) E35(-20.034,2.723) E37(-20.948,2.723) E38(-21.863,2.723) E40(-22.777,2.723) E42(-23.691,2.723) E43(-24.606,2.723) E45(-25.52,2.723) E46(-26.435,2.723) E48(-27.349,2.723) E50(-28.263,2.723) E52(-29.178,2.723) E53(-30.092,2.723) E55(-31.007,2.723) E56(-31.921,2.723) E58(-32.835,2.723) E60(-33.75,2.723) E61(-34.664,2.723) E63(-35.629,2.659) E65(-36.645,2.659) E66(-37.661,2.659) E68(-38.213,1.951) F2(-0.975,2.848) F4(-1.951,2.848) F5(-2.66,3.373) F6(-3.575,3.373) F8(-4.489,3.373) F10(-5.403,3.373) F11(-6.318,3.373) F13(-7.232,3.373) F15(-8.147,3.373) F16(-9.061,3.373) F18(-9.975,3.373) F20(-10.89,3.373) F21(-11.804,3.373) F22(-12.719,3.373) F23(-13.633,3.373) F25(-14.547,3.373) F27(-15.462,3.373) F28(-16.376,3.373) F30(-17.291,3.373) F32(-18.205,3.373) F33(-19.119,3.373) F35(-20.034,3.373) F37(-20.948,3.373) F38(-21.863,3.373) F40(-22.777,3.373) F42(-23.691,3.373) F43(-24.606,3.373) F45(-25.52,3.373) F46(-26.435,3.373) F48(-27.349,3.373) F50(-28.263,3.373) F52(-29.178,3.373) F53(-30.092,3.373) F55(-31.007,3.373) F56(-31.921,3.373) F58(-32.835,3.373) F60(-33.75,3.373) F61(-34.664,3.373) F63(-35.629,3.31) F65(-36.645,3.31) F66(-37.661,3.31) F68(-38.876,2.994) G4(-1.951,3.511) G5(-2.66,4.023) G6(-3.575,4.023) G8(-4.489,4.023) G10(-5.403,4.023) G11(-6.318,4.023) G13(-7.232,4.023) G15(-8.147,4.023) G16(-9.061,4.023) G18(-9.975,4.023) G20(-10.89,4.023) G21(-11.804,4.023) G22(-12.719,4.023) G23(-13.633,4.023) G25(-14.547,4.023) G27(-15.462,4.023) G28(-16.376,4.023) G30(-17.291,4.023) G32(-18.205,4.023) G33(-19.119,4.023) G35(-20.034,4.023) G37(-20.948,4.023) G38(-21.863,4.023) G40(-22.777,4.023) G42(-23.691,4.023) G43(-24.606,4.023) G45(-25.52,4.023) G46(-26.435,4.023) G48(-27.349,4.023) G50(-28.263,4.023) G52(-29.178,4.023) G53(-30.092,4.023) G55(-31.007,4.023) G56(-31.921,4.023) G58(-32.835,4.023) G60(-33.75,4.023) G61(-34.664,4.023) G63(-35.629,3.96) G65(-36.645,3.96) G66(-37.661,3.96) G68(-38.678,3.655) G69(-39.328,3.655) H3(-1.626,4.174) H5(-2.66,4.674) H6(-3.575,4.674) H8(-4.489,4.674) H10(-5.403,4.674) H11(-6.318,4.674) H13(-7.232,4.674) H15(-8.147,4.674) H16(-9.061,4.674) H18(-9.975,4.674) H20(-10.89,4.674) H21(-11.804,4.674) H63(-35.629,4.61) H65(-36.645,4.61) H66(-37.661,4.61) H69(-39.003,4.218) J4(-1.951,4.837) J5(-2.66,5.324) J6(-3.575,5.324) J8(-4.489,5.324) J10(-5.403,5.324) J11(-6.318,5.324) J13(-7.232,5.324) J22(-13.176,4.488) J23(-14.09,4.488) J25(-15.005,4.488) J27(-15.919,4.488) J28(-16.833,4.488) J30(-17.748,4.488) J32(-18.662,4.488) J33(-19.577,4.488) J35(-20.491,4.488) J37(-21.405,4.488) J38(-22.32,4.488) J40(-23.234,4.488) J42(-24.149,4.488) J43(-25.063,4.488) J45(-25.977,4.488) J46(-26.892,4.488) J48(-27.806,4.488) J50(-28.721,4.488) J52(-29.635,4.488) J53(-30.549,4.488) J55(-31.464,4.488) J56(-32.378,4.488) J58(-33.293,4.488) J60(-34.207,4.488) J68(-38.676,4.794) K15(-8.126,5.438) K16(-8.776,5.438) K17(-9.426,5.438) K18(-10.077,5.438) K19(-10.727,5.438) K20(-11.377,5.438) K21(-12.027,5.438) K22(-12.719,4.952) K23(-13.633,4.952) K25(-14.547,4.952) K27(-15.462,4.952) K28(-16.376,4.952) K30(-17.291,4.952) K32(-18.205,4.952) K33(-19.119,4.952) K35(-20.034,4.952) K37(-20.948,4.952) K38(-21.863,4.952) K40(-22.777,4.952) K42(-23.691,4.952) K43(-24.606,4.952) K45(-25.52,4.952) K46(-26.435,4.952) K48(-27.349,4.952) K50(-28.263,4.952) K52(-29.178,4.952) K53(-30.092,4.952) K55(-31.007,4.952) K56(-31.921,4.952) K58(-32.835,4.952) K60(-33.75,4.952) K61(-34.664,4.952) K63(-35.447,5.26) K64(-36.097,5.26) K65(-36.747,5.26) K66(-37.398,5.26) K67(-38.048,5.26) K68(-38.666,5.468) K70(-39.653,5.57) L2(-0.975,5.5) L4(-1.951,5.5) L6(-2.729,5.974) L7(-3.379,5.974) L8(-4.029,5.974) L9(-4.679,5.974) L10(-5.33,5.974) L11(-5.98,5.974) L12(-6.63,5.974) L13(-7.28,5.974) L15(-8.126,6.276) L16(-8.776,6.276) L17(-9.426,6.276) L18(-10.077,6.276) L19(-10.727,6.276) L20(-11.377,6.276) L21(-12.027,6.276) L62(-34.958,5.689) L63(-35.427,6.147) L64(-36.077,6.147) L65(-36.727,6.147) L66(-37.377,6.147) L67(-38.028,6.147) L68(-38.678,6.147) L69(-39.328,6.147) L70(-39.978,6.147) L71(-40.629,6.147) M4(-1.951,6.163) M62(-34.958,6.604) N3(-1.626,6.826) N6(-2.729,6.914) N7(-3.379,6.914) N8(-4.029,6.914) N9(-4.679,6.914) N10(-5.33,6.914) N11(-5.98,6.914) N12(-6.63,6.914) N13(-7.28,6.914) N15(-8.126,7.114) N16(-8.776,7.114) N17(-9.426,7.114) N18(-10.077,7.114) N19(-10.727,7.114) N20(-11.377,7.114) N21(-12.027,7.114) N63(-35.427,7.061) N64(-36.077,7.061) N65(-36.727,7.061) N66(-37.377,7.061) N67(-38.028,7.061) N68(-38.678,7.061) N69(-39.328,7.061) N70(-39.978,7.061) N71(-40.629,7.061) P4(-1.951,7.489) P15(-8.126,7.952) P16(-8.776,7.952) P17(-9.426,7.952) P18(-10.077,7.952) P19(-10.727,7.952) P20(-11.377,7.952) P21(-12.027,7.952) P62(-34.958,7.518) R6(-2.729,7.981) R7(-3.379,7.981) R8(-4.029,7.981) R9(-4.679,7.981) R10(-5.33,7.981) R11(-5.98,7.981) R12(-6.63,7.981) R13(-7.28,7.981) R63(-35.427,7.975) R64(-36.077,7.975) R65(-36.727,7.975) R66(-37.377,7.975) R67(-38.028,7.975) R68(-38.678,7.975) R69(-39.328,7.975) R70(-39.978,7.975) R71(-40.629,7.975) T2(-0.975,8.152) T4(-1.951,8.152) T15(-8.126,8.791) T16(-8.776,8.791) T17(-9.426,8.791) T18(-10.077,8.791) T19(-10.727,8.791) T20(-11.377,8.791) T21(-12.027,8.791) T62(-34.958,8.433) U4(-1.951,8.815) U6(-2.729,9.047) U7(-3.379,9.047) U8(-4.029,9.047) U9(-4.679,9.047) U10(-5.33,9.047) U11(-5.98,9.047) U12(-6.63,9.047) U13(-7.28,9.047) U63(-35.427,8.89) U64(-36.077,8.89) U65(-36.727,8.89) U66(-37.377,8.89) U67(-38.028,8.89) U68(-38.678,8.89) U69(-39.328,8.89) U70(-39.978,8.89) U71(-40.629,8.89) V3(-1.626,9.478) V15(-8.126,9.629) V16(-8.776,9.629) V17(-9.426,9.629) V18(-10.077,9.629) V19(-10.727,9.629) V20(-11.377,9.629) V21(-12.027,9.629) V62(-34.958,9.347) W4(-1.951,10.141) W6(-2.729,10.114) W7(-3.379,10.114) W8(-4.029,10.114) W9(-4.679,10.114) W10(-5.33,10.114) W11(-5.98,10.114) W12(-6.63,10.114) W13(-7.28,10.114) W63(-35.427,9.804) W64(-36.077,9.804) W65(-36.727,9.804) W66(-37.377,9.804) W67(-38.028,9.804) W68(-38.678,9.804) W69(-39.328,9.804) W70(-39.978,9.804) W71(-40.629,9.804) Y15(-8.126,10.467) Y16(-8.776,10.467) Y17(-9.426,10.467) Y18(-10.077,10.467) Y19(-10.727,10.467) Y20(-11.377,10.467) Y21(-12.027,10.467) Y62(-34.958,10.261)
  oval 0.254x0.343 smd: A6(-2.847,0.325) A7(-3.523,0) A9(-4.65,0) A10(-5.325,0.325) A11(-6.001,0) A13(-7.128,0) A14(-7.803,0.325) A15(-8.479,0) A17(-9.606,0) A18(-10.281,0.325) A19(-10.957,0) A21(-12.084,0) A22(-12.759,0.325) A23(-13.435,0) A25(-14.562,0) A26(-15.237,0.325) A27(-15.913,0) A29(-17.04,0) A30(-17.715,0.325) A31(-18.391,0) A33(-19.518,0) A34(-20.194,0.325) A36(-20.869,0) A38(-21.996,0) A39(-22.672,0.325) A40(-23.347,0) A42(-24.474,0) A44(-25.15,0.325) A45(-25.825,0) A47(-26.952,0) A48(-27.628,0.325) A50(-28.303,0) A52(-29.43,0) A53(-30.106,0.325) A54(-30.781,0) A56(-31.908,0) A58(-32.584,0.325) A59(-33.259,0) A61(-34.386,0) A62(-35.062,0.325) A63(-35.737,0) A65(-36.864,0) A66(-37.54,0.325) A67(-38.215,0) AY7(-3.763,21.328) AY9(-4.898,21.328) AY11(-6.184,21.328) AY13(-7.319,21.328) AY15(-8.604,21.328) AY17(-9.74,21.328) AY20(-11.025,21.328) AY22(-12.16,21.328) AY25(-13.486,21.328) AY31(-17.167,21.328) AY33(-18.467,21.328) AY39(-22.148,21.328) AY42(-23.423,21.328) AY48(-27.103,21.328) AY50(-28.236,21.328) AY56(-31.916,21.328) AY59(-33.191,21.328) AY65(-36.872,21.328) AY67(-38.216,21.328) B7(-3.523,0.65) B9(-4.65,0.65) B11(-6.001,0.65) B13(-7.128,0.65) B15(-8.479,0.65) B17(-9.606,0.65) B19(-10.957,0.65) B21(-12.084,0.65) B23(-13.435,0.65) B25(-14.562,0.65) B27(-15.913,0.65) B29(-17.04,0.65) B31(-18.391,0.65) B33(-19.518,0.65) B36(-20.869,0.65) B38(-21.996,0.65) B40(-23.347,0.65) B42(-24.474,0.65) B45(-25.825,0.65) B47(-26.952,0.65) B50(-28.303,0.65) B52(-29.43,0.65) B54(-30.781,0.65) B56(-31.908,0.65) B59(-33.259,0.65) B61(-34.386,0.65) B63(-35.737,0.65) B65(-36.864,0.65) B67(-38.215,0.65) BA4(-1.948,22.004) BA6(-3.141,21.572) BA7(-3.705,21.978) BA9(-4.898,21.978) BA10(-5.561,21.572) BA11(-6.125,21.978) BA13(-7.319,21.978) BA14(-7.982,21.572) BA15(-8.546,21.978) BA17(-9.74,21.978) BA18(-10.403,21.572) BA20(-10.966,21.978) BA22(-12.16,21.978) BA25(-13.486,21.978) BA26(-14.149,21.653) BA27(-14.812,21.978) BA29(-15.841,21.978) BA30(-16.504,21.653) BA31(-17.167,21.978) BA33(-18.467,21.978) BA34(-19.13,21.653) BA35(-19.793,21.978) BA37(-20.822,21.978) BA38(-21.485,21.653) BA39(-22.148,21.978) BA42(-23.423,21.978) BA43(-24.086,21.653) BA44(-24.748,21.978) BA46(-25.777,21.978) BA47(-26.44,21.653) BA48(-27.103,21.978) BA50(-28.236,21.978) BA51(-28.899,21.653) BA52(-29.562,21.978) BA54(-30.59,21.978) BA55(-31.253,21.653) BA56(-31.916,21.978) BA59(-33.191,21.978) BA60(-33.854,21.653) BA61(-34.517,21.978) BA63(-35.546,21.978) BA64(-36.209,21.653) BA65(-36.872,21.978) BA66(-37.535,21.653) BA67(-38.216,21.978) BB5(-2.529,22.628) BB6(-3.141,22.303) BB7(-3.705,22.628) BB9(-4.898,22.628) BB10(-5.561,22.303) BB11(-6.125,22.628) BB13(-7.319,22.628) BB14(-7.982,22.303) BB15(-8.546,22.628) BB17(-9.74,22.628) BB18(-10.403,22.303) BB20(-10.966,22.628) BB22(-12.16,22.628) BB23(-12.849,22.222) BB25(-13.486,22.628) BB26(-14.149,22.303) BB27(-14.812,22.628) BB29(-15.841,22.628) BB30(-16.504,22.303) BB31(-17.167,22.628) BB32(-17.83,22.222) BB33(-18.467,22.628) BB34(-19.13,22.303) BB35(-19.793,22.628) BB37(-20.822,22.628) BB38(-21.485,22.303) BB39(-22.148,22.628) BB41(-22.785,22.222) BB42(-23.423,22.628) BB43(-24.086,22.303) BB44(-24.748,22.628) BB46(-25.777,22.628) BB47(-26.44,22.303) BB48(-27.103,22.628) BB50(-28.236,22.628) BB51(-28.899,22.303) BB52(-29.562,22.628) BB54(-30.59,22.628) BB55(-31.253,22.303) BB56(-31.916,22.628) BB57(-32.554,22.222) BB59(-33.191,22.628) BB60(-33.854,22.303) BB61(-34.517,22.628) BB63(-35.546,22.628) BB64(-36.209,22.303) BB65(-36.872,22.628) BB66(-37.535,22.303) BB67(-38.216,22.628)
  oval 0.343x0.254 smd: AA1(-0.325,10.804) AB1(0,11.467) AB2(-0.65,11.467) AB3(-1.3,11.467) AC1(-0.325,12.13) AC2(-0.975,12.13) AD1(0,12.792) AD2(-0.65,12.792) AD3(-1.3,12.792) AF1(-0.325,13.455) AF70(-39.978,13.154) AF71(-40.629,13.154) AG1(0,14.118) AG2(-0.65,14.118) AG3(-1.3,14.118) AG70(-39.653,13.817) AG71(-40.303,13.817) AH1(-0.325,14.781) AH2(-0.975,14.781) AH68(-38.678,14.48) AH69(-39.328,14.48) AH70(-39.978,14.48) AH71(-40.629,14.48) AJ1(0,15.444) AJ2(-0.65,15.444) AJ3(-1.3,15.444) AK70(-40.303,15.143) AL1(-0.325,16.107) AL68(-38.678,15.806) AL69(-39.328,15.806) AL70(-39.978,15.806) AL71(-40.629,15.806) AM1(0,16.77) AM2(-0.65,16.77) AM3(-1.3,16.77) AM70(-39.653,16.469) AM71(-40.303,16.469) AN1(-0.325,17.433) AN2(-0.975,17.433) AN70(-39.978,17.132) AN71(-40.629,17.132) AP1(0,18.096) AP2(-0.65,18.096) AP3(-1.3,18.096) AR70(-39.978,18.16) AR71(-40.629,18.16) AT1(-0.325,18.759) AT70(-39.653,18.823) AT71(-40.303,18.823) AU1(0,19.422) AU2(-0.65,19.422) AU3(-1.3,19.422) AU68(-38.678,19.461) AU69(-39.328,19.486) AU70(-39.978,19.486) AU71(-40.629,19.486) AV1(0,20.142) AV2(-0.95,20.113) AV71(-40.629,20.215) AW2(-0.625,20.677) AW3(-1.275,20.677) E70(-39.978,2.305) E71(-40.629,2.413) F1(-0.325,2.848) F70(-39.526,2.994) F71(-40.176,2.931) G1(0,3.511) G2(-0.65,3.511) G3(-1.3,3.511) G70(-39.978,3.555) G71(-40.629,3.555) H1(-0.325,4.174) H2(-0.975,4.174) H70(-39.653,4.218) H71(-40.303,4.218) J1(0,4.837) J2(-0.65,4.837) J3(-1.3,4.837) J69(-39.328,4.881) J70(-39.978,4.881) J71(-40.629,4.881) K71(-40.303,5.57) L1(-0.325,5.5) M1(0,6.163) M2(-0.65,6.163) M3(-1.3,6.163) N1(-0.325,6.826) N2(-0.975,6.826) P1(0,7.489) P2(-0.65,7.489) P3(-1.3,7.489) T1(-0.325,8.152) U1(0,8.815) U2(-0.65,8.815) U3(-1.3,8.815) V1(-0.325,9.478) V2(-0.975,9.478) W1(0,10.141) W2(-0.65,10.141) W3(-1.3,10.141)
SW_NTC311-EA1T-A160T_4P
  rect 1.651x1.041 smd: 1(0,0) 2(3.85,0)
  rect 1.651x1.041 hole 0.66: 3(-0.1,-1.525) 4(3.95,-1.525)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SW_SSAL120100_3P
  rect 0.787x0.787 smd: 1(0,0) 3(3.4,0)
  rect 1.194x0.787 smd: 2(1.7,0)
  rect 1.041x0.889 smd: 4(-2.375,-1.6) 5(5.775,-1.6)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8210AQVC_QFN19_4X3
  oval 0.787x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 6(0,-2.25) 7(0,-2.7) 8(0,-3.15) 12(2.8,-3.15) 13(2.8,-2.7) 14(2.8,-2.25) 15(2.8,-1.8) 16(2.8,-1.35) 17(2.8,-0.9) 18(2.8,-0.45) 19(2.8,0)
  rect 0.94x2.108 smd: 9(1.07,-0.43)
  rect 0.406x2.108 smd: 10(2,-0.43)
  rect 1.295x2.007 smd: 11(1.25,-2.78)
SY8286BRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8286CRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8286RAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
T-SOL_158-1090902600_18P-T
  round 0.711 hole 0.711 unplated: (-8.92,-13.15)
  round 0.787 hole 0.787 unplated: (2.08,-0.55)
  oval 0.61x1.499 smd: 1(0,0) 2(-0.9,0) 3(-1.8,0) 4(-2.7,0) 5(-3.6,0) 6(-4.5,0) 7(-5.4,0) 8(-6.3,0)
  oval 0.711x1.499 smd: 9(-7.9,0)
  oval 1.092x1.905 hole 0.508x1.194: 10(-9.4,-0.35) 11(4.2,-0.35) 12(4.2,-9.75) 13(-9.4,-9.75)
  oval 1.092x1.194 smd: 14(0.71,-13.15)
  oval 0.61x1.194 smd: 15(-0.54,-13.15) 16(-1.45,-13.15) 17(-2.36,-13.15) 18(-3.27,-13.15) 19(-4.18,-13.15) 20(-5.09,-13.15) 21(-6,-13.15) 22(-6.91,-13.15) 23(-7.82,-13.15)
TAI-T_HCB1005KF-600T25_2P
  rect 0.559x0.559 smd: 1(0,0) 2(0.95,0)
TAI-T_HCB1608KF-121T3_L0603_2P
  rect 0.991x0.787 smd: 1(0,0) 2(1.6,0)
TAI-T_HCB2012KF-121T50_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TCS40DLR_SOT23F3
  oval 0.787x0.889 smd: 1(0,0) 2(0.95,2.1) 3(-0.95,2.1)
TLV62150RGTR_QFN16_3X3-S
  oval 0.254x1.016 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,2.975) 10(1,2.975) 11(0.5,2.975) 12(0,2.975)
  oval 1.016x0.254 smd: 5(2.238,0.738) 6(2.238,1.238) 7(2.238,1.738) 8(2.238,2.238) 13(-0.738,2.238) 14(-0.738,1.738) 15(-0.738,1.238) 16(-0.738,0.738)
  rect 1.702x1.702 smd: 17(0.75,1.488)
TPC12
  round 0.305 smd: 1(0,0)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS62134ARGT_QFN16_3X3-S
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  oval 0.254x0.889 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.702x1.702 smd: 17(1.55,-0.75)
TPS62134BRGT_QFN16_3X3-S
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  oval 0.254x0.889 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.702x1.702 smd: 17(1.55,-0.75)
TPS62134CRGT_QFN16_3X3-S
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  oval 0.254x0.889 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.702x1.702 smd: 17(1.55,-0.75)
TPS65982_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TUSB546_QFN40_4X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 21(6.1,-2.8) 22(6.1,-2.4) 23(6.1,-2) 24(6.1,-1.6) 25(6.1,-1.2) 26(6.1,-0.8) 27(6.1,-0.4) 28(6.1,0)
  oval 0.203x0.889 smd: 9(0.85,-3.45) 10(1.25,-3.45) 11(1.65,-3.45) 12(2.05,-3.45) 13(2.45,-3.45) 14(2.85,-3.45) 15(3.25,-3.45) 16(3.65,-3.45) 17(4.05,-3.45) 18(4.45,-3.45) 19(4.85,-3.45) 20(5.25,-3.45) 29(5.25,0.65) 30(4.85,0.65) 31(4.45,0.65) 32(4.05,0.65) 33(3.65,0.65) 34(3.25,0.65) 35(2.85,0.65) 36(2.45,0.65) 37(2.05,0.65) 38(1.65,0.65) 39(1.25,0.65) 40(0.85,0.65)
  rect 4.699x2.692 smd: 41(3.05,-1.4)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
W25Q64FVZPIG_WSON8_6X5
  oval 0.66x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.9) 6(2.54,5.9) 7(1.27,5.9) 8(0,5.9)
  rect 4.293x3.404 smd: 9(1.905,2.95)
W25Q80DVZPIG_WSON8
  oval 0.66x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.9) 6(2.54,5.9) 7(1.27,5.9) 8(0,5.9)
  rect 4.293x3.404 smd: 9(1.905,2.95)
W25Q256FVEIG_WSON8
  oval 0.66x0.991 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,8) 6(2.54,8) 7(1.27,8) 8(0,8)
  rect 4.293x3.404 smd: 9(1.905,4)
Y_7M25000016_4P
  rect 0.991x0.889 smd: 1(0,0) 2(2.15,0) 3(2.15,1.55) 4(0,1.55)
Y_9H03220008_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X1A000141000200_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
1.2V_DDR_OT: PR600.1 PU600.19
1.2V_DDR_PG: PR601.1 PU600.18
1.8VA_PWROK: PR805.1 PU800.4 RE245.2 RE253.1
1.8VU_PWROK: PR905.1 PU900.4
3.3V_CAM_EN#: QZ1.2 R100.1 UCPU1.AT15
3.3V_TS_EN: R76.1 UCPU1.AP5 UZ1.4
3V_FB: PC511.1 PU500.13
3V_SN: PC510.1 PR501.2
5V_FB: PC525.1 PU501.13
5V_SN: PC524.1 PR507.2
+0.6VS: CD100.1 CD101.1 CD102.1 CD103.1 CD104.1 CD105.1 CD106.1 CD107.1 CD108.1 CD109.1 PJP601.2 RD21.2 RD22.2 RD23.2 RD24.2 RD25.2 RD26.2 RD27.2 RD28.2 RD29.2 RD30.2 RD31.2 RD32.2 RD33.2 RD34.2 RD35.2 RD36.2 RD37.2 RD38.2 RD39.2 RD40.2 RD41.2 RD42.2 RD43.2 RD44.2 RD45.2 RD46.2 RD47.2 RD48.2 RD49.2 RD50.2 RD51.2 RD52.2 RD53.2 RD54.2 RD55.2 RD56.2 RD57.2 RD58.2 RD59.2 RD60.2 RD61.2 RD62.2 RD63.2 RD64.2 RD65.2 RD66.2 RD67.2 RD68.2 RD69.2 RD70.2 RD71.2 RD72.2 RD73.2 RD74.2 RD75.2 RD76.2 RD77.2 RD78.2 RD79.2 RD80.2 RD81.2 RD82.2
+0.6VSP: PC615.1 PC616.1 PJP601.1 PU600.5 PU600.6
+1.0V_AMPHYPLL: CC80.1 RC173.2 UCPU1.K15 UCPU1.L15
+1.0V_APLL: R4.1 RC177.2 UCPU1.V15
+1.0V_APLLEBB: CC79.1 RC172.2 UCPU1.N18
+1.0V_CLK: CC83.1 RC64.2 RC175.2 UCPU1.A10 UCPU1.A14 UCPU1.K19 UCPU1.L19 UCPU1.L21 UCPU1.N20
+1.0V_DTS: RC169.2 UCPU1.T1
+1.0V_MPHYAON: CC64.1 RC168.2 UCPU1.K17 UCPU1.L1
+1.0V_MPHYGT: CC70.1 CC71.1 CZ8.1 R104.2 RC171.1 RC172.1 RC173.1 UCPU1.N15 UCPU1.N16 UCPU1.N17 UCPU1.P15 UCPU1.P16
+1.0V_PRIM_CORE: CC63.1 CC66.1 PJP1401.2 UCPU1.AF18 UCPU1.AF19 UCPU1.V20 UCPU1.V21
+1.0V_PRIM_COREP: PC1406.1 PC1415.1 PC1416.1 PJP1401.1 PL1403.2 PR1421.2 PU1401.1
+1.0V_SRAM: CC78.1 RC171.2 UCPU1.AF20 UCPU1.AF21 UCPU1.T19 UCPU1.T20
+1.0V_VCCST: CC28.1 CC31.1 CC96.1 CC97.1 CZ1.1 PC1001.1 PR1003.1 PR1004.1 R101.2 RC79.1 RC126.2 RC154.1 RC156.1 RC158.1 RC218.1 RC219.1 RE147.1 RE222.1 UCPU1.A18 UCPU1.K20 UCPU1.K21
+1.0V_VCCSTG: CC29.1 CZ5.1 PR1525.1 R102.2 RC153.2 RC221.1 RC230.2 RC239.2 RC240.2 RC242.1 RC252.2 RC254.2 RC255.1 UCPU1.A22
+1.0V_VCCSTG_R: RC153.1 UCPU1.G20
+1.0VA: CC62.1 CC67.1 CE96.1 CZ2.1 CZ3.1 CZ9.1 PJP700.2 R104.1 RC168.1 RC169.1 RC175.1 RC177.1 RC251.1 UCPU1.AB17 UCPU1.AB19 UCPU1.AB20 UCPU1.AK20 UCPU1.P18 UCPU1.Y18 UZ3.1 UZ3.2 UZ3.7 UZ4.1 UZ4.2 UZ4.7
+1.0VA_XDP: CC85.1 CC86.1 JXDP1.43 JXDP1.44 RC125.2 RC226.1 RC251.2
+1.0VAP: PC706.1 PC707.1 PC708.1 PC709.1 PC710.1 PJP700.1 PL701.2 PR702.1
+1.0VS_VCCIO: CC39.1 CC40.1 CC41.1 CC42.1 CC51.1 CC52.1 CC53.1 CC54.1 CC55.1 CC56.1 PJP1400.2 QE13.1 RC8.1 RC163.1 UCPU1.AK28 UCPU1.AK30 UCPU1.AL30 UCPU1.AL42 UCPU1.AM28 UCPU1.AM30 UCPU1.AM42
+1.0VS_VCCIOP: PC1403.1 PC1404.1 PC1405.1 PJP1400.1 PL1401.2 PR1408.1 PU1400.1
