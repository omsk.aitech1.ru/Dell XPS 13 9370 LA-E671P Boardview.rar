# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_TXP_P3_C: length 0.6
  BOTTOM w0.102: R255.1 C1059.2
EDP_TXP_P3_CONN: length 4.4
  BOTTOM w0.102: R255.2 35.33,58.12 35.33,59.33 34.99,59.67 34.99,59.94 v10(34.8,60.13) 34.44,60.49 34.44,60.98 34.58,61.12 JEDP1.34
EDRAM_OPIO_RCOMP: length 2.3
  TOP w0.305: v2(99.58,62.17) 99.31,62.17 v8(99.08,61.94) 99.08,61.94 RC108.1
  BOTTOM w0.254: v8(99.08,61.94) 99.41,61.61 UCPU1.H66
EMMC_RCOMP: length 4.1
  BOTTOM w0.089: RC10.1 140.31,47.49 137.26,47.49 UCPU1.AT1
EN_0.6V: length 7.3
  BOTTOM w0.254: PR611.2 117.02,11.37 116.44,10.78 PC618.1 ; PU600.2 117.02,8.06 116.6,8.48 116.01,8.48 115.82,8.68 115.82,10.45 PC618.1 ; PC618.1 115.28,10.78 PR610.1 114.43,10.8 PR609.2
EN_1.0V: length 4.5
  BOTTOM w0.254: PR703.2 130.86,8.39 PC712.1 PR704.1 132.27,8.37 132.7,7.94 133.65,7.94 133.9,7.69 PU700.11
EN_1.0V_PRIM_COREP: length 4.8
  BOTTOM w0.254: PR1513.1 66.12,36.78 PC1512.1 67.01,36.82 67.83,36.82 PR1512.2 67.86,36.8 68.41,36.25 69.09,36.25 69.57,35.77 PU1501.13
EN_1.2V: length 6.1
  BOTTOM w0.095: PR607.2 112.46,8 v2(112.46,7.45)
  BOTTOM w0.254: PU600.1 116.57,7.94 116.43,8.08 115.76,8.08 115.25,8.59 PC617.1 PR608.1 114.33,9.01 113.99,9.01 113.98,9.02 PR607.2
EN_1.8VA: length 4.3
  BOTTOM w0.095: 162.13,59.14 PC800.1
  BOTTOM w0.254: PU800.13 160.47,60.25 161.03,59.69 161.64,59.69 162.13,59.2 162.13,59.14 162.16,59.12 PR800.2 163,59.99 PR801.2
EN_1.8VU: length 8.9
  BOTTOM w0.095: PC900.1 v2(150.88,2.6)
  BOTTOM w0.254: PU900.13 155.06,5.19 154.66,4.78 154.66,4.1 154.4,3.84 152.62,3.84 152.23,3.45 PR900.2 ; PR900.2 151.83,3.45 151.49,3.79 151.49,4.72 151.98,5.21 PR901.2 ; PR900.2 152.05,3.42 PC900.1
EN_INVPWR: length 286.3
  TOP w0.095: v7(32.39,13.01) 32.13,12.75 32.13,11.32 31.01,10.2 29.56,10.2 RE161.1 28.83,9.47 26.61,9.47 26.01,10.07 25.47,10.07 25.07,10.46 24.26,10.46 UE3.B2 ; v7(113.47,13.28) v2(114.37,13.28) 116.24,13.28 116.34,13.18 120.88,13.18 122.53,14.82 130.26,14.82 130.66,14.42 137.88,14.42 138.7,15.25 147.11,15.25 147.26,15.41 v7(147.26,16.23)
  IN1 w0.076: v7(282.66,15.03) 281.05,16.64 v9(280.44,16.64) ; v7(113.47,13.28) 112.98,13.77 106.36,13.77 105.44,14.7 104.18,14.7 103.56,14.08 102.14,14.08 99.78,11.72 91.92,11.72 91.43,11.23 79.92,11.23 75.54,6.85 71.49,6.85 71.28,7.06 66.61,7.06 66.13,7.54 61.38,7.54 60.85,8.07 52.81,8.07 48.41,12.48 37.55,12.48 36.42,13.6 34.85,13.6 34.25,13.01 v7(32.39,13.01) ; v7(147.26,16.23) 147.39,16.11 152.65,16.11 154.54,18 158.25,18 158.73,17.53 160.99,17.53 161.21,17.75 168.31,17.75 168.94,17.12 173.24,17.12 173.53,17.4 176.64,17.4 180.84,13.2 181.23,13.2 183.2,11.23 184.73,11.23 186.64,9.33 206.53,9.33 211.58,14.38 224.23,14.38 225.95,12.66 227.55,12.66 231.1,9.11 249.38,9.11 251.37,11.09 253.91,11.09 254.97,12.15 v9(255.62,12.15)
  GND1 w0.095: v9(255.62,12.15) 255.74,12.15 255.99,11.9 v3(256.04,11.9) ; v9(280.44,16.64) v3(280.08,16.64)
  GND3 w0.095: v6(280.62,16.51) 280.21,16.51 v3(280.08,16.64) ; v3(256.04,11.9) v6(256.29,12.15)
  IN4 w0.076: v6(280.62,16.51) 279.65,16.51 279.39,16.77 277.76,16.77 277.16,17.36 276.39,17.36 273.37,14.34 267.78,14.34 266.87,15.25 264.64,15.25 261.85,12.47 256.61,12.47 v6(256.29,12.15)
EN_PD_HV1: length 31.2
  TOP w0.095: R173.2 23.06,36.24 v1(22.99,36.32)
  GND1 w0.095: v3(22.79,35.87) 22.79,36.12 v1(22.99,36.32) ; v1(31.66,18.07) 31.66,18.02 v3(32.03,17.65)
  GND3 w0.095: v3(22.79,35.87) 22.79,36.15 v6(23.07,36.43) ; v3(32.03,17.65) v6(31.62,17.65)
  IN4 w0.076: v6(23.07,36.43) 23.32,36.18 25.25,36.18 26.14,35.3 27.32,35.3 27.63,34.99 27.63,33.49 29.35,31.77 29.35,30.6 29.53,30.42 30.25,30.42 30.44,30.61 32.16,30.61 32.79,29.98 32.79,28.44 31.78,27.43 31.78,26.46 31.4,26.08 31.4,25.11 31.88,24.63 31.88,24.14 30.86,23.13 30.86,21.72 30.05,20.91 30.05,19.6 31.62,18.02 v6(31.62,17.65)
EN_PD_HV2: length 32.3
  TOP w0.095: R201.2 35.84,38.02 37.09,38.02 v2(37.52,37.59) 37.68,37.43 37.68,32.74 37.5,32.56 37.5,27.07 37.31,26.88 37.31,24.82 36.88,24.39 v7(36.88,24.03)
  IN1 w0.076: v7(36.88,24.03) 36.88,21.8 38.71,19.97 38.71,19.34 39.33,18.72 48.93,18.72 v7(49.22,18.43)
EN_PD_HV3: length 74.8
  IN4 w0.076: v5(219.52,4.35) 219.54,4.33 v5(234.19,4.33) 267.19,4.33 267.56,4.7 271.33,4.7 272.94,6.31 274.42,6.31 274.53,6.41 277.07,6.41 277.73,5.75 279.55,5.75 281.64,7.83 281.64,10.78 280.19,12.22 280.19,13.16 279.33,14.03 v5(279.25,14.03)
  BOTTOM w0.095: PR259.1 217.57,2.89 219.03,4.35 v5(219.52,4.35)
EN_PRIM_CORE: length 6.2
  IN4 w0.203: v5(159.07,68.84) 159.32,68.59 159.32,68.44 160.53,67.24 160.53,67.2 v5(160.78,66.95)
  BOTTOM w0.095: PR1412.2 v2(163.55,66.95)
  BOTTOM w0.203: PU1401.13 158.82,69.09 v5(159.07,68.84) ; v5(160.78,66.95) PR1413.1 PR1412.2
EN_VCC_EDRAM: length 4.2
  BOTTOM w0.254: PU1500.13 58.85,35.57 58.46,35.96 57.86,35.96 57.57,36.26 PR1501.2 57.11,36.63 57.06,36.58 PC1500.1 56.66,36.58 PR1502.1
EN_VCCIO: length 5.7
  BOTTOM w0.095: PR1401.2 164.06,50.04 164.72,49.37 165.11,49.37 v2(165.42,49.07)
  BOTTOM w0.254: PR1401.2 164.06,50.12 PR1402.1 164.03,51.05 PC1400.1 164.03,52.18 163.5,52.7 PU1400.13
ENLDO_3V5V: length 16.5
  IN4 w0.076: v5(48.64,25.52) 48.6,25.49 46.53,25.49 46.01,24.98 45.22,24.98 44.33,24.09 43.6,24.09 43.1,23.59 39.89,23.59 38.83,24.65 38.46,24.65 v5(38.39,24.58)
  BOTTOM w0.095: v2(35.04,23.41) 35.54,23.91 PR509.1
  BOTTOM w0.127: PU500.11 48.91,25.88 48.68,25.65 48.68,25.57 v5(48.64,25.52)
  BOTTOM w0.254: v5(38.39,24.58) PU501.11 38.13,24.47 38.13,24.13 37.88,23.88 37.08,23.88 PR508.2 36.18,24.09 PR509.1
ENVDD: length 8.3
  BOTTOM w0.508: D13.1 38.71,52.4 39.85,53.55 41.11,53.55 41.8,54.24 R99.2 42.84,53.55 v2(43.33,53.06) 43.79,52.6 UZ2.4
ENVDD_PCH: length 252.2
  TOP w0.095: UE3.L12 15.9,18.23 15.51,18.62 15.51,21.19 v7(15.41,21.29)
  IN1 w0.076: v7(15.41,21.29) 15.53,21.29 15.66,21.17 15.91,21.17 16.17,21.42 16.17,22.05 17.06,22.94 18.07,22.94 18.45,23.32 19.5,23.32 20.66,24.48 22.09,24.48 22.21,24.6 23.33,24.6 23.68,24.96 28.64,24.96 28.84,24.76 29.36,24.76 30.48,23.64 34.62,23.64 36.17,22.08 v9(36.57,22.08) ; v9(37.64,38.65) 37.64,38.92 36.16,40.39 36.16,42.81 34.76,44.21 33.49,44.21 33,44.7 33,45.74 33.17,45.9 34.17,45.9 34.86,46.6 34.86,49.16 34.51,49.51 34.51,52.72 34.87,53.09 36.2,53.09 v9(36.41,53.29)
  GND1 w0.095: v3(37.6,38.98) 37.64,38.94 v9(37.64,38.65) ; v3(36.55,53.6) 36.55,53.44 v9(36.41,53.29) ; v9(36.57,22.08) 36.77,22.08 v3(36.95,21.9)
  GND3 w0.095: v6(37.11,21.46) 36.95,21.63 v3(36.95,21.9) ; v3(37.6,38.98) 37.62,38.98 v6(37.86,38.74) ; v4(36.81,52.93) 36.81,53.34 v3(36.55,53.6)
  IN4 w0.076: v8(130.68,57.72) 130.73,57.72 132.31,56.14 132.69,56.14 132.84,55.99 132.84,55.46 133.12,55.17 136.03,55.17 136.17,55.03 138.88,55.03 139.3,55.46 140.31,55.46 141.54,54.23 142.79,54.23 143.15,53.87 143.15,52.64 149.1,46.69 149.1,38.8 148.5,38.2 148.5,35.22 148.25,34.97 148.25,34.04 148.76,33.52 148.76,31.03 150.48,29.32 150.48,18.15 148.89,16.56 147.64,16.56 147.45,16.75 144.9,16.75 144.49,16.34 138.39,16.34 137.86,15.8 131.66,15.8 131.52,15.95 123.64,15.95 123.51,15.82 121.48,15.82 121.39,15.91 113.78,15.91 112.94,15.07 83.05,15.07 81.91,13.93 80.67,13.93 79.26,12.52 78.32,12.52 77.4,11.59 74.31,11.59 72.63,9.91 70.8,9.91 70.29,9.4 67.84,9.4 67.15,10.09 61.73,10.09 61.03,10.78 52.23,10.78 50.81,12.21 48.76,12.21 47.57,13.4 39.46,13.4 37.05,15.81 37.05,20.01 37.11,20.08 v6(37.11,21.46) 37.22,21.56 37.22,23.48 36.7,23.99 36.7,25.07 38.72,27.09 38.72,31.28 38.14,31.86 38.14,38.45 37.86,38.73 v6(37.86,38.74)
  BOTTOM w0.095: v2(35.16,53.42) 36.32,53.42 v4(36.81,52.93)
  BOTTOM w0.112: v8(130.68,57.72) 130.28,57.32 UCPU1.U13
EOPIO_RCOMP: length 2.4
  TOP w0.102: v8(100.54,61.93) 100.54,61.68 100.97,61.25 101.08,61.25 v2(101.12,61.21)
  TOP w0.305: RC109.1 100.18,61.57 v8(100.54,61.93)
  BOTTOM w0.254: v8(100.54,61.93) 100.54,61.87 100.79,61.61 UCPU1.H65
ESPI_ALERT#: length 184.4
  TOP w0.095: UE3.H7 19.9,15.56 v8(19.57,15.23)
  IN2 w0.064: v3(40.91,11.01) 40.44,10.53 34.07,10.53 30.29,14.32 30.29,15.09 29.93,15.44 29.18,15.44 28.92,15.7 27.49,15.7 26.7,14.91 25.37,14.91 25.2,15.08 25.2,15.08 24.98,15.3 24.98,15.3 24.36,15.92 24.19,15.92 23.69,16.42 20.95,16.42 20.71,16.18 20.71,15.88 20.47,15.65 19.98,15.65 v8(19.57,15.23)
  IN3 w0.064: v3(134.38,40.74) 135.55,39.57 138.47,39.57 141.95,36.09 142.1,36.09 144.47,33.72 145.12,33.72 146.52,32.32 147.57,32.32 150.4,29.5 150.4,23.38 149.24,22.23 149.24,16.15 148.47,15.37 144.43,15.37 144.09,15.03 116.93,15.03 116.2,14.29 111.15,14.29 108.94,12.08 100.59,12.08 97.74,14.93 88.32,14.93 88.02,15.24 84.32,15.24 80.66,11.58 78.16,11.58 75.39,8.81 60.6,8.81 59.72,9.69 47.84,9.69 47.31,10.23 42.7,10.23 42.51,10.04 42.21,10.04 41.8,10.44 41.47,10.44 v3(40.91,11.01)
  GND3 w0.095: v4(134.07,40.86) 134.07,40.85 134.09,40.84 134.09,40.83 134.18,40.74 v3(134.38,40.74)
  BOTTOM w0.076: 131.67,43.09 131.3,43.09 130.99,43.39 130.99,44.31 131.38,44.7 UCPU1.AY11
  BOTTOM w0.095: 131.67,43.09 132.34,42.42 133.93,42.42 134.29,42.06 134.29,41.07 v4(134.07,40.86) 133.88,40.86 v2(133.7,40.68) 133.64,40.62 RC24.2
ESPI_CLK_5105: length 192
  TOP w0.095: RE172.1 29.71,13.7 28.74,13.7 28.54,13.91 v1(28.54,14.22) ; UE3.G7 20.26,14.46 v8(20.26,14.41)
  GND1 w0.095: v1(28.54,14.22) 28.57,14.19 28.57,14.02 28.47,13.93 v3(28.36,13.93)
  IN2 w0.064: v3(137.27,38.37) 137.57,38.07 139.53,38.07 142.4,35.21 142.4,34.23 146.18,30.44 147.89,30.44 150.14,28.19 150.14,26.14 151.58,24.7 151.58,18.2 152.22,17.55 152.22,16.38 150.66,14.82 136.32,14.82 135.89,14.39 111.8,14.39 v3(111.27,13.86) ; v3(50.9,8.81) 49.86,7.77 34.82,7.77 32.85,9.74 30.49,9.74 29.2,11.03 29.2,12.45 28.36,13.29 v3(28.36,13.93) 25.42,13.93 24.65,14.69 24.25,14.69 23.67,14.12 20.55,14.12 v8(20.26,14.41)
  IN3 w0.064: v3(111.27,13.86) 111.08,13.86 107.97,10.75 78.5,10.75 75.73,7.98 59.21,7.98 58.55,8.65 51.06,8.65 v3(50.9,8.81) ; v8(20.26,14.41) 19.9,14.05 19.9,13.41 19.71,13.21 19.27,13.21 19.13,13.08 19.13,11.01 18.67,10.55 16.89,10.55 16.58,10.86 15.62,10.86 14.91,11.56 12.85,11.56 12.33,11.04 10.74,11.04 v8(10.31,10.61)
  GND3 w0.095: v3(137.27,38.37) 137.27,38.8 v4(137.25,38.82)
  BOTTOM w0.095: v4(137.25,38.82) 137.25,38.84 CC2.2 136.36,40.55 RC19.2 ; JESPI1.10 10.21,10.12 10.09,10.23 10.09,10.39 v8(10.31,10.61)
ESPI_CS#: length 195.1
  TOP w0.095: v8(20.31,15.23) 20.69,15.62 UE3.H6
  IN2 w0.064: v8(9.86,8.61) 10.22,8.61 12.59,10.97 12.59,12.83 13.06,13.3 13.22,13.3 13.83,13.3 15.37,14.84 19.92,14.84 v8(20.31,15.23) 20.56,15.23 20.96,15.63 22.15,15.63 22.29,15.77 22.77,15.77 22.91,15.63 24.36,15.63 25.27,14.72 26.93,14.72 27.72,15.5 28.71,15.5 30.22,13.99 30.35,13.99 33.99,10.34 40.93,10.34 v3(41.54,10.95)
  IN3 w0.064: v3(133.85,41.26) 133.85,41.17 133.98,41.04 133.98,40.34 134.94,39.38 138.39,39.38 141.87,35.9 142.02,35.9 144.39,33.52 145.04,33.52 146.48,32.08 147.54,32.08 150.21,29.42 150.21,23.46 149.05,22.3 149.05,16.52 148.1,15.56 144.35,15.56 144.01,15.22 116.85,15.22 116.12,14.48 111.07,14.48 108.86,12.27 100.67,12.27 97.82,15.12 88.4,15.12 88.09,15.43 84.15,15.43 80.5,11.78 78.09,11.78 76.51,10.2 75.43,10.2 74.23,9.01 60.68,9.01 59.81,9.89 47.93,9.89 47.37,10.45 42.82,10.45 42.49,10.77 41.72,10.77 v3(41.54,10.95)
  GND3 w0.095: v4(133.9,41.61) 133.9,41.46 133.85,41.41 v3(133.85,41.26)
  BOTTOM w0.076: v4(133.9,41.61) 133.9,42 133.66,42.25 132.25,42.25 131.58,42.92 131.23,42.92 130.83,43.33 130.83,44.55 UCPU1.BA12
  BOTTOM w0.095: v8(9.86,8.61) 9.89,8.61 9.89,8.62 JESPI1.7
ESPI_IO0: length 207.1
  TOP w0.095: v8(21.91,17.63) 21.91,17.62 UE3.K5 ; v1(141.63,34.84) 141.33,34.84 139.84,33.34 137.02,33.34 136.67,33 130.07,33 128.54,34.53 v2(128.54,36.2) 128.54,40.39 RC366.2
  GND1 w0.095: v3(142,34.82) 141.65,34.82 v1(141.63,34.84)
  IN2 w0.064: v8(9.85,6.25) 9.52,6.58 9.52,7.83 9.52,7.84 9.52,8.39 9.43,8.48 9.43,9.11 9.14,9.4 9.14,10.97 9.45,11.27 10.67,11.27 11.57,12.18 11.57,12.75 12.78,13.95 13.69,13.95 15.78,16.04 17.03,16.04 17.4,16.42 20.56,16.42 20.7,16.57 20.7,17.05 20.88,17.23 21.5,17.23 v8(21.91,17.63) 21.54,18 21.54,18.81 22.1,19.37 23.07,19.37 23.62,18.82 26.49,18.82 27.32,17.99 28.71,17.99 29.15,18.43 30.1,18.43 31.94,16.59 31.94,14.06 34.56,11.43 38.16,11.43 v3(38.42,11.69)
  IN3 w0.064: v3(142,34.82) 143.91,32.9 144.83,32.9 146.29,31.44 147.38,31.44 149.63,29.18 149.63,23.74 148.48,22.59 148.48,16.87 147.74,16.14 144.12,16.14 143.77,15.79 116.62,15.79 115.88,15.06 110.84,15.06 108.62,12.85 101.89,12.85 99.02,15.72 88.99,15.72 88.43,16.28 83.84,16.28 80.86,13.29 76.83,13.29 73.92,10.39 72.86,10.39 72.26,9.79 61,9.79 60.12,10.67 48.85,10.67 47.4,12.13 38.85,12.13 v3(38.42,11.69)
  BOTTOM w0.095: JESPI1.3 10.24,6.62 9.91,6.28 9.89,6.28 v8(9.85,6.25)
ESPI_IO0_R: length 5.4
  TOP w0.095: v8(130.18,42.7) 128.71,42.7 v2(128.39,42.37) 128.39,41.46 RC366.1
  BOTTOM w0.076: v8(130.18,42.7) 129.97,42.91 129.97,43.67 129.99,43.69 130.02,43.77 130.02,44.01 129.99,44.15 129.99,44.39 130.24,44.65 UCPU1.AY13
ESPI_IO1: length 194.7
  TOP w0.095: v8(22.7,18.4) 22.32,18.02 UE3.L4
  GND1 w0.095: v1(139.71,42.51) 139.71,42.21 v3(139.77,42.15)
  IN2 w0.064: v3(38.98,11.61) 38.61,11.24 34.49,11.24 31.74,13.99 31.74,16.53 30.09,18.17 29.17,18.17 28.79,17.79 27.22,17.79 26.39,18.62 23.03,18.62 22.79,18.39 22.71,18.39 v8(22.7,18.4)
  IN3 w0.064: v3(139.77,42.15) 140.16,41.75 140.16,39.7 141.66,38.21 141.66,37.22 142.85,36.02 143.5,36.02 145.23,34.3 146.6,32.92 147.85,32.92 149.23,31.54 150.05,31.54 151.15,30.44 151.15,29.39 150.98,29.21 150.98,23.15 149.84,22.01 149.84,15.91 148.7,14.78 144.67,14.78 144.34,14.45 116.9,14.45 115.94,13.5 111.79,13.5 111.05,12.75 110.51,12.75 108.13,10.37 78.71,10.37 75.94,7.6 59,7.6 58.39,8.22 48.64,8.22 47.06,9.79 43.17,9.79 42.84,9.46 41.97,9.46 41.63,9.81 40.03,9.81 38.98,10.86 v3(38.98,11.61) ; v8(9.9,6.89) 9.91,6.89 12.33,9.31 13.48,9.31 13.84,9.67 20.16,9.67 20.97,10.48 20.97,12.01 21.48,12.52 21.48,13.99 21.38,14.08 21.38,14.9 22.42,15.94 22.42,16.51 23.15,17.24 23.15,17.99 22.77,18.38 22.72,18.38 v8(22.7,18.4)
  BOTTOM w0.095: JESPI1.4 10.13,7.12 v8(9.9,6.89)
ESPI_IO1_R: length 13
  TOP w0.095: v2(138.84,44.27) 138.84,43.94 v1(138.99,43.79) 139.34,43.79 RC367.1
  GND1 w0.095: v1(138.99,43.79) 138.99,43.85 v3(138.76,44.07)
  IN3 w0.064: v3(132.12,42.39) 132.31,42.21 133.35,42.21 133.75,42.6 135.21,42.6 135.87,41.94 136.67,41.94 138.76,44.04 v3(138.76,44.07)
  GND3 w0.095: v4(131.48,42.36) 132.09,42.36 v3(132.12,42.39)
  BOTTOM w0.076: UCPU1.BA13 130.5,43.99 130.5,43.18 131.31,42.36 v4(131.48,42.36)
ESPI_IO2: length 199.6
  TOP w0.095: v8(21.11,15.23) 20.7,14.83 UE3.G6 ; v1(141.31,35.33) 141.31,35.13 139.75,33.56 136.93,33.56 136.58,33.22 130.17,33.22 129,34.39 v2(129,39) 129,40.11 RC368.2
  GND1 w0.095: v1(141.31,35.33) v3(141.66,35.33)
  IN2 w0.064: v3(42.27,11.34) 42.27,10.99 41.43,10.15 33.91,10.15 30.34,13.72 30.14,13.72 29.13,14.73 29.13,14.81 28.86,15.08 28.62,15.08 28.02,14.48 25.14,14.48 24.61,15 22.79,15 22.71,14.92 21.43,14.92 v8(21.11,15.23)
  IN3 w0.064: v8(21.11,15.23) 20.7,14.82 20.7,11.31 20.25,10.86 19.4,10.86 18.47,9.92 13.71,9.92 13.28,9.5 12.25,9.5 10.24,7.48 v8(9.91,7.48) ; v3(141.66,35.33) 142.05,35.33 144.23,33.14 144.89,33.14 146.36,31.67 147.41,31.67 149.82,29.26 149.82,23.66 148.67,22.51 148.67,16.75 147.87,15.95 144.2,15.95 143.85,15.6 116.7,15.6 115.96,14.87 110.91,14.87 108.7,12.65 101.81,12.65 98.94,15.53 88.79,15.53 88.28,16.03 84.02,16.03 80.2,12.21 76.78,12.21 73.97,9.41 60.84,9.41 59.96,10.29 48.15,10.29 47.59,10.85 43.31,10.85 42.81,11.34 v3(42.27,11.34)
  BOTTOM w0.095: v8(9.91,7.48) 10.05,7.62 JESPI1.5
ESPI_IO2_R: length 3.5
  TOP w0.095: RC368.1 129.35,41.98 v2(129.67,42.29) v8(130.61,42.29)
  BOTTOM w0.112: UCPU1.BB13 130.24,43.17 130.68,42.73 130.68,42.37 v8(130.61,42.29)
ESPI_IO3: length 195.9
  TOP w0.095: UE3.L5 21.12,18.4 v8(21.12,18.45)
  GND1 w0.095: v1(138.83,42.37) 139.08,42.11 v3(139.19,42.11)
  IN2 w0.064: v8(9.02,8) 9.14,8.11 9.14,9.02 8.94,9.22 8.94,12.18 9.73,12.98 11.13,12.98 12.97,14.81 13.18,14.81 15.98,17.61 17.96,17.61 18.39,18.04 18.87,18.04 19.59,18.76 20.8,18.76 v8(21.12,18.45) 21.12,18.93 21.75,19.56 23.51,19.56 24.05,19.01 26.64,19.01 27.46,18.19 28.59,18.19 29.04,18.64 30.17,18.64 32.15,16.66 32.15,14.12 34.42,11.85 37.87,11.85 38.07,12.05 39.12,12.05 v3(39.54,11.64)
  IN3 w0.064: v3(39.54,11.64) 39.38,11.48 39.38,10.73 40.11,10 41.71,10 42.05,9.66 42.66,9.66 42.99,9.98 47.22,9.98 48.78,8.42 58.46,8.42 59.09,7.79 75.84,7.79 78.61,10.56 108.05,10.56 110.43,12.94 110.97,12.94 111.71,13.69 115.86,13.69 116.82,14.64 144.27,14.64 144.59,14.97 148.62,14.97 149.63,15.97 149.63,22.07 150.79,23.23 150.79,29.37 150.96,29.55 150.96,30.32 150.02,31.27 149.16,31.27 147.88,32.55 147.71,32.72 146.53,32.72 143.42,35.83 142.78,35.83 141.47,37.14 141.47,38.13 139.97,39.62 139.97,41.33 v3(139.19,42.11)
  BOTTOM w0.095: v8(9.02,8) 9.14,8.12 JESPI1.6
ESPI_IO3_R: length 14.2
  TOP w0.095: v2(137.53,44.03) 138.28,43.29 RC369.1 138.95,43.41 v1(138.98,43.41)
  GND1 w0.095: v3(138.72,43.18) 138.95,43.41 v1(138.98,43.41)
  IN3 w0.064: v3(138.72,43.18) 138.72,42.67 137.78,41.73 135.79,41.73 135.31,42.21 133.89,42.21 v3(133.83,42.16)
  GND3 w0.095: v4(133.59,41.9) 133.59,41.91 v3(133.83,42.16)
  BOTTOM w0.076: UCPU1.AY12 130.81,45 130.47,44.66 130.47,44.47 130.66,44.28 130.66,43.24 131.15,42.76 131.51,42.76 132.25,42.02 133.47,42.02 v4(133.59,41.9)
ESPI_RESET#: length 149.5
  TOP w0.095: UE3.K6 20.73,17.22 v8(21.11,16.83)
  IN2 w0.064: v3(39.75,10.9) 39.59,10.74 34.18,10.74 30.55,14.37 30.55,15.12 30.01,15.66 29.36,15.66 29.09,15.93 25.14,15.93 24.96,16.11 24.36,16.11 23.64,16.83 v8(21.11,16.83)
  IN3 w0.064: v3(77.03,12.88) 74.34,10.2 72.94,10.2 72.34,9.6 60.92,9.6 60.04,10.48 48.57,10.48 47.25,11.81 40.48,11.81 39.75,11.07 v3(39.75,10.9)
  GND3 w0.095: v3(77.03,12.88) v6(77.36,13.21)
  IN4 w0.076: v6(77.36,13.21) 77.8,13.66 78.68,13.66 82.04,17.02 82.04,23.46 82.36,23.78 82.36,28.45 84.45,30.54 131.51,30.54 134.73,33.76 134.73,37.62 134.88,37.77 134.88,38.68 134.53,39.03 134.53,39.03 134.53,39.83 134.77,40.07 134.78,40.07 135.42,40.71 135.42,41.42 v4(135.34,41.5)
  BOTTOM w0.076: UCPU1.BA11 131.25,44.24 131.16,44.15 131.16,43.47 131.37,43.26 131.78,43.26 132.43,42.6 133.99,42.6 134.78,41.81 135.03,41.81 v4(135.34,41.5)
FAN1_PWM: length 271.5
  TOP w0.095: v7(145.4,14.5) 145.32,14.58 139,14.58 138.17,13.76 130.38,13.76 130,14.14 122.79,14.14 121.16,12.51 116.83,12.51 115.28,10.96 113.55,10.96 v2(113.32,11.19) 112.64,11.87 v7(112.64,13.28) ; UE3.L10 v7(17.5,18.37)
  IN1 w0.076: v7(145.4,14.5) 145.61,14.29 146.91,14.29 147.31,14.69 153.29,14.69 153.68,15.08 156.6,15.08 156.99,15.47 163.39,15.47 163.73,15.8 177.03,15.8 179.2,13.64 179.2,13.28 179.92,12.56 181.29,12.56 183.03,10.83 184.57,10.83 186.47,8.92 206.7,8.92 211.75,13.97 224.06,13.97 225.79,12.25 227.38,12.25 230.92,8.7 249.55,8.7 250.63,9.78 253.18,9.78 253.89,10.5 254.43,10.5 255.22,11.28 v9(255.22,11.64) ; v7(17.5,18.37) 18.12,18.99 22.89,18.99 22.94,18.94 26.41,18.94 28.25,17.1 28.64,17.1 29,16.74 30.16,16.74 30.68,16.22 30.68,14.9 31.6,13.99 31.6,12.8 32.18,12.22 34.99,12.22 35.55,11.66 48.06,11.66 52.5,7.23 60.38,7.23 60.97,6.65 65.87,6.65 66.27,6.25 70.4,6.25 70.9,5.75 72.75,5.75 73.03,6.03 75.88,6.03 80.26,10.41 103.95,10.41 105.85,12.31 108.44,12.31 109.4,13.28 v7(112.64,13.28)
  GND1 w0.095: v3(255.63,11.55) 255.53,11.64 v9(255.22,11.64)
  GND3 w0.095: v3(255.63,11.55) 255.68,11.55 255.8,11.43 v4(255.95,11.43)
  BOTTOM w0.095: JFAN1.3 259.15,6.25 258.46,6.95 258.46,9.26 256.28,11.43 v4(255.95,11.43) 255.08,12.31 R36.1
FAN1_TACH: length 256.1
  TOP w0.095: UE3.E3 22.74,13.58 22.74,15.16 22.83,15.25 23.47,15.25 v7(23.54,15.32) ; v7(113.32,12.27) 113.69,11.91 v2(114.64,11.91) 115.91,11.91 116.74,12.73 121.07,12.73 122.7,14.36 130.09,14.36 130.47,13.98 138.08,13.98 138.9,14.8 145.61,14.8 v7(145.82,14.59)
  IN1 w0.076: v7(145.82,14.59) 145.98,14.59 146.04,14.53 146.83,14.53 147.19,14.89 153.2,14.89 153.6,15.28 156.52,15.28 156.9,15.67 163.27,15.67 163.6,16.01 177.12,16.01 179.4,13.72 179.4,13.37 179.97,12.8 181.34,12.8 183.11,11.03 184.65,11.03 186.56,9.12 206.61,9.12 211.67,14.18 224.14,14.18 225.87,12.45 227.46,12.45 231.01,8.9 249.47,8.9 251.45,10.89 254.12,10.89 v9(254.8,11.56) ; v7(23.54,15.32) 24.26,15.32 24.99,14.59 26.35,14.59 26.61,14.33 26.97,14.33 28.21,13.1 28.67,13.1 30.62,11.14 31.53,11.14 31.65,11.03 35.04,11.03 35.21,10.85 47.52,10.85 51.95,6.42 60.02,6.42 60.6,5.83 63.1,5.83 63.91,5.02 69.16,5.02 69.25,4.93 73.07,4.93 73.37,5.22 76.22,5.22 80.6,9.6 104.29,9.6 106.19,11.5 108.78,11.5 109.55,12.27 v7(113.32,12.27)
  GND1 w0.095: v3(255.26,11.15) 255.22,11.15 v9(254.8,11.56)
  GND3 w0.095: v3(255.26,11.15) 255.52,11.15 v4(255.6,11.06)
  BOTTOM w0.095: v4(255.6,11.06) 254.32,11.06 D11.2 253.86,11.52 R37.1
FAN2_PWM: length 212.1
  TOP w0.095: UE3.L11 17.07,17.65 17.68,17.65 17.91,17.42 v7(17.91,16.81)
  IN1 w0.076: v7(17.91,16.81) 17.94,16.81 18.35,16.4 22.66,16.4 23,16.06 24.16,16.06 25.2,15.03 26.14,15.03 26.32,15.21 26.92,15.21 28.04,14.09 28.25,14.09 30.52,11.82 31.14,11.82 31.73,11.23 35.12,11.23 35.3,11.05 47.6,11.05 52.04,6.62 60.11,6.62 60.69,6.04 64.08,6.04 64.48,5.64 70.15,5.64 70.65,5.13 72.99,5.13 73.28,5.42 76.13,5.42 80.51,9.8 104.2,9.8 106.1,11.7 108.7,11.7 109.57,12.58 114.56,12.58 116.71,14.74 126.03,14.74 126.52,14.24 131.68,14.24 132.19,13.74 137.62,13.74 138.17,14.29 144.36,14.29 145.19,15.12 146.78,15.12 146.95,15.3 153.03,15.3 153.43,15.69 156.35,15.69 156.74,16.08 163.06,16.08 163.41,16.43 173.42,16.43 173.78,16.79 175.94,16.79 v9(176.18,16.56)
  GND1 w0.095: v9(176.18,16.56) 176.39,16.77 v3(176.45,16.77)
  GND3 w0.095: v4(176.75,16.62) 176.61,16.62 v3(176.45,16.77)
  BOTTOM w0.095: v4(176.75,16.62) 176.75,17.41 v2(177.05,17.71) 177.52,17.71 182.42,12.81 183.57,12.81 185.02,11.35 187.85,11.35 189.11,10.08 197.56,10.08 197.64,10.16 198.93,10.16 199.13,9.96 199.15,9.96 199.24,9.87 200.7,9.87 200.86,10.04 202.01,10.04 R39.1 203.34,9.56 206.83,6.07 JFAN2.3
FAN2_TACH: length 188.2
  IN1 w0.076: v9(181.11,11.47) 180.89,11.69 179.64,11.69 178.24,13.09 175.28,13.09 174.99,12.79 169.36,12.79 168.54,13.61 164.13,13.61 163.76,13.24 149.89,13.24 149.34,12.69 145.62,12.69 144.85,13.46 138.53,13.46 137.88,12.81 130.49,12.81 130.02,13.28 116.53,13.28 114.46,11.21 109.78,11.21 109.08,10.51 106.78,10.51 104.3,8.03 80.49,8.03 76.67,4.21 73.79,4.21 73.5,3.91 68.83,3.91 68.74,4 63.49,4 62.8,4.69 58.89,4.69 58.66,4.92 52,4.92 47.91,9.01 32.24,9.01 31.76,9.48 30.45,9.48 29.68,10.26 28.23,10.26 26.37,12.12 25.32,12.12 25.02,12.41 v7(24.7,12.41)
  GND1 w0.095: v3(181.5,11.89) 181.5,11.86 v9(181.11,11.47)
  GND3 w0.095: v4(181.88,11.89) v3(181.5,11.89)
  BOTTOM w0.095: D12.2 200.78,9.55 200.07,8.85 R40.1 199.58,8.85 199.22,9.21 199.22,9.56 198.84,9.94 197.73,9.94 197.65,9.86 189.02,9.86 187.75,11.13 184.93,11.13 184.17,11.89 v2(183.54,11.89) v4(181.88,11.89)
FB_1.0V: length 6.2
  BOTTOM w0.095: v2(134.9,11.2) 135.12,11.41 PR702.2
  BOTTOM w0.254: 134.71,8.69 135.25,8.15 PU700.14
  BOTTOM w0.305: PR702.2 135.93,10.55 PC706.2 135.58,10.52 135.28,10.22 135.28,9.18 134.79,8.69 PR705.1
FB_1.8VA: length 5.4
  BOTTOM w0.254: PC801.2 PR802.2 155.86,64.22 156.71,64.22 PR804.1 157.86,64.17 158.45,64.76 v2(158.55,64.76) 158.73,64.76 158.83,64.66 158.83,64.13 158.97,63.98 PU800.5
FB_1.8VU: length 4.5
  BOTTOM w0.095: PR902.2 159.87,8.7 v2(159.4,9.18)
  BOTTOM w0.254: PR902.2 PC901.2 159.89,7.29 159.89,6.46 PR904.1 159.46,6.44 159.21,6.69 PU900.5
FCCM_GT: length 37.5
  TOP w0.095: v8(62.75,40.53) v2(62.17,40.53)
  TOP w0.203: PU1000.11 42.97,44.25 43.37,43.85 43.93,43.85 v7(43.98,43.9)
  TOP w0.254: v8(60.43,50.68) 61.11,50.68 PR1108.1
  IN1 w0.254: v7(43.98,43.9) 44.36,44.28 49.04,44.28 51.53,41.79 51.53,41.76 51.81,41.49 51.83,41.49 52.85,40.47 52.85,40.44 53.13,40.16 53.15,40.16 53.68,39.63 56.07,39.63 56.79,40.35 62.57,40.35 v8(62.75,40.53) 62.19,41.09 62.19,45.02 61.54,45.67 61.54,48.92 61.12,49.35 61.12,49.99 v8(60.43,50.68)
  BOTTOM w0.254: PU1150.2 63.83,41.73 62.75,40.65 v8(62.75,40.53)
FCCM_SA: length 21
  TOP w0.095: v8(55.34,46.23) v2(54.55,46.23)
  TOP w0.203: v7(39.79,51.82) 39.77,51.8 PU1000.34
  IN1 w0.254: v8(55.34,46.23) 52.86,46.23 50.9,48.19 47.72,48.19 47.52,47.99 46.47,47.99 46.3,48.16 45.47,48.16 44.18,49.45 44.18,50.06 42.9,51.34 40.12,51.34 39.79,51.67 v7(39.79,51.82)
  BOTTOM w0.254: v8(55.34,46.23) 55.34,46.51 PU1151.2
FCCM_VCORE: length 29.8
  TOP w0.095: v8(60.4,51.53) v2(59.89,52.04)
  TOP w0.203: v1(44.87,50.3) 44.65,50.08 PU1000.24
  TOP w0.254: PR1111.1 61.14,51.53 v8(60.4,51.53)
  GND1 w0.254: v3(45.63,50.38) 44.95,50.38 v1(44.87,50.3)
  IN3 w0.254: v8(60.4,51.53) 60.57,51.71 60.57,52.07 59.98,52.66 54.09,52.66 52.17,50.74 49.27,50.74 48.63,51.38 46.64,51.38 v3(45.63,50.38)
  BOTTOM w0.254: PU1100.2 62.43,59.8 62.19,59.57 62.19,59.19 61.76,58.76 61.76,57.83 61.47,57.54 61.47,52.95 60.59,52.07 60.59,51.72 v8(60.4,51.53)
FGND: length 5.4
  BOTTOM w0.095: v2(278.25,11.74) 278.69,11.3 278.69,10.09 278.26,9.66 RE255.2
  BOTTOM w0.305: JFP2.4 277.58,8.15 277.66,8.24 277.66,9.15 RE255.2
FPR_DET#: length 263.4
  TOP w0.095: RE280.1 28.97,7.94 29.58,8.55 RE281.1 30.04,8.67 30.54,9.16 30.54,9.28 31.37,10.11 31.37,10.13 v7(31.62,10.38) ; v7(260.72,13.32) 260.75,13.34 v7(263.3,13.34)
  IN1 w0.076: v7(31.62,10.38) 31.86,10.62 34.87,10.62 35.05,10.44 47.34,10.44 52.25,5.53 59.58,5.53 59.74,5.38 60.52,5.38 60.57,5.43 62.93,5.43 63.74,4.61 69,4.61 69.08,4.52 73.24,4.52 73.53,4.82 76.39,4.82 80.23,8.66 99.14,8.66 99.67,9.19 104.58,9.19 106.48,11.09 108.95,11.09 109.63,11.78 114.46,11.78 116.36,13.68 131.58,13.68 131.99,13.28 137.74,13.28 138.34,13.88 145.23,13.88 145.25,13.86 149.01,13.86 149.44,14.28 156.75,14.28 157.33,14.86 160.87,14.86 161.33,14.4 161.73,14.4 162.32,14.99 163.49,14.99 163.61,15.11 165.18,15.11 165.55,14.74 177.52,14.74 178.79,13.47 178.79,13.11 179.75,12.16 181.12,12.16 182.86,10.42 184.4,10.42 186.3,8.51 206.87,8.51 211.92,13.57 221.09,13.57 222.82,11.84 227.21,11.84 230.76,8.3 249.72,8.3 250.77,9.34 253.31,9.34 254.06,10.09 254.6,10.09 257.01,12.5 260.11,12.5 260.72,13.12 v7(260.72,13.32) ; v9(263.95,13.57) 263.72,13.34 v7(263.3,13.34)
  GND1 w0.095: v9(263.95,13.57) 263.95,13.04 v3(264.47,12.52)
  GND3 w0.095: v6(264.85,12.83) 264.78,12.83 v3(264.47,12.52)
  IN4 w0.076: v5(272.12,10.85) 271.65,11.33 266.54,11.33 v5(265.22,12.65) 265.03,12.83 v6(264.85,12.83)
FPR_GPIO_DET#: length 15.2
  IN4 w0.254: v5(271.77,7.21) 271.72,7.26 271.25,7.26 270.59,6.6 270.59,6.1 271.05,5.65 v5(271.64,5.65) ; v5(276.76,5.88) 276.75,5.86 275.02,5.86 274.82,5.66 v5(273.58,5.66)
  BOTTOM w0.095: RE274.2 271.78,9.94 271.49,10.23 v2(270.94,10.23)
  BOTTOM w0.254: v5(273.58,5.66) 273.57,5.65 MD3.2 MD3.3 v5(271.64,5.65) ; v5(276.76,5.88) 276.08,6.56 JFP2.1 ; v5(271.77,7.21) 271.77,8.18 272.43,8.84 272.43,9.18 272.12,9.48 RE274.2
FPR_SCAN#: length 280.5
  TOP w0.095: RE254.1 26.83,12.63 RE272.1 26.54,12.63 26.32,12.41 v7(25.79,12.41) ; UE3.E5 21.52,13.21 v7(21.86,13.56)
  IN1 w0.076: v7(21.86,13.56) 21.97,13.44 22.58,13.44 22.75,13.28 23.56,13.28 23.95,12.88 24.86,12.88 25.33,12.41 v7(25.79,12.41) 26.53,12.41 28.1,10.84 29.67,10.84 v9(30.39,10.12)
  GND1 w0.095: v3(30.81,10.68) 30.77,10.64 30.77,10.5 v9(30.39,10.12)
  GND3 w0.095: v6(30.92,10.36) 30.81,10.47 v3(30.81,10.68)
  IN4 w0.076: v5(152.18,6.69) 152.18,6.11 152.93,5.36 154.58,5.36 155.32,4.63 157.08,4.63 161.06,8.6 163.83,8.6 165.08,9.85 169.48,9.85 170.63,8.7 172.78,8.7 174.88,6.59 184.2,6.59 185.68,5.12 196.76,5.12 196.93,5.29 201.06,5.29 202.76,6.99 203.91,6.99 204.17,7.24 207.23,7.24 209.42,9.43 209.69,9.43 212.6,12.34 216.24,12.34 218.67,9.91 222.81,9.91 225.22,7.5 251.74,7.5 252.42,8.18 258.35,8.18 258.83,7.7 262.33,7.7 263.19,6.83 263.19,6.28 263.6,5.87 268.29,5.87 268.51,6.09 269.26,6.09 269.5,5.85 v5(270.05,5.85) ; v5(150.97,12.95) 150.52,12.95 149.74,12.17 146.64,12.17 146.45,12.36 145.56,12.36 145.03,12.89 139.9,12.89 139.77,12.76 129.8,12.76 129.67,12.88 125.81,12.88 125.69,12.77 120.34,12.77 119.68,12.11 114.9,12.11 114.8,12.01 110.99,12.01 109.94,10.96 100.59,10.96 99.05,9.43 79.66,9.43 76.08,5.85 69.51,5.85 69.34,6.03 68.3,6.03 68.01,6.32 65.89,6.32 65.17,7.04 58.73,7.04 58.65,6.96 51.43,6.96 49.23,9.16 47.4,9.16 46.76,9.8 41.89,9.8 41.56,10.13 37.46,10.13 36.51,9.18 35.32,9.18 34.4,10.1 31.18,10.1 v6(30.92,10.36)
  BOTTOM w0.095: v5(150.97,12.95) 151.29,12.63 151.29,11.3 151.48,11.12 v2(151.66,11.12) 152.41,10.37 152.41,6.93 152.18,6.7 v5(152.18,6.69) ; v5(270.05,5.85) 270.61,6.41 270.61,8.35 270.66,8.4 270.66,8.57 271.02,8.92 RE273.1
GPIO006: length 7.3
  IN1 w0.076: v7(23.1,10.81) 23.73,11.44 24.31,11.44 24.95,10.79 26.16,10.79 27.86,9.1 28.56,9.1 v7(29,8.67)
GPIO043: length 6.3
  IN1 w0.076: v7(10.29,14.82) 13.55,14.82 15.15,16.42 v7(15.9,16.42)
GPIO206: length 7.3
  IN1 w0.076: v7(29.53,14.99) 29.22,14.69 28.2,14.69 27.01,15.88 24.97,15.88 24.44,16.42 v7(23.1,16.42)
GPP_B22: length 2.2
  TOP w0.095: v2(134.09,49.46) 134.09,49.3 v8(134.37,49.01) 134.78,48.6 RC46.2
  BOTTOM w0.112: v8(134.37,49.01) 134.67,49.31 UCPU1.AN5
GPP_B23: length 2.7
  TOP w0.095: v8(133.53,49.55) 133.53,49.6 133.95,50.02 134.34,50.02 134.87,49.49 RC29.1
  BOTTOM w0.112: UCPU1.AM7 133.94,49.96 v8(133.53,49.55)
GPP_C5: length 3.8
  BOTTOM w0.095: UCPU1.W1 137.61,56.08 137.85,55.84 140.85,55.84 RC27.1
GPP_E1: length 2.2
  TOP w0.095: v1(136.17,61.68) 135.77,61.68 v2(135.33,61.25)
  GND1 w0.095: v1(136.17,61.68) 135.94,61.91 v3(135.94,62.42)
  GND3 w0.095: v4(135.94,62.05) v3(135.94,62.42)
H_CATERR#: length 7.6
  BOTTOM w0.076: UCPU1.D63 102.12,64.56 102.12,64.99 102.26,65.47 102.26,65.7 102.24,65.74 102.21,65.85 102.21,65.97 102.22,65.98 102.24,66.05 102.24,67.4 101.51,68.14 101.51,69.09 101.78,69.36 RC219.2 102.35,70.1 v2(102.76,70.5)
H_CPU_SVIDALRT#: length 6.7
  BOTTOM w0.076: RC155.1 100.75,70.24 100.46,70.24 100.38,70.16 100.38,69.78 100.27,69.66 99.78,69.66 99.62,69.5 99.62,69.23 101.54,67.3 101.54,66.1 101.83,65.82 UCPU1.B63
H_CPUPWRGD: length 6.4
  TOP w0.095: v8(95.77,67.93) 95.83,67.99 CA1.1 96.49,67.19 RC85.2 96.83,66.66 v2(97.35,66.66)
  BOTTOM w0.076: UCPU1.A68 97.92,67 96.95,67 96.03,67.93 v8(95.77,67.93)
H_CPUPWRGD_R: length 1
  TOP w0.095: T10.1 95.48,66.29 RC85.1
H_PROCHOT#: length 203.6
  TOP w0.095: PR315.1 58.55,7.48 v2(58.55,4.78) 58.55,4.64 v1(59.63,2.04) ; v1(10.95,14.01) 11.31,14.37 RE158.2 ; RC220.1 RC221.2 v1(96.94,71.51)
  GND1 w0.095: v3(10.91,13.63) 10.95,13.67 v1(10.95,14.01) ; v1(59.63,2.04) 59.63,1.72 59.69,1.66 v3(59.69,1.49) ; v3(97.11,72.14) 97.11,71.98 96.94,71.81 v1(96.94,71.51)
  GND3 w0.095: v6(10.94,13.21) 10.91,13.24 v3(10.91,13.63) ; v3(97.11,72.14) 97.11,72.33 v6(96.95,72.49) ; v6(59.23,1.56) 59.34,1.66 59.59,1.66 59.69,1.56 v3(59.69,1.49)
  IN4 w0.076: v5(9.03,15.87) 9.03,13.58 9.39,13.21 v6(10.94,13.21) 10.77,13.04 10.77,7.99 11.94,6.81 13.59,6.81 13.78,6.63 13.78,4.9 15.35,3.32 25.72,3.32 27.37,1.67 36.04,1.67 36.41,1.31 58.99,1.31 v6(59.23,1.56) ; v5(38.31,47.45) 38.65,47.79 38.65,50.06 44.13,55.54 44.13,58.39 44.92,59.18 45.9,59.18 46.51,59.79 46.51,64.31 53.35,71.15 61.43,71.15 62.68,72.41 77.9,72.41 79.64,70.67 83.4,70.67 84.16,71.43 85.76,71.43 86.68,72.35 87.75,72.35 88.2,72.8 90.62,72.8 90.99,72.42 91.19,72.42 91.61,72 92.02,72 92.27,72.24 92.72,72.24 92.98,71.98 95.31,71.98 95.82,72.49 v6(96.95,72.49)
  BOTTOM w0.095: v5(38.31,47.45) 38.29,47.46 PR1009.1 37.56,47.46 35.08,44.98 35.08,35.33 34.34,34.59 31.12,34.59 29.22,32.69 27.71,32.69 26.99,31.97 26.26,31.97 25.38,31.09 24.24,31.09 23.18,30.02 23.18,29.22 20.2,26.24 19.64,26.24 19.24,25.85 19.24,23.01 18.74,22.51 16.88,22.51 16.13,21.76 13.85,21.76 13.31,21.22 13.31,20.52 12.77,19.98 11.07,19.98 10.81,20.24 9.78,20.24 9.25,19.71 9.25,18.64 9.76,18.13 9.76,16.6 9.04,15.87 v5(9.03,15.87)
H_PROCHOT#_R: length 8.5
  TOP w0.095: RC220.2 96.94,69.45 v1(97.17,69.22) 97.19,69.2 v2(97.95,69.2)
  GND1 w0.095: v3(97.42,68.96) 97.17,69.21 v1(97.17,69.22)
  GND3 w0.095: v4(97.42,68.63) 97.42,68.63 v3(97.42,68.96)
  BOTTOM w0.076: v4(97.42,68.63) 97.43,68.63 97.74,68.32 99.73,68.32 101.01,67.04 101.01,65.43 100.7,65.12 UCPU1.C65
H_PROCHOT#_R1: length 3.1
  TOP w0.095: UE3.H13 14.15,15.62 v2(13.71,15.17) 12.9,14.37 RE158.1
H_THERMTRIP#: length 125.2
  GND1 w0.095: v3(101.11,68.96) 101.01,69.06 v1(101.01,69.38)
  IN2 w0.064: v3(14.69,26.72) 14.83,26.58 16.37,26.58 16.71,26.92 16.71,27.42 17.29,28.01 19.62,28.01 19.68,27.95 20.24,27.95 20.44,28.15 22.17,28.15 22.61,28.59 25.19,28.59 25.76,29.16 29.02,29.16 29.52,29.66 31.1,29.66 31.94,30.5 32.77,30.5 32.93,30.34 33.77,30.34 34.05,30.62 34.77,30.62 34.98,30.83 34.98,31.16 35.99,32.17 35.99,34.65 35.23,35.41 35.23,36.33 34.85,36.7 34.85,37.26 35.23,37.63 35.23,38.7 34.88,39.05 34.88,41.29 35.33,41.74 38.55,41.74 v3(38.81,41.99)
  GND3 w0.095: v3(38.81,41.99) 38.81,42.14 v6(38.96,42.3) ; v3(14.69,26.72) 14.64,26.77 v4(14.33,26.77) ; v6(101.11,68.6) v3(101.11,68.96)
  IN4 w0.076: v6(38.96,42.3) 38.96,42.67 38.75,42.88 38.75,43.27 40.06,44.58 40.86,44.58 43.4,47.12 47.39,47.12 47.57,47.31 47.57,51 47.84,51.27 48.46,51.89 48.46,54.72 49.05,55.32 49.98,55.32 51.37,56.7 51.37,60.4 52.94,61.97 52.94,62.98 56.29,66.33 60.7,66.33 61.24,65.79 78.3,65.79 78.63,65.46 84.47,65.46 86.03,63.91 86.03,63.91 86.45,63.49 90.18,63.49 90.18,63.49 91.48,63.49 93.06,65.07 96.91,65.07 97.71,65.87 97.71,67.19 98.74,68.22 100.88,68.22 101.11,68.45 v6(101.11,68.6)
  BOTTOM w0.095: v2(13.97,28.06) 13.97,27.13 v4(14.33,26.77)
H_THERMTRIP#_R: length 6.9
  TOP w0.095: RC222.2 100.19,69.73 100.2,69.73 RC218.2
  GND1 w0.095: v3(100.5,68.96) 100.3,69.16 v1(100.3,69.36)
  GND3 w0.095: v3(100.5,68.96) 100.5,69.18 v4(100.65,69.33)
  BOTTOM w0.076: v4(100.65,69.33) 101.27,68.71 101.27,68.13 102.08,67.32 102.08,66.11 102.04,65.99 102.04,65.81 102.09,65.67 102.09,65.53 101.94,65.01 101.86,64.92 UCPU1.C63
H_VCCST_PWRGD: length 33.6
  TOP w0.095: v8(9.56,10.75) 9.26,10.45 8.31,10.45 7.46,11.3 RE4.2 7.24,10.54 v7(7.28,10.5) ; UE3.J6 20.32,16.03 v8(20.31,16.03)
  IN1 w0.076: v8(7.81,21.65) 7.57,21.65 7.44,21.52 5.64,21.52 4.24,20.12 4.24,18.42 4.52,18.14 4.52,13.87 7.28,11.11 v7(7.28,10.5)
  IN2 w0.064: v8(20.31,16.03) 20.13,15.86 19.46,15.86 19.23,15.63 17.53,15.63 17.3,15.85 15.86,15.85 13.68,13.67 13.38,13.67 13.37,13.67 12.77,13.67 11.76,12.67 11.76,12.1 10.73,11.07 9.88,11.07 v8(9.56,10.75)
  BOTTOM w0.095: U16.2 7.96,21.8 v8(7.81,21.65)
H_VCCST_PWRGD_P: length 172.7
  TOP w0.095: RE4.1 7.24,13.04 v8(7.42,13.21) ; RC371.1 v2(40.78,63.16) v7(40.36,62.74) 38.53,60.92 35.22,60.92 33.55,59.25 30.99,59.25 29.9,58.16 29.9,55.77 v7(29.67,55.54)
  IN1 w0.076: v7(40.36,62.74) 41.41,61.69 v9(50.1,61.69) ; v9(6.89,23.43) 6.89,24.29 8.05,25.46 10.07,25.46 12.25,27.64 12.25,29.52 10.63,31.13 10.63,31.58 8.81,33.4 8.81,36.22 9.63,37.04 9.63,38.93 9.88,39.19 10.59,39.19 11.67,38.11 11.67,36.7 11.58,36.61 11.58,36.05 11.97,35.66 13.99,35.66 14.2,35.45 15.36,35.45 15.69,35.78 16.28,35.78 16.5,36 17.89,36 20.12,38.23 20.12,39.11 21.43,40.42 24.34,40.42 28.59,44.68 28.59,51.04 29.48,51.92 29.48,55.35 v7(29.67,55.54)
  GND1 w0.095: v3(6.89,22.94) v9(6.89,23.43) ; v9(50.1,61.69) 50.15,61.65 v3(50.55,61.65)
  IN3 w0.064: v3(6.89,22.94) 5.21,22.94 4.76,22.49 4.76,20.09 3.63,18.97 3.63,15.4 5.16,13.87 6.71,13.87 7.37,13.21 v8(7.42,13.21)
  GND3 w0.095: v6(50.51,62.04) 50.51,61.68 v3(50.55,61.65) ; v4(7.01,22.57) 6.89,22.7 v3(6.89,22.94)
  IN4 w0.076: v6(50.51,62.04) 50.51,63.57 51.06,64.11 51.06,64.77 54.73,68.45 61.17,68.45 62,67.62 78.76,67.62 79.3,68.17 84.58,68.17 87.35,65.4 89.97,65.4 91.5,66.92 91.5,67.13 93.44,69.07 96.55,69.07 96.83,69.36 v5(97.13,69.36)
  BOTTOM w0.095: v5(97.13,69.36) 97.13,69.81 CA2.1 97.76,70.44 97.76,71.27 97.19,71.84 RC86.1 97.5,71.97 97.84,71.62 98.51,71.62 99.28,72.4 RC79.2 ; U16.4 9.27,22.45 8.8,22.92 8.08,22.92 7.72,22.56 RE118.1 v4(7.01,22.57) 6.76,22.83 6.76,23.84 7.17,24.25 UE7.4
HDA_BIT_CLK: length 5
  BOTTOM w0.076: UCPU1.AY22 125.4,44.83 125.24,44.67 125.17,44.46 125.14,44.35 125.14,43.46 125.58,43.01 125.58,42.56 125.58,41.95 125.34,41.7 125.34,40.65 RC112.2
HDA_BIT_CLK_R: length 237.5
  IN1 w0.076: v9(274.18,65.13) 270.91,61.85 270.91,60.03 269.27,58.39 269.27,54.9 273.05,51.11 273.05,45.92 273.84,45.14 273.84,34.21 v7(275.12,32.93) 275.12,29.93 275.28,29.77 275.28,23.57 275.72,23.13 275.72,22.62 v9(275.76,22.58)
  GND1 w0.095: v3(274.26,65.5) 274.26,65.26 274.18,65.18 v9(274.18,65.13) ; v3(275.76,22.24) v9(275.76,22.58)
  IN2 w0.064: v3(132.65,42.57) 132.69,42.53 132.69,40.55 133.16,40.08 133.62,40.08 134.75,38.95 139.3,38.95 142.85,35.4 142.85,34.75 145.83,31.77 147.92,31.77 151.03,28.67 151.03,26.5 152.47,25.07 152.47,18.56 153.63,17.4 153.63,16.41 153.89,16.15 153.89,16.15 154.52,15.52 156.05,15.52 159.43,12.14 160.36,12.14 161.12,11.38 161.4,11.38 163.52,9.26 167.25,9.26 170.49,6.02 173.02,6.02 173.51,6.51 183.89,6.51 185.59,4.81 218.31,4.81 220.33,6.83 225.54,6.83 225.96,6.41 227.86,6.41 229.41,4.86 257.06,4.86 257.48,5.28 259.59,5.28 267.86,13.56 268.26,13.56 270.33,15.63 270.33,17.13 270.68,17.47 271.69,17.47 272.73,18.51 272.73,19.6 273.34,20.2 274.08,20.2 275.76,21.88 v3(275.76,22.24)
  GND3 w0.095: v3(274.26,65.5) 274.26,65.67 v4(274.1,65.83) ; v3(132.65,42.57) 132.42,42.79 v6(132.36,42.79)
  IN4 w0.076: v6(132.36,42.79) 130.91,42.79 130.18,43.53 128.64,43.53 127.51,42.4 127.51,40.68 126.49,39.66 v4(126.36,39.66)
  BOTTOM w0.095: v4(274.1,65.83) 274.1,65.85 274.45,66.2 CA21.1 274.72,66.15 274.72,65.69 274.86,65.55 U5.14 ; v4(126.36,39.66) 126.14,39.44 RC112.1
HDA_RST#: length 12.4
  BOTTOM w0.076: T15.1 122.98,38.06 123.61,37.42 125.37,37.42 125.76,37.81 CR26.2 125.76,38.93 125.68,39.02 125.34,39.02 125.18,39.19 125.18,42.24 125.42,42.49 125.42,42.92 124.97,43.37 124.97,44.38 124.98,44.41 125.02,44.51 125.11,44.8 125.11,45.12 125.4,45.41 UCPU1.AW22
HDA_SDIN0: length 238.6
  IN1 w0.076: v9(271.41,64.07) 271.41,63.07 270.45,62.11 270.45,60.22 268.81,58.58 268.81,54.71 272.6,50.92 272.6,44.68 273.38,43.9 273.38,33.85 274.55,32.68 274.55,29.85 274.82,29.58 274.82,23.36 275.26,22.93 v9(275.26,22.47)
  GND1 w0.095: v9(271.41,64.07) 271.57,64.23 v3(271.57,64.46) ; v3(274.92,22.4) 274.99,22.47 v9(275.26,22.47)
  IN2 w0.064: v3(146.42,35.52) 147.08,34.86 147.08,34.49 154.04,27.53 154.04,22.25 154.7,21.6 154.7,21.01 155.21,20.49 155.21,18.54 160.47,13.29 161.24,13.29 164.59,9.93 167.57,9.93 170.83,6.68 172.58,6.68 173.05,7.14 184.17,7.14 185.83,5.49 209.16,5.49 209.84,6.17 211.39,6.17 212.07,5.5 216.66,5.5 218.63,7.46 225.8,7.46 226.22,7.04 228.14,7.04 229.67,5.51 256.79,5.51 257.42,6.14 259.54,6.14 267.16,13.76 267.16,16.11 267.95,16.89 267.95,17.67 268.52,18.25 271.43,18.25 272.1,18.92 272.1,19.96 273.03,20.9 273.03,21.54 273.89,22.4 v3(274.92,22.4)
  GND3 w0.095: v3(271.57,64.46) 271.58,64.47 v6(271.58,64.81) ; v3(146.42,35.52) 146.39,35.52 v4(146.17,35.29)
  IN4 w0.076: v6(271.58,64.81) 273.53,66.77 275.39,66.77 275.5,66.87 v5(275.5,66.9)
  BOTTOM w0.076: 127.92,39.91 127.92,39.93 CR25.2 127.36,41.42 127.1,41.68 126.66,41.68 126.08,42.26 126.08,43.16 125.97,43.26 125.97,44.57 UCPU1.BA21
  BOTTOM w0.095: v4(146.17,35.29) 146.14,35.27 145.49,35.27 142.97,32.74 140.46,32.74 139.52,33.69 136.13,33.69 134.23,35.58 131.39,35.58 v2(130.72,36.25) 129.53,37.45 128.97,37.45 127.92,38.5 127.92,39.91
HDA_SDIN0_R: length 2.5
  BOTTOM w0.095: v2(276.4,66.62) 275.81,66.62 RA14.2 275.5,65.54 275.66,65.38 U5.16
HDA_SDOUT: length 39.8
  TOP w0.095: v1(126.91,40.27) v2(126.91,37.78) 126.91,35.84 129.98,32.77 136.77,32.77 137.11,33.12 140.05,33.12 141.04,34.11 141.44,34.11 142,34.66 142,35.99 143.36,37.35 144.11,37.35 144.6,37.85 147.18,37.85 147.59,38.26 149.49,38.26 150.86,39.63 RH73.2
  GND1 w0.095: v1(126.91,40.27) 126.75,40.11 v3(126.56,40.11)
  GND3 w0.095: v3(126.56,40.11) 126.98,40.11 v4(127.22,39.87)
  BOTTOM w0.076: v4(127.22,39.87) 127.13,39.87 126.83,40.16 126.39,40.16 126.1,40.46 126.1,40.9 125.79,41.21 RC119.2
  BOTTOM w0.095: RC119.2 125.79,41.68 125.86,41.75 125.86,43.07 125.4,43.53 UCPU1.BB22
HDA_SDOUT_R: length 231
  IN1 w0.076: v9(275.96,23.55) 275.97,23.55 275.97,23.72 275.74,23.95 275.74,29.96 275.58,30.12 275.58,34.33 274.29,35.62 274.29,45.32 273.51,46.11 273.51,51.3 269.73,55.09 269.73,58.2 271.36,59.84 271.36,61.59 275.29,65.51 275.56,65.51 v9(275.63,65.59)
  GND1 w0.095: v9(275.96,23.55) 275.44,23.03 v3(275.38,23.03) ; v9(275.63,65.59) 275.63,65.6 275.63,65.94 v3(275.61,65.96)
  IN2 w0.064: v3(146.58,34.7) 153.85,27.43 153.85,22.17 154.5,21.52 154.5,20.93 155.02,20.41 155.02,18.46 155.42,18.06 155.42,18.05 160.38,13.1 161.16,13.1 164.51,9.74 167.48,9.74 170.75,6.47 172.75,6.47 173.23,6.95 184.08,6.95 185.74,5.3 209.29,5.3 209.97,5.98 211.29,5.98 211.96,5.31 216.74,5.31 218.71,7.27 225.72,7.27 226.14,6.85 228.05,6.85 229.59,5.31 256.88,5.31 257.51,5.95 259.62,5.95 267.35,13.68 267.35,16.03 268.19,16.87 269.44,16.87 270.49,17.92 271.36,17.92 272.29,18.84 272.29,19.82 273.46,20.98 274.23,20.98 274.46,21.21 274.46,21.84 274.61,21.99 275.14,21.99 275.31,22.16 275.31,22.96 v3(275.38,23.03)
  GND3 w0.095: v4(146.14,34.7) v3(146.58,34.7) ; v3(275.61,65.96) 275.61,65.89 v4(275.81,65.69)
  BOTTOM w0.095: U5.17 276.06,65.36 275.81,65.62 v4(275.81,65.69) ; v4(146.14,34.7) 146.13,34.71 145.25,34.71 143.06,32.52 140.37,32.52 139.42,33.46 136.04,33.46 134.14,35.36 131.03,35.36 v2(129.28,37.12) 128.53,37.12 127.37,38.27 RC113.1
HDA_SYNC: length 7.6
  BOTTOM w0.076: UCPU1.BA22 125.4,44.39 125.87,44.86 126.19,44.86 126.25,44.8 126.25,44.13 126.14,44.01 126.14,43.33 126.29,43.18 126.29,42.33 126.78,41.84 127.19,41.84 127.69,41.35 127.69,40.41 127.79,40.3 127.99,40.3 128.01,40.28
  BOTTOM w0.095: 128.01,40.28 128.47,39.82 RC111.2
HDA_SYNC_R: length 229.3
  IN1 w0.076: v9(275.33,65.11) 275.17,65.11 271.57,61.51 271.57,59.76 269.93,58.12 269.93,55.17 273.71,51.39 273.71,46.19 274.5,45.41 274.5,35.7 275.78,34.42 275.78,30.21 276.12,29.87 v9(276.12,24.47)
  GND1 w0.095: v9(276.12,24.47) 276.06,24.47 275.99,24.39 v3(275.58,24.39) ; v3(275.05,65.39) v9(275.33,65.11)
  IN2 w0.064: v3(275.58,24.39) 275.58,24.36 272.84,21.62 272.84,20.98 271.91,20.04 271.91,19 271.35,18.44 268.45,18.44 267.76,17.75 267.76,16.97 266.97,16.18 266.97,13.84 259.46,6.33 257.34,6.33 256.71,5.7 229.79,5.7 228.25,7.23 226.3,7.23 225.88,7.65 218.55,7.65 216.58,5.69 212.26,5.69 211.58,6.36 209.75,6.36 209.07,5.68 185.92,5.68 184.26,7.33 172.97,7.33 172.52,6.88 170.91,6.88 167.66,10.13 164.66,10.13 161.32,13.48 160.55,13.48 155.4,18.62 155.4,20.58 154.89,21.09 154.89,21.68 154.23,22.34 154.23,27.62 147.32,34.53 147.32,35.14 v3(147.09,35.37)
  GND3 w0.095: v3(147.09,35.37) 146.86,35.6 v4(146.86,35.84) ; v3(275.05,65.39) 275.17,65.51 v4(275.17,65.77)
  BOTTOM w0.095: v4(275.17,65.77) 275.26,65.68 U5.15 ; RC111.1 129.54,37.77 129.66,37.77 131.63,35.81 134.32,35.81 136.22,33.91 139.61,33.91 140.55,32.97 142.79,32.97 145.67,35.84 v2(146.18,35.84) v4(146.86,35.84)
HOST_DEBUG_TX: length 10.8
  TOP w0.095: UE3.G11 v8(16.31,14.42)
  IN3 w0.064: v3(12.85,15.49) 13.75,15.49 14.36,14.87 15.62,14.87 16.07,14.42 v8(16.31,14.42)
  GND3 w0.095: v4(12.56,15.26) 12.79,15.49 v3(12.85,15.49)
  IN4 w0.076: v8(16.31,14.42) 16.72,14.01 17.94,14.01 18.28,13.67 18.28,12.74 18.56,12.46 18.65,12.46 19.23,11.88 v4(19.81,11.88)
  BOTTOM w0.095: v4(12.56,15.26) RE202.2
HOST_SD_WP#: length 215.5
  IN1 w0.076: v9(163.33,9.13) 163.81,9.13 164.68,8.26 167.57,8.26 168.87,6.97 182.96,6.97 184.87,5.06 218.35,5.06 219.12,5.82 222.48,5.82 223.25,5.06 225.29,5.06 227.13,3.22 254.82,3.22 256.3,4.7 257.09,4.7 v9(258.8,6.42)
  GND1 w0.095: v9(163.33,9.13) v3(162.97,9.13) ; v3(258.69,6.99) 258.8,6.89 v9(258.8,6.42)
  IN2 w0.064: v3(258.69,6.99) 258.79,6.99 259,6.79 259.41,6.79 264.06,11.44 264.06,13.23 266.47,15.64 266.47,16.82 267.47,17.81 267.47,18.31 267.79,18.63 271.27,18.63 271.72,19.08 271.72,20.12 272.65,21.06 272.65,21.97 276.2,25.52 276.2,28.75 278.22,30.78 289.09,30.78 289.58,31.26 290.51,31.26 290.76,31.52 v8(291.35,31.52)
  IN3 w0.064: v3(162.97,9.13) 162.29,9.13 156.59,14.83 154.35,14.83 152.47,16.71 152.47,18.13 v3(150.66,19.94)
  GND3 w0.095: v6(150.16,20.06) 150.22,20 150.59,20 150.65,19.94 v3(150.66,19.94)
  IN4 w0.076: v6(150.16,20.06) 150.03,20.19 150.03,22.72 150.26,22.96 150.26,29.25 148.56,30.95 148.56,33.39 148.04,33.91 148.04,35.05 148.29,35.3 148.29,38.35 148.89,38.94 148.89,46.6 144.38,51.12 142.42,51.12 141.62,51.92 141.62,52.99 v5(141.15,53.47)
  BOTTOM w0.095: v2(293.35,28.71) 293.35,28.77 QR1.2 292.03,29.79 291.35,30.46 v8(291.35,31.52) ; RC38.2 140.59,53.49 140.01,54.06 139.76,54.06 139.61,54.2 138.01,54.2 137.94,54.28 137.49,54.28 137.41,54.36 136.76,54.36 136.36,54.76 UCPU1.AB3
HP2_D_L: length 12.3
  IN3 w0.254: v3(285.39,57.88) 282.03,61.24 v3(282.03,64.55)
  GND3 w0.254: v4(282.39,64.55) v3(282.03,64.55) ; v4(285.67,57.68) 285.47,57.88 v3(285.39,57.88)
  BOTTOM w0.254: v2(280.94,63.72) 281.78,64.55 v4(282.39,64.55) ; v4(285.67,57.68) 285.68,57.68 RA60.1 286.51,57.7 RA53.1
HP2_D_L_C: length 7.6
  IN3 w0.254: v3(286.83,60.48) 286.91,60.4 v3(289.03,60.4)
  GND3 w0.254: v3(286.83,60.48) 286.68,60.33 v4(286.52,60.33) ; v4(289.37,60.1) 289.33,60.1 v3(289.03,60.4)
  BOTTOM w0.203: JAUDIO1.5 291.02,61.91 291.02,61.91
  BOTTOM w0.254: v4(286.52,60.33) 286.52,59.46 LA9.2 ; v4(289.37,60.1) 289.37,61.02 289.84,61.5 v2(290.08,61.5) 290.61,61.5 291.02,61.91
HP2_D_L_R1: length 0.9
  BOTTOM w0.254: LA9.1 287.36,58.63 RA53.2
HP2_D_R: length 13.5
  IN3 w0.254: v3(282.39,65.79) 282.67,65.51 282.67,61.53 285.36,58.83 v3(285.39,58.83)
  GND3 w0.254: v3(285.39,58.83) v4(285.67,58.55) ; v4(282.39,65.44) v3(282.39,65.79)
  BOTTOM w0.254: RA58.2 285.67,58.58 RA59.1 RA54.1 ; v4(282.39,65.44) 281.93,65.44 v2(281.43,64.94) 280.56,64.07
HP2_D_R_C: length 6.6
  BOTTOM w0.203: JAUDIO1.7 290.62,62.09
  BOTTOM w0.254: 290.62,62.09 290.49,61.96 289.39,61.96 v2(288.8,61.36) 288.54,61.11 288.54,60.27 DA8.1 287.99,60.41 287.99,60.8 287.6,61.19 CA77.1 286.56,61.19 LA10.2
HP2_D_R_R1: length 1.9
  BOTTOM w0.102: LA10.1 285.18,61.22 v2(284.8,61.6)
  BOTTOM w0.254: RA54.2 285.7,61.2 LA10.1
HRESET_PD1: length 10.5
  TOP w0.095: v7(16.68,24.82) R5757.2 16.73,23.91 R5753.2
  IN1 w0.076: v7(16.68,24.82) 16.68,24.89 17.12,25.33 17.12,25.67 18.33,26.88 18.71,26.88 20.51,28.68 20.51,28.85 21.25,29.59 21.25,30.09 20.64,30.69 20.09,30.69 v7(19.98,30.81)
HRESET_PD1_EC: length 16
  TOP w0.095: UE3.K4 22.33,17.22 v8(22.72,17.61)
  GND1 w0.095: v1(17.31,23.32) 17.36,23.32 v3(17.7,23.66)
  GND3 w0.095: v6(18.15,23.66) v3(17.7,23.66)
  IN4 w0.076: v6(18.15,23.66) 18.15,23.91 19.52,25.28 19.83,25.28 20.11,25.01 20.11,23.96 21.03,23.03 21.03,20.7 19.71,19.38 19.71,17.67 20.15,17.24 22.35,17.24 v8(22.72,17.61)
HRESET_PD2: length 5.7
  TOP w0.095: v7(35.46,31.93) 35.67,31.72 R5745.2 35.98,31.58 36.23,31.33 36.79,31.33 37.08,31.62 R5763.2
  IN1 w0.076: v7(32.52,33.04) 33.14,33.04 33.43,32.76 33.79,32.76 34.04,32.51 35.11,32.51 35.46,32.17 v7(35.46,31.93)
HRESET_PD2_EC: length 38.9
  TOP w0.095: UE3.L6 20.84,18.02 v7(21.12,17.74) ; v7(34.34,11.73) 35.24,12.63 35.24,13.06 35.98,13.8 35.98,15.44 36.38,15.85 36.38,18.77 36.13,19.02 36.13,21.87 36.51,22.24 36.51,24.52 v2(36.6,24.61) 37.05,25.06 37.05,27.1 37.24,27.3 37.24,30.94 R5763.1
  IN1 w0.076: v7(34.34,11.73) 31.83,11.73 31.23,12.32 30.88,12.32 30.27,12.93 30.27,14.43 30.18,14.52 30.18,15.11 29,16.29 28.17,16.29 27.48,16.98 27.48,17.17 26.23,18.42 24.86,18.42 24.46,18.03 21.42,18.03 v7(21.12,17.74)
HRESET_PD3: length 11.1
  IN4 w0.076: v5(287.52,15.32) 287.98,14.87 287.98,14.13 288.35,13.76 288.86,13.76 289.38,14.28 289.7,14.28 290.26,14.84 294.13,14.84 294.36,15.07 v5(294.49,15.07)
  BOTTOM w0.095: RT98.2 RT99.2 294.43,14.45 294.15,14.17 294.15,12.85 v2(294.22,12.77)
HRESET_PD3_EC: length 333.3
  TOP w0.095: v8(7.53,6.01) 7.43,5.91 v2(7.43,5.2)
  IN1 w0.076: v9(288.9,10.03) 288.89,10.01 288.89,8.88 288.61,8.6 288.61,6.28 286.76,4.43 281.29,4.43 280.87,4.84 275.27,4.84 274.74,4.31 273.57,4.31 272.35,3.09 268.27,3.09 267.41,2.24 226.91,2.24 224.93,4.21 184.53,4.21 182.61,6.13 168.52,6.13 167.23,7.42 164.69,7.42 163.52,6.25 159.07,6.25 158.27,7.05 155.7,7.05 155.19,6.54 152.89,6.54 149.42,10.01 144.79,10.01 144.4,10.4 138.93,10.4 138.29,9.77 118.51,9.77 116.18,7.43 115.87,7.43 114.59,6.16 81.24,6.16 77.46,2.38 74.55,2.38 74.25,2.08 68.07,2.08 67.98,2.17 62.73,2.17 62.04,2.86 53.78,2.86 53.77,2.87 42.78,2.87 41.46,4.2 39.24,4.2 38.58,3.53 33.47,3.53 32.57,4.44 29.66,4.44 29.02,3.8 21.8,3.8 20.9,4.7 18.36,4.7 17.5,3.84 10.58,3.84 10.36,4.06 10.07,4.06 9.78,3.78 8.07,3.78 7.34,4.5 7.34,5.82 v8(7.53,6.01)
  GND1 w0.095: v3(289.21,10.33) v9(288.9,10.03) ; v3(21.81,14.51) v1(21.5,14.82)
  IN3 w0.064: v3(21.81,14.51) 22.13,14.19 22.66,14.19 22.98,13.88 22.98,13.34 21.3,11.66 21.3,10.45 20.24,9.39 15.28,9.39 15.28,9.39 13.89,9.39 13.62,9.12 12.41,9.12 10.42,7.12 10.42,6.18 10,5.76 7.79,5.76 v8(7.53,6.01)
  GND3 w0.095: v6(289.55,10.41) 289.28,10.41 v3(289.21,10.33)
  IN4 w0.076: v5(295.57,15.03) 295.57,14.39 293.19,12.02 293.19,11.08 292.53,10.41 v6(289.55,10.41)
  BOTTOM w0.095: RT98.1 v5(295.57,15.03)
I2C0_SCK_TS: length 106.6
  IN3 w0.064: v3(51.25,54.92) 50.89,54.92 50.38,55.43 48.24,55.43 47.1,56.58 47.1,58.62 47.72,59.24 59.29,59.24 61.24,61.19 61.24,63.63 62.42,64.81 75.74,64.81 77,63.54 77.72,63.54 78.21,63.05 79.03,63.05 83.6,58.49 93.53,58.49 94.82,59.78 99,59.78 99.32,60.09 102.15,60.09 104.53,57.71 113.06,57.71 113.25,57.52 119.59,57.52 120.91,58.85 123.61,58.85 124.57,57.88 126.21,57.88 127.47,56.62 128.02,56.62 128.54,56.1 134.22,56.1 134.48,56.36 v8(134.48,56.51)
  GND3 w0.095: v4(51.35,54.52) 51.35,54.83 v3(51.25,54.92)
  BOTTOM w0.076: v8(134.48,56.51) 134.83,56.87 UCPU1.U6
  BOTTOM w0.095: RR16.1 v4(51.35,54.52)
I2C0_SDA_TS: length 105.8
  IN3 w0.064: v3(50.32,54.87) 50.45,55 50.45,55.09 50.3,55.24 48.16,55.24 46.91,56.5 46.91,58.7 47.64,59.43 59.21,59.43 61.05,61.27 61.05,63.71 62.34,65 75.82,65 77.08,63.74 77.8,63.74 78.29,63.25 79.11,63.25 83.68,58.68 93.45,58.68 94.74,59.97 98.92,59.97 99.24,60.28 102.23,60.28 104.61,57.9 113.14,57.9 113.33,57.71 119.51,57.71 120.83,59.04 123.69,59.04 124.65,58.07 126.29,58.07 127.55,56.81 128.09,56.81 128.62,56.29 133.67,56.29 v8(133.89,56.51)
  GND3 w0.095: v3(50.32,54.87) 50.46,54.73 v4(50.46,54.52)
  BOTTOM w0.076: UCPU1.U7 134.18,56.81 v8(133.89,56.51)
  BOTTOM w0.095: RR15.1 50.46,55.2 v4(50.46,54.52)
