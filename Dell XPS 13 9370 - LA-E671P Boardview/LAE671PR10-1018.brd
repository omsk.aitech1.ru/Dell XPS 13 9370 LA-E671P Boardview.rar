# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AMP_I2S_OUT: length 3.1
  BOTTOM w0.095: U5.9 272.93,62.88 v2(272.44,63.37) 271.81,64 271.54,64 271.18,64.36 RA18.1
AMP_I2S_OUT_R: length 65.6
  TOP w0.095: U6.12 270.34,12.95 269.73,13.55 269.73,14.71 269.45,14.99 269.45,15.34 v2(269.51,15.4) 269.76,15.65 v1(269.98,15.65)
  GND1 w0.095: v3(269.8,16.08) 269.98,15.9 v1(269.98,15.65)
  GND3 w0.095: v3(269.8,16.08) 270.21,16.08 v6(270.28,16.01)
  IN4 w0.076: v5(269.34,64.38) 268.9,63.94 268.34,63.94 266.74,62.34 266.74,53.97 267.54,53.17 267.54,50.35 266.65,49.47 266.65,41.76 267.6,40.81 267.6,39.01 266.94,38.34 266.94,33.78 268.12,32.6 273.26,32.6 274.93,30.93 274.93,25.87 273.79,24.73 273.79,22.86 273.11,22.18 273.11,21.54 272.55,20.98 272.55,17.69 270.95,16.09 270.35,16.09 v6(270.28,16.01)
  BOTTOM w0.095: RA18.2 v5(269.34,64.38)
AMP_MUTE#: length 72.2
  TOP w0.095: U6.15 268.38,11.45 268.21,11.61 268.21,12.27 268.91,12.97 268.91,14.37 v7(269.05,14.51) ; v2(268.63,63.4) 269.97,64.74 D7.2 D8.2 270.4,66.77 D9.2 271.87,66.77 271.93,66.71 RA12.1 RA8.1 271.72,66.12 v7(271.48,65.88)
  IN1 w0.076: v7(271.48,65.88) 270.74,65.14 270.74,63.01 270.25,62.52 270.25,60.3 268.56,58.61 268.56,54 272.19,50.37 272.19,44.51 272.89,43.81 272.89,33.56 273.62,32.82 273.62,28.84 273.98,28.48 273.98,22.28 274.91,21.36 274.91,19.28 275.43,18.76 275.43,17.04 274.2,15.81 273.71,15.81 273.26,15.36 272.84,15.36 271.9,14.42 269.13,14.42 v7(269.05,14.51)
AMP_OUT_L+:
  vias: v2(277.42,10.73)
AMP_OUT_P_L-: length 4.6
  TOP w0.095: 280.35,12.69 v2(280.35,13.75)
  IN2 w1.016: 275.1,8.9 275.11,8.89 275.54,9.32 276.94,9.32 278.01,10.39
  vias: v1(279.02,11.87) v1(279.26,11.77) v3(271.62,8.85) v3(272.02,8.85) v3(278.66,11.45) v3(279.09,11.45) v4(270.13,8.78) v4(270.35,9)
AMP_OUT_P_L-_R: length 1.2
  BOTTOM w0.095: v2(269.44,9.98) 269.31,9.84 RA35.2
  vias: v1(267.75,7.62) v1(267.75,7.34) v3(267.28,7.67) v3(267.47,8.05) v4(267.88,8.72) v4(267.88,8.44)
AMP_OUT_P_R-: length 4.6
  TOP w0.095: RA45.1 v2(281.91,6.26)
  IN2 w1.016: 278.57,7.4 275.72,7.4 275.51,7.61
  vias: v1(279.89,7.84) v1(280.07,7.63) v3(270.39,4.97) v3(270.8,4.94) v3(279.53,7.73) v3(279.79,7.41) v4(269.8,4.99) v4(270.06,4.99)
AMP_OUT_P_R-_R:
  vias: v1(267.84,6.23) v1(267.84,5.97) v3(268.11,5.77) v4(268.14,5.42) v4(268.39,5.42)
AMP_OUT_R-:
  vias: v2(277.45,7.7)
AUD_PWR_EN: length 160.9
  TOP w0.095: U14.3 251.85,7.86 251.75,7.76 v1(251.32,7.76) 251.32,7.23 251.51,7.05 251.84,7.05 251.85,7.06 U14.5 ; v8(223.9,13.01) 223.1,12.21 218.52,12.21 217.98,11.67 v2(217.98,10.42) 218.13,10.27 218.13,8.79 218.4,8.52 219.33,8.52 R86.1 R89.1 220.98,9.06 221.03,9.12 U12.5
  IN1 w0.076: v9(139.58,40.75) 139.51,40.68 139.51,40.25 141.49,38.27 147.63,38.27 150.43,41.07 152.44,41.07 158.07,35.44 159.05,35.44 159.36,35.14 159.36,32.48 160.16,31.68 160.92,31.68 164.03,28.57 v8(165.4,28.57)
  GND1 w0.095: v1(251.32,7.76) 251.32,7.99 251.42,8.09 v3(251.42,8.12) ; v3(139.56,41.09) 139.56,40.76 v9(139.58,40.75)
  IN3 w0.064: v3(170.26,23.7) 170.26,24.14 165.86,28.55 165.42,28.55 v8(165.4,28.57)
  GND3 w0.095: v6(139.33,40.73) 139.47,40.87 139.47,40.99 v3(139.56,41.09) ; v6(170.59,23.67) 170.3,23.67 v3(170.26,23.7) ; v4(251.05,8.31) 251.19,8.31 251.38,8.12 v3(251.42,8.12)
  IN4 w0.076: v6(170.59,23.67) 171.6,23.67 181.75,13.51 182.81,13.51 184.26,12.07 185.64,12.07 187.9,9.8 193.92,9.8 194.19,10.07 199.76,10.07 200.99,11.31 203.14,11.87 205.41,11.87 207.19,13.65 208.35,13.65 210.75,16.05 214.51,16.05 v4(214.59,16.12) ; v5(134.91,45.22) 134.91,44.7 138.89,40.73 v6(139.33,40.73)
  BOTTOM w0.095: v4(214.59,16.12) 215.21,16.12 216.23,15.1 217.61,15.1 218.78,13.93 218.78,13.12 218.89,13.01 v8(223.9,13.01) 229.4,7.51 250.25,7.51 v4(251.05,8.31)
AUX_EN_WOWL: length 318.9
  TOP w0.095: UE3.D3 23.5,12.02 24.91,12.02 25.62,11.31 25.62,11.21 v7(25.68,11.14) ; v7(268.94,54.03) 269.02,54.11 269.02,55.48 267.86,56.64 D75.3 266.79,56.64 RE291.1
  IN1 w0.076: v7(25.68,11.14) 25.69,11.13 26.14,11.13 27.97,9.3 28.77,9.3 29.64,8.44 30.34,8.44 31.42,7.36 32.85,7.36 33.23,7.74 39.64,7.74 40.25,7.13 47.78,7.13 50.6,4.31 58.4,4.31 58.63,4.08 62.55,4.08 63.24,3.39 68.49,3.39 68.58,3.3 73.75,3.3 74.04,3.6 76.93,3.6 80.76,7.42 105.04,7.42 107.34,9.72 109.31,9.72 110.18,10.6 115.04,10.6 116.54,12.1 138.04,12.1 138.79,12.85 144.6,12.85 145.45,11.99 150.33,11.99 150.89,12.55 161.93,12.55 162.13,12.35 164.87,12.35 165.08,12.55 168.73,12.55 169.76,11.53 174.58,11.53 175.54,12.48 177.57,12.48 179.29,10.76 180.37,10.76 181.53,9.61 184.06,9.61 185.97,7.7 207.2,7.7 212.26,12.76 216.33,12.76 217.68,11.41 219.22,11.41 219.4,11.23 226.96,11.23 230.5,7.69 249.97,7.69 251.02,8.73 254.11,8.73 257.26,11.89 260.45,11.89 261.42,12.86 261.42,14.11 262.25,14.94 263.99,14.94 264.72,14.22 272.94,14.22 273.38,14.66 273.38,15.2 273.79,15.61 274.28,15.61 274.93,16.26 275.65,16.26 276.03,16.64 276.03,18.45 275.11,19.37 275.11,21.44 274.19,22.36 274.19,28.56 273.83,28.92 273.83,33.03 273.09,33.77 273.09,43.89 272.39,44.59 272.39,50.58 v7(268.94,54.03)
AUX_EN_WOWL_R: length 11.7
  TOP w0.095: v7(269.2,52.89) 268.86,52.89 268.33,53.42 RE290.2 268.22,53.54 268.22,54.3 268.4,54.48 D75.1 268.4,55.29 268.15,55.54 RE291.2 v2(265.63,55.54) ; v7(268.7,49.64) 268.69,49.63 R96.2
  TOP w0.119: U13.3 268.57,49.14 268.17,49.54 R96.2
  IN1 w0.076: v7(268.7,49.64) 269.33,50.27 269.33,52.76 v7(269.2,52.89)
B+: length 258.9
  TOP w0.305: v7(70.68,10.82) 70.68,10.66 70.22,10.2 PR323.1
  TOP w3.048: 168.43,6 168.21,6.22 168.21,12.59 167.58,13.22 167.58,23.97 169.75,26.14 169.75,34.09
  IN1 w0.305: v7(70.68,10.82) 70.68,10.96 71.15,11.43 71.99,11.43 73.91,13.34 75.33,13.34 76.99,15.01 v8(76.99,15.03)
  IN1 w0.508: 37.56,25.44 38.38,24.62 v8(38.38,23.58) 38.38,22.38 40.06,20.71 42.58,20.71 44.86,22.98 v8(46.52,22.98)
  IN1 w1.524: 218.32,2.04 183.63,2.04 182.59,3.08 169.64,3.08 169.2,2.64
  IN2 w0.762: 295.41,9.01 294.94,9.01 294.02,9.93 294.02,13.42 292.9,14.53 292.9,19.35 291.26,20.99 v8(291.26,25.07)
  IN3 w1.524: 157.68,2.06 132.18,2.06 ; 90.64,2.06 128.06,2.06
  IN4 w0.762: 281.21,39.35 281.21,36.42 ; 281.22,34.31 281.22,31.33 282.45,30.09 284.12,30.09 286.68,27.53 288.8,27.53 v8(291.26,25.07)
  BOTTOM w0.305: v8(76.99,15.03) 76.99,13.81 76.68,13.51 PR304.1
  BOTTOM w0.381: R116.1 31.61,28.58 32.08,28.11 32.08,26.25 31.8,25.97 v8(31.8,25.91)
  BOTTOM w0.508: PD301.2 57.19,6.11 57.19,2.09 57.92,1.36 71.97,1.36 72.18,1.57
  BOTTOM w1.524: 226.23,3.17 235.85,3.17 237.28,4.6 250.07,4.6 252,2.67 256.78,2.67
  vias: v3(223.24,1.63) v3(223.68,1.64) v3(224.11,1.64) v3(224.55,1.63) v3(266.98,1.59) v3(266.99,2.03) v3(267.39,2.03) v3(267.41,1.59) v4(223.44,2.03) v4(223.7,2.03) v4(223.96,2.02) v4(224.22,2.01) v4(224.48,2.01) v4(267.76,2.08) v4(267.75,1.78) v4(267.75,1.52) v4(268.05,2.08) v4(268.02,1.78) v4(268.01,1.52) v5(281.05,40.08) v5(281.21,40.35) v5(281.36,40.08) v5(281.28,35.39) v5(281.46,35.59) v5(281.46,35.16) v7(167.02,1.48) v7(167.29,1.48) v7(167.55,1.48) v7(167.8,1.48) v7(168.07,1.48) v7(168.34,1.48) v7(168.61,1.47) v7(168.88,1.47) v7(169.13,1.47) v7(169.39,1.47) v7(169.66,1.47) v7(169.93,1.47) v8(46.52,24.15) v8(46.52,23.57) v8(46.52,22.4) v8(47.11,24.15) v8(47.11,23.57) v8(47.11,22.98) v8(47.11,22.4) v8(47.69,24.15) v8(47.69,23.57) v8(47.69,22.98) v8(47.69,22.4) v8(48.7,22.73) v8(48.7,22.12) v8(48.72,21.48) v8(49.3,22.73) v8(49.29,22.14) v8(49.34,21.54) v8(49.3,20.94) v8(49.92,22.71) v8(49.91,22.12) v8(49.93,21.52) v8(49.93,20.93) v8(52.59,44.23) v8(52.64,43.55) v8(52.68,42.92) v8(52.7,42.25) v8(52.83,41.61) v8(53.2,43.87) v8(53.23,43.24) v8(53.23,42.58) v8(53.39,41.94) v8(53.39,41.33) v8(53.91,44.14) v8(54.49,44.14) v8(55.07,44.14) v8(55.02,43.46) v8(55.02,42.86) v8(55.01,42.24) v8(55.05,41.56) v8(55.07,40.92) v8(55.15,30.82) v8(55.13,30.2) v8(55.73,30.8) v8(55.72,30.18) v8(56.08,29.26) v8(56.1,28.62) v8(56.71,29.28) v8(56.69,28.63) v8(57.29,28.61) v8(57.55,29.19) v8(65.37,31.73) v8(65.36,31.12) v8(66.9,31.52) v8(67.02,32.11) v8(72.56,15.65) v8(72.56,15.07) v8(72.56,14.48) v8(72.56,13.9) v8(72.56,13.31) v8(73.14,16.23) v8(73.14,15.65) v8(73.14,15.07) v8(73.14,14.48) v8(73.14,13.9) v8(73.14,13.31) v8(73.1,9.81) v8(73.64,20.11) v8(73.73,16.23) v8(73.73,15.65) v8(73.69,9.81) v8(73.98,19.04) v8(73.98,17.98) v8(75.48,16.23) v8(75.48,15.65) v8(86.57,1.7) v8(87.17,1.54) v8(87.78,1.54) v8(88.38,1.54) v8(88.97,1.54) v8(89.57,1.55) v8(129.59,1.51) v8(130.2,1.51) v8(158.8,1.5) v8(159.45,1.51) v8(169.57,55.58) v8(169.62,56.19) v8(169.74,38.5) v8(169.74,37.87) v8(169.74,37.23) v8(170.27,56.15) v8(170.25,55.54) v8(170.32,38.5) v8(170.32,37.87) v8(170.32,37.23) v8(170.85,56.13) v8(170.86,55.52) v8(295.73,8.07) v8(295.74,7.48) v8(295.75,6.86) v8(295.75,6.25) v9(223.25,1.98) v9(223.54,1.98) v9(223.82,1.99) v9(224.1,1.98) v11(168.87,54.06)
B+_1.0V:
  vias: v2(131.71,3.82) v8(132.59,3.67) v8(133.2,3.66)
B+_3V:
  vias: v2(53.15,25.2) v8(53.39,27.11) v8(53.4,26.49) v8(53.44,25.88) v8(53.66,23.96) v8(53.67,23.22) v8(53.69,22.59) v8(54.05,27.14) v8(54.11,26.44) v8(54.09,25.81)
B+_5V:
  vias: v2(44.11,26.52) v8(42.88,25.26) v8(42.88,24.66) v8(43.5,25.74) v8(43.52,25.13) v8(43.63,24.49) v8(44.21,25.86) v8(44.21,25.23) v8(44.21,24.59)
B+_AMP: length 9.7
  TOP w0.203: U6.51 v1(276.43,9.45) ; CA42.1 272.81,4.55 272.74,4.63 U6.37 ; v1(276.44,8.26) 276.42,8.25 U6.48 ; v8(275.56,12.87) 275.42,13.01 275.02,13.01 274.74,12.73 U6.1 ; U6.56 275.99,11.45 276.54,11.99 v8(276.54,12.12)
  TOP w0.508: CA43.1 272.73,3.56 CA42.1
  GND1 w0.254: v1(276.43,9.45) 276.52,9.54 v3(276.52,10.24) ; v1(276.44,8.26) v3(276.08,8.26)
  GND1 w0.508: v3(271.55,2.83) 271.55,3.1 271.75,3.31 v1(271.75,3.38)
  GND3 w0.254: v4(276.15,8.65) 276.08,8.57 v3(276.08,8.26)
  GND3 w0.508: v3(271.55,2.83) 271.55,3.1 v4(271.8,3.35)
  vias: v2(273.93,3.36) v4(276.14,10.52) v4(276.22,9.62) v8(275.31,5.36) v8(275.92,5.35)
B+_CAM:
  vias: v2(280.38,29.7)
B+_CAM_EN: length 370.2
  TOP w0.095: RE261.1 10.73,8.99 v7(10.66,8.91) ; v1(154.52,44.48) 154.57,44.43 158.73,44.43 159.56,43.6 v2(159.56,41.28) 159.56,39.88 163.33,36.1 163.33,28.42 161.48,26.57 161.48,16.44 162.97,14.95 162.97,13.24 162.44,12.71 v7(162.2,12.71)
  IN1 w0.076: v9(219.31,11.69) 219.23,11.61 217.76,11.61 216.42,12.96 212.17,12.96 207.12,7.9 186.05,7.9 184.14,9.81 181.61,9.81 180.46,10.97 179.37,10.97 177.65,12.68 175.45,12.68 174.5,11.73 169.84,11.73 168.82,12.76 164.99,12.76 164.79,12.55 162.36,12.55 v7(162.2,12.71) 162.11,12.8 150.85,12.8 150.33,12.28 145.45,12.28 144.68,13.05 138.7,13.05 138.05,12.4 129.87,12.4 129.58,12.69 116.84,12.69 114.95,10.8 110.1,10.8 109.31,10.01 107.13,10.01 104.73,7.62 80.67,7.62 76.85,3.8 73.96,3.8 73.66,3.51 68.66,3.51 68.57,3.6 63.32,3.6 62.63,4.29 58.72,4.29 58.49,4.52 50.68,4.52 47.86,7.33 40.33,7.33 39.7,7.97 33.17,7.97 32.77,7.57 31.5,7.57 30.43,8.64 29.72,8.64 28.86,9.51 28.07,9.51 26.13,11.45 24.58,11.45 24.27,11.77 22.93,11.77 22.79,11.91 20.58,11.91 20.31,11.63 20.31,11.61 20.01,11.31 17.97,11.31 17.16,10.5 15.97,10.5 15.61,10.14 15.61,9.76 15.23,9.38 15.08,9.38 14.48,8.78 14.48,6.09 14.08,5.69 13.03,5.69 12.83,5.49 12.21,5.49 12,5.69 12,7.03 10.66,8.37 v7(10.66,8.91)
  GND1 w0.095: v3(219.5,12.22) 219.31,12.03 v9(219.31,11.69) ; v3(154.06,43.9) 154.52,44.36 v1(154.52,44.48)
  GND3 w0.095: v4(153.58,44.01) 153.7,43.9 v3(154.06,43.9) ; v6(219.88,12.22) v3(219.5,12.22)
  IN4 w0.076: v6(219.88,12.22) 223.07,12.22 226.26,9.03 249.41,9.03 250.13,9.75 252.77,9.75 258.72,15.69 260.1,15.69 260.97,14.82 263.09,14.82 264.31,16.03 268.59,16.03 269.51,15.12 272.74,15.12 275.43,17.8 275.43,24.2 276.19,24.96 276.19,31.5 273.69,34 273.69,34.94 273.97,35.22 274.87,35.22 276.49,33.6 278.07,33.6 278.41,33.94 278.41,36.77 v5(278.39,36.79)
  BOTTOM w0.095: U31.2 v5(278.39,36.79) ; RC389.2 150.78,49.79 153.3,47.26 153.3,44.29 v4(153.58,44.01)
B+_CAM_F:
  vias: v2(278.73,33.05)
BAT1_LED#: length 7.4
  TOP w0.095: UE3.D10 17.12,12.79 v8(17.07,12.79)
  IN4 w0.076: v8(17.07,12.79) 16.18,11.91 15.06,11.91 14.8,11.64 v5(14.8,11.28) 14.8,11 15.11,10.69 16.84,10.69 v5(17.17,10.36)
  BOTTOM w0.095: JKB1.9 17.18,10.35 v5(17.17,10.36)
BAT2_LED#: length 9.7
  IN1 w0.076: v7(16.7,12.41) 16.7,12.11 16.32,11.73 16.32,11.42 16,11.11 15.49,11.11 14.43,10.04 v1(13.65,10.04)
  GND1 w0.095: v1(13.65,10.04) 13.73,10.04 v3(14.06,10.37)
  GND3 w0.095: v3(14.06,10.37) 14.17,10.48 v6(14.71,10.48)
  IN4 w0.076: v5(17.68,10.33) 17.65,10.33 17.35,10.03 16.54,10.03 16.08,10.48 v6(14.71,10.48)
  BOTTOM w0.095: JKB1.8 v5(17.68,10.33)
BAT_LED#_LV1: length 3.4
  TOP w0.095: LED1.1 2.93,27 v2(4.35,27) 5.74,27 R71.2
BAT_LED#_LV2: length 3.4
  TOP w0.095: LED2.1 3,24.07 v2(3.81,24.07) R70.2
BAT_LED#_LV3: length 5.9
  TOP w0.095: LED3.1 3.7,20.1 v2(4.14,19.65) 4.65,19.15 4.65,17.34 R69.2
BAT_LED#_LV4: length 4.1
  TOP w0.095: R68.2 5.75,14.33 v2(4.2,15.88) 3.58,16.5 LED4.1
BAT_LED#_LV5: length 3.5
  TOP w0.095: LED5.1 2.88,13.15 v2(4.19,13.15) 4.73,13.15 5.31,12.57 R67.2
BATBTN#: length 58.4
  TOP w0.095: UE3.B5 21.5,10.62 21.86,10.27 21.86,9.74 v7(21.64,9.52) 21.64,9.22 21.63,9.21 21.63,8.26 21.54,8.17 RE137.1 ; v8(5.64,32.65) 5.91,32.38 7.48,32.38 C71.1 7,33.88 7,34.25 v11(6.79,34.46) 6.03,35.22 SW2.1 SW2.2
  IN1 w0.076: v9(4.62,18.57) 4.9,18.29 4.9,14.03 7.66,11.27 7.66,10.84 7.66,7.88 9.72,5.82 11.28,5.82 11.8,5.29 12.92,5.29 13.1,5.47 14.16,5.47 15.31,6.62 19.05,6.62 20.79,8.36 20.79,8.67 v7(21.64,9.52)
  GND1 w0.095: v9(4.62,18.57) 4.67,18.62 v3(4.67,18.9)
  IN2 w0.064: v8(5.64,32.65) 5.51,32.52 5.51,30.93 6.15,30.3 6.15,25.94 4.23,24.02 4.23,19.85 4.67,19.41 v3(4.67,18.9)
BATT_LED#_LV1: length 13.3
  TOP w0.095: v2(8.31,17.39) 8.31,16.86 Q4.3 v8(8.09,16.2) ; UE3.F12 v8(15.5,14.42)
  IN4 w0.076: v8(15.5,14.42) 14.89,15.03 13.47,15.03 12.8,15.69 12.8,16.18 11.33,17.65 9.88,17.65 8.44,16.2 v8(8.09,16.2)
  BOTTOM w0.095: RE287.1 7.91,16.02 v8(8.09,16.2)
BATT_LED#_LV2: length 17.4
  TOP w0.095: v8(17.87,15.23) 17.5,14.87 UE3.G10
  IN4 w0.076: v8(17.87,15.23) 17.48,15.63 17.48,16.63 17.49,16.65 17.49,16.97 17.48,16.98 17.48,19.02 15.05,21.45 12.97,21.45 v5(12.88,21.36)
  BOTTOM w0.095: v5(12.88,21.36) 12.88,20.79 v2(12.51,20.42) 12.38,20.29 11.18,20.29 10.93,20.54 9.66,20.54 8.96,19.83 8.96,18.16 RE286.1
BATT_LED#_LV3: length 17.2
  TOP w0.095: UE3.H12 15.54,15.25 14.4,15.25 v1(14.27,15.11)
  GND1 w0.095: v3(14.5,15.56) 14.27,15.33 v1(14.27,15.11)
  GND3 w0.095: v3(14.5,15.56) v6(14.5,16.18)
  IN4 w0.076: v5(9.45,22.76) 9.23,22.54 9.23,22.27 8.7,21.74 8.7,20.37 8.96,20.1 8.96,19.4 9.69,18.68 12.35,18.68 14.5,16.53 v6(14.5,16.18)
  BOTTOM w0.095: RE283.1 11.58,24.15 QH2.4 11.19,22.87 9.56,22.87 v5(9.45,22.76)
BATT_LED#_LV4: length 22.9
  TOP w0.095: v8(20.3,16.81) 20.3,16.78 19.93,16.42 UE3.J7
  IN3 w0.064: v8(11.05,23.58) 11.05,23.5 12.88,21.67 12.88,20.9 13.5,20.28 14.14,20.28 16.54,17.88 17.82,17.88 18.47,17.23 19.92,17.23 20.3,16.85 v8(20.3,16.81)
  BOTTOM w0.095: RE285.1 8.92,26.85 8.66,27.11 8.05,27.11 7.8,26.85 7.8,24.37 7.48,24.05 v2(7.48,23.47) 7.9,23.47 7.99,23.56 QH1.1 8.81,23.56 9.26,23.11 10.65,23.11 11.05,23.51 v8(11.05,23.58)
BATT_LED#_LV5: length 13.7
  GND1 w0.095: v1(15.1,18.82) 15.1,18.7 v3(14.9,18.5)
  GND3 w0.095: v3(14.9,18.5) 14.77,18.5 v6(14.52,18.75)
  IN4 w0.076: v5(10.39,24.86) 9.79,24.27 9.79,22.42 9.19,21.82 9.19,19.46 9.65,19 11.06,19 11.18,19.12 v5(13.73,19.12) 14.15,19.12 v6(14.52,18.75)
  BOTTOM w0.095: RE284.1 10.6,25.08 v5(10.39,24.86)
BATT_PRS#: length 4.2
  TOP w0.095: PR157.1 100.46,13.9 v1(100.56,13.8) 101.08,13.28 101.08,13.04 101.83,12.29 v2(102.16,12.29)
  GND1 w0.095: v1(100.56,13.8) 101.45,13.8 v3(101.68,13.58)
  GND3 w0.095: v3(101.68,13.58) 101.68,13.66 v4(101.96,13.94)
BC_CLK_ECE1117: length 12.7
  TOP w0.095: v8(15.53,12.82) 15.51,12.82 UE3.D13 14.87,12.18 v2(13.65,12.18)
  IN4 w0.076: v5(18.18,9.87) 18.06,9.87 17.75,9.57 16.06,9.57 15.6,10.03 14,10.03 13.33,10.69 13.33,12.12 13.52,12.31 15.79,12.31 15.87,12.39 15.87,12.74 15.79,12.82 v8(15.53,12.82)
  BOTTOM w0.095: JKB1.7 v5(18.18,9.87)
BC_DAT_ECE1117: length 13.2
  TOP w0.095: v1(12.43,9.86) RE130.1 12.46,9.86 12.9,10.3 12.9,11.05 13.7,11.85 14.43,11.85 14.53,11.96 15.18,11.96 15.64,12.41 UE3.D12
  GND1 w0.095: v1(12.43,9.86) v3(12.85,9.86)
  GND3 w0.095: v6(12.33,9.37) 12.83,9.86 v3(12.85,9.86)
  IN4 w0.076: v5(18.68,9.28) 18.6,9.36 15.55,9.36 15.2,9.71 13.58,9.71 13.24,9.37 v6(12.33,9.37) 12.07,9.37 v5(11.97,9.27)
BC_INT#_ECE1117: length 8.5
  TOP w0.095: v8(24.3,13.66) 24.3,13.61 UE3.E2
  BOTTOM w0.095: JKB1.5 19.18,10.34 19.47,10.64 21.07,10.64 21.22,10.79 v2(21.5,10.79) 22.05,10.79 22.26,11 22.26,11.44 22.26,11.45 22.26,11.95 23.43,13.11 23.43,13.22 23.87,13.66 v8(24.3,13.66)
BEEP: length 338.8
  TOP w0.095: v7(179.87,13.31) 179.87,13.11 180.03,12.96 v2(180.03,11.89) v7(180.03,10.46) ; UE3.L9 v7(17.95,18.37)
  IN1 w0.076: v7(17.95,18.37) 18.39,18.82 22.81,18.82 22.97,18.66 26.28,18.66 27.87,17.07 27.87,16.88 28.25,16.49 29.09,16.49 30.38,15.2 30.38,14.6 30.54,14.44 30.54,13.06 31,12.6 31.29,12.6 31.87,12.02 34.91,12.02 35.47,11.46 47.97,11.46 52.41,7.03 60.28,7.03 60.86,6.44 65.79,6.44 66.19,6.04 70.32,6.04 70.81,5.55 72.83,5.55 73.11,5.83 75.96,5.83 80.34,10.21 104.04,10.21 105.94,12.11 108.52,12.11 109.4,12.99 114.39,12.99 116.54,15.14 126.2,15.14 126.69,14.65 131.85,14.65 132.36,14.14 137.45,14.14 138,14.69 144.19,14.69 145.5,16.01 146.77,16.01 147.07,15.7 152.86,15.7 153.25,16.1 156.18,16.1 156.39,16.31 156.39,16.31 156.57,16.49 161.48,16.49 161.71,16.71 173.41,16.71 173.7,17 176.47,17 179.87,13.59 v7(179.87,13.31) ; v7(275.71,62.54) 274.64,62.54 270.13,58.04 270.13,55.34 273.92,51.56 273.92,46.27 274.7,45.49 274.7,35.79 275.98,34.5 275.98,30.29 276.37,29.9 276.37,24.67 276.56,24.48 276.56,18.97 276.23,18.64 276.23,16.19 275.45,15.4 273.88,15.4 273.59,15.11 273.59,14.45 273.15,14.01 264.63,14.01 263.91,14.74 262.34,14.74 261.65,14.05 261.65,12.81 260.53,11.68 257.35,11.68 254.2,8.53 251.11,8.53 250.06,7.48 230.42,7.48 226.87,11.03 219.32,11.03 219.13,11.21 217.59,11.21 216.25,12.55 212.34,12.55 207.29,7.5 185.88,7.5 183.97,9.4 181.09,9.4 v7(180.03,10.46)
BIA_PWM_EC: length 92
  TOP w0.095: UE3.N1 24.7,19.79 v1(24.93,20.02)
  GND1 w0.095: v1(24.93,20.02) 24.55,20.02 v3(24.42,19.9)
  GND3 w0.095: v4(24.64,19.56) 24.64,19.68 v3(24.42,19.9)
  IN4 w0.076: v5(33.92,63.35) 32.92,62.35 32.92,61.2 32.31,60.59 32.31,60.04 32.53,59.82 32.53,59.06 32.78,58.81 32.78,56.7 33.86,55.62 33.86,54.96 35.42,53.4 36.14,53.4 36.31,53.22 36.31,52.59 36.65,52.25 36.65,47.59 36.3,47.24 36.3,39.4 36.49,39.21 36.49,34.19 37.14,33.55 37.14,31.03 37.82,30.35 37.82,27.35 35.88,25.41 35.88,23.66 36.4,23.14 36.4,22.02 36.21,21.83 36.21,21.12 v5(36.13,21.03)
  BOTTOM w0.095: v5(36.13,21.03) 35.96,20.86 35.96,19.9 34.95,18.89 33.39,18.89 32.74,19.54 31.53,19.54 31.06,20.01 26.95,20.01 26.86,19.92 26.86,19.67 26.58,19.39 25.64,19.39 25.47,19.56 v4(24.64,19.56) ; D6.3 58.52,67.18 58.18,67.51 58.18,68.22 57.7,68.7 v2(54.32,68.7) 51.74,66.12 51.74,64.44 50.65,63.35 v5(33.92,63.35)
BID_BC: length 6.9
  BOTTOM w0.076: RH84.1 141.23,60.05 140.73,60.05 RH85.2 139.73,59.71 139.41,59.39 138.47,59.39 138.03,58.95 138.03,58.75 137.67,58.4 137.03,58.4 136.87,58.24 136.87,57.86 136.42,57.41 UCPU1.U3
BL_PWMO: length 339.3
  TOP w0.095: v1(111.91,15.92) 112.28,15.54 v2(112.28,14.22) 112.28,8.03 111.97,7.72 v7(111.94,7.72)
  IN1 w0.076: v7(111.94,7.72) 112.22,7.72 113.07,8.57 115.88,8.57 118.1,10.79 129.51,10.79 130.02,11.29 138.38,11.29 139.12,12.03 144.21,12.03 145.14,11.1 152.08,11.1 152.56,10.62 152.56,8.69 153.14,8.11 158.02,8.11 158.44,8.53 158.44,10.84 159.12,11.53 160.68,11.53 161.66,10.54 164.44,10.54 165.12,9.86 167.99,9.86 169.46,8.39 183.55,8.39 185.46,6.48 208.76,6.48 213.12,10.83 215.44,10.83 218.02,8.25 224.45,8.25 226.35,6.35 226.35,6.01 227.61,4.75 252.54,4.75 253.22,5.43 255.02,5.43 255.76,6.18 256.34,6.18 257.57,7.41 257.57,8.15 258.57,9.16 260.72,9.16 264.56,13 273.57,13 274.93,14.36 275.85,14.36 277.25,15.77 277.25,18.21 279.06,20.02 279.06,23.68 279.52,24.14 v9(279.57,24.14)
  GND1 w0.095: v9(279.57,24.14) 279.58,24.14 v3(280.15,24.14) ; v3(112.1,16.2) 111.91,16 v1(111.91,15.92)
  GND3 w0.095: v4(278.93,24.44) 279.86,24.44 v3(280.15,24.14) ; v6(112.4,16.02) 112.29,16.02 v3(112.1,16.2)
  IN4 w0.076: v6(112.4,16.02) 111.95,16.02 111.2,15.27 84.21,15.27 82.97,15.27 81.82,14.13 81.37,14.13 80.58,14.13 79.17,12.72 78.24,12.72 77.31,11.79 74.23,11.79 72.55,10.12 70.72,10.12 70.21,9.61 67.92,9.61 67.24,10.29 62.57,10.29 62.51,10.36 62.5,10.36 60.82,12.04 53.13,12.04 52.36,12.8 48.5,12.8 47.7,13.61 39.54,13.61 37.25,15.9 37.25,19.92 37.42,20.09 37.42,23.56 36.91,24.07 36.91,24.99 37.25,25.33 38.51,25.33 39.33,26.15 39.33,32.25 38.35,33.23 38.35,38.68 37.11,39.91 37.11,46.88 37.59,47.37 37.59,47.72 37.96,48.09 37.96,51.06 39.5,52.6 39.64,52.6 43,55.96 43,56.49 43.34,56.84 43.34,58.79 44.93,60.38 v5(45.85,60.38)
  BOTTOM w0.095: JEDP1.9 47.08,60.7 46.98,60.6 46.07,60.6 v5(45.85,60.38)
BOARD_ID: length 3.7
  TOP w0.095: UE3.J13 14.96,16.55 12.97,16.55 CE75.1 RE194.2
BOT_MUX_N: length 38.4
  TOP w0.102: v1(284.28,46.92) ML7.4
  GND1 w0.102: v1(284.28,46.92) 284.62,46.92 v3(284.65,46.89)
  IN3 w0.089: v3(284.65,46.89) 284.3,46.89 284.18,47.01 284.18,47.21 284.32,47.35 285.29,47.35 285.57,47.06 285.57,43.11 292.68,36.01 292.68,34.37 293.61,33.44 293.61,30.64 289.21,26.25 289.21,23.08 289.72,22.57 289.72,19.91 289.33,19.51 289.02,19.51 v3(288.83,19.7)
  GND3 w0.102: v3(288.83,19.7) 288.75,19.61 v4(288.33,19.61)
  BOTTOM w0.076: U21.L7 287.92,18.93 287.92,19.2 288.33,19.61 v4(288.33,19.61)
BOT_MUX_N_R: length 6.8
  TOP w0.102: v1(287.26,47.02) 287.19,47.1 286.59,47.1 286.42,46.92 ML7.3
  GND1 w0.102: v1(287.26,47.02) 287.39,47.15 v3(287.6,47.15)
  IN2 w0.089: v3(287.6,47.15) 287.66,47.21 288.19,47.21 288.49,47.52 288.49,49.16 289.46,50.12 290.3,50.12 JUSBC3.B7
BOT_MUX_P: length 38.4
  TOP w0.102: v1(284.28,47.42) ML7.1
  GND1 w0.102: v1(284.28,47.42) 284.32,47.42 v3(284.65,47.75)
  IN3 w0.089: v3(284.65,47.75) 284.7,47.7 285.44,47.7 285.93,47.21 285.93,43.26 293.03,36.16 293.03,34.51 293.96,33.59 293.96,30.5 289.57,26.1 289.57,23.23 290.08,22.72 290.08,19.74 289.5,19.16 288.85,19.16 v3(288.84,19.15)
  GND3 w0.102: v4(288.35,19.19) 288.37,19.22 288.77,19.22 v3(288.84,19.15)
  BOTTOM w0.076: U21.K7 288.27,18.57 288.27,19.12 v4(288.35,19.19)
BOT_MUX_P_R: length 6.9
  TOP w0.102: v1(287.26,47.66) 286.93,47.33 286.62,47.33 286.52,47.42 ML7.2
  GND1 w0.102: v3(287.63,47.7) 287.59,47.66 v1(287.26,47.66)
  IN2 w0.089: v3(287.63,47.7) 287.76,47.57 288.04,47.57 288.14,47.67 288.14,49.3 289.31,50.47 290.28,50.47 JUSBC3.B6
BREATH_LED#: length 333.2
  TOP w0.095: v7(57.88,3.18) 57.82,3.18 v2(56.03,4.98) 55.41,5.59 50.91,5.59 v7(50.79,5.71)
  IN1 w0.076: v7(16.7,11.61) 17.27,12.19 18.45,12.19 18.58,12.05 18.84,12.05 19.18,12.39 21.07,12.39 21.45,12.77 21.45,13.04 21.66,13.24 22.5,13.24 22.66,13.08 23.17,13.08 24.03,12.21 24.4,12.21 24.71,11.9 26.3,11.9 28.15,10.05 28.89,10.05 29.89,9.05 30.6,9.05 31.66,7.99 32.61,7.99 33,8.38 39.87,8.38 40.5,7.74 48.03,7.74 50.06,5.71 v7(50.79,5.71) ; v7(57.88,3.18) 57.99,3.07 62.13,3.07 62.82,2.38 68.07,2.38 68.16,2.29 74.17,2.29 74.46,2.58 77.38,2.58 81.17,6.37 112.46,6.37 113.25,7.17 115.32,7.17 115.79,7.63 116.09,7.63 118.43,9.97 123.14,9.97 123.27,9.97 138.21,9.97 138.85,10.61 144.49,10.61 144.88,10.22 149.57,10.22 153.04,6.75 155.06,6.75 155.61,7.3 158.96,7.3 161.13,9.47 163.93,9.47 164.94,8.47 167.66,8.47 168.95,7.17 183.05,7.17 184.96,5.26 216.71,5.26 218.44,6.99 221.6,6.99 223.33,5.26 225.37,5.26 227.12,3.51 254.82,3.51 256.22,4.9 256.79,4.9 259.36,7.47 260.53,7.47 265.04,11.98 273.99,11.98 275.36,13.34 278.08,13.34 280.1,15.36 280.1,16.83 279.27,17.65 279.27,18.74 280.08,19.55 280.08,22 280.61,22.53 280.61,27.33 280.04,27.89 280.04,33.1 279.84,33.31 279.84,40.57 280,40.73 280,42.39 278.99,43.4 278.99,49.87 280.84,51.72 285.08,51.72 285.44,52.07 285.44,55.17 285.78,55.51 v8(287.03,55.51)
  BOTTOM w0.095: RE275.1 v8(287.03,55.51)
BST_1.0V: length 1.3
  BOTTOM w0.095: PR701.1 135.3,2.41 v2(134.76,1.87)
BST_1.0V_R: length 1.8
  BOTTOM w0.095: PR701.2 v2(136.71,1.43)
  BOTTOM w0.254: PR701.2 136.87,2.25 PC703.1
BST_3V: length 1.6
  BOTTOM w0.095: v2(54.76,26.85) 54.76,27.17 53.95,27.98 PR500.1
BST_5V: length 0.8
  TOP w0.095: v2(42.48,25.99) 42.14,26.33 v8(42.14,26.63)
  vias: v8(42.73,26.67)
BT_RADIO_DIS#: length 311.9
  TOP w0.095: RE133.1 26.96,6.86 26.34,7.48 v7(26.34,8.85) ; UE3.C2 24.2,11.32 v7(24.2,11.13)
  IN1 w0.076: v9(278.51,36.62) 278.57,36.56 278.57,32.46 279.23,31.8 279.23,27.99 279.12,27.88 279.12,25.35 278.43,24.66 278.43,20.26 276.64,18.47 276.64,16.02 275.59,14.97 274.68,14.97 273.32,13.61 264.4,13.61 263.68,14.33 262.51,14.33 262.06,13.88 262.06,12.62 260.11,10.67 256.92,10.67 254.37,8.12 251.27,8.12 250.23,7.08 230.25,7.08 226.7,10.62 220.18,10.62 219.75,10.19 218.03,10.19 216.08,12.15 212.51,12.15 207.46,7.09 185.71,7.09 183.81,9 169.71,9 168.24,10.47 165.37,10.47 164.7,11.15 161.91,11.15 160.92,12.15 151.87,12.15 151.48,11.76 145.4,11.76 144.51,12.64 138.87,12.64 138.13,11.9 116.79,11.9 114.91,10.03 110.23,10.03 109.5,9.29 107.2,9.29 105.12,7.22 80.84,7.22 77.02,3.39 74.12,3.39 73.83,3.1 68.49,3.1 68.41,3.19 63.15,3.19 62.46,3.88 58.55,3.88 58.34,4.09 50.54,4.09 47.7,6.93 38.22,6.93 37.61,7.54 33.31,7.54 32.89,7.12 31.38,7.12 30.26,8.24 27.75,8.24 27.09,8.9 26.39,8.9 v7(26.34,8.85) 26.34,9.3 26.61,9.57 26.61,10.06 26.09,10.58 24.75,10.58 v7(24.2,11.13)
  GND1 w0.095: v3(278.4,37.05) 278.51,36.94 v9(278.51,36.62)
  IN3 w0.064: v3(278.4,37.05) 279.41,38.07 281.99,38.07 v3(282.34,38.41)
  GND3 w0.095: v3(282.34,38.41) 282.44,38.31 v4(282.44,38.03)
  BOTTOM w0.095: v4(282.44,38.03) 282.51,37.95 284.44,37.95 v2(284.75,38.26) 285.26,38.77 289.22,38.77 289.54,39.09 DZ3.1
BT_RADIO_DIS#_R: length 12.4
  IN4 w0.076: v5(276.27,42.22) 276.82,41.67 278.58,41.67 278.97,42.06 279.66,42.06 280.04,41.68 281.81,41.68 282.72,40.77 v4(283.26,40.77) 285.79,40.77 v5(286.46,40.1)
  BOTTOM w0.095: v5(286.46,40.1) 286.96,40.1 DZ3.2
CAD_SNK: length 5.7
  TOP w0.095: 274.16,30.36 RC394.2 ; 274.16,30.36 274.17,30.37 R49.1 ; 274.16,30.36 273.93,30.13 R5812.1 273.8,28.99 v2(273.8,27.36) 273.19,26.75 272.84,26.75 272.71,26.63 U30.29
CAM_CBL_DET#: length 230.2
  TOP w0.095: v7(156,47.83) 155.56,47.83 154.07,49.32 154.07,50.59 v2(153.5,51.15) 149.96,54.69 147.61,54.69 147.21,55.1 144.91,55.1 144.12,54.31 144.12,53.84 143.2,52.92 141.57,52.92 RC114.1 140.66,52.41 140.36,52.7 140.36,53.69 140.67,54 140.67,55.5 139.32,56.85 137.58,56.85 137.11,56.38 135.25,56.38 134.04,55.18 131.85,55.18 v8(131.4,55.62)
  IN1 w0.076: v9(160.56,11.23) 161.45,10.34 164.36,10.34 165.04,9.66 167.9,9.66 169.37,8.19 183.47,8.19 185.38,6.28 208.92,6.28 213.26,10.61 215.22,10.61 217.81,8.02 224.36,8.02 226.15,6.24 226.15,5.92 227.54,4.53 252.67,4.53 253.35,5.21 255.08,5.21 255.85,5.97 256.42,5.97 257.77,7.32 257.77,8.07 258.66,8.96 260.8,8.96 264.64,12.79 273.66,12.79 275.02,14.16 275.93,14.16 277.45,15.68 277.45,18.12 279.27,19.94 279.27,23.38 v9(279.57,23.68) ; v7(156,47.83) 156.54,47.83 161.51,42.86 161.51,39.71 164.47,36.74 v9(164.77,36.74)
  GND1 w0.095: v3(165.36,36.56) 165.1,36.56 164.92,36.74 v9(164.77,36.74) ; v3(280.14,23.56) 280.02,23.68 v9(279.57,23.68) ; v3(160.41,11.56) 160.56,11.41 v9(160.56,11.23)
  GND3 w0.095: v6(165.71,36.36) 165.51,36.56 v3(165.36,36.56) ; v3(280.14,23.56) 280.17,23.59 v4(281.21,23.59) ; v6(160.42,12.15) 160.41,12.13 v3(160.41,11.56)
  IN4 w0.076: v6(165.71,36.36) 166.19,36.36 167.51,35.05 167.51,32.1 165.97,30.56 165.97,27.17 166.41,26.73 168.2,26.73 169.83,25.1 169.83,23.44 171.32,21.95 171.32,19.18 169.37,17.23 167.96,17.23 164.44,13.71 162.17,13.71 160.61,12.15 v6(160.42,12.15)
  BOTTOM w0.095: JCAM1.12 280.2,22.94 280.85,23.59 v4(281.21,23.59)
  BOTTOM w0.112: v8(131.4,55.62) 131.58,55.44 UCPU1.AB11
CEXT: length 3.1
  TOP w0.095: U30.1 267.05,25.68 266.78,25.95 266.78,26.23 C70.2 R5808.2
CFG0: length 12.9
  BOTTOM w0.076: UCPU1.E68 99.35,64.47 99.63,64.75 99.63,65.01 99.78,65.46 99.78,65.64 99.72,65.83 99.72,65.96 99.78,66.07 99.78,66.5 99.51,66.77 99.51,67.07 99.07,67.51 97.3,67.51 96.03,68.77 95.59,68.77 94.73,69.63 94.73,70.23 ; T80.1 94.73,71.59 95.29,72.15
  BOTTOM w0.095: 95.29,72.15 96,72.86 RC120.2
  BOTTOM w0.305: 94.73,70.23 T80.1
CFG0_1: length 1
  TOP w0.305: RC256.1 55.86,73.97 56.12,74.24 T112.1
CFG1: length 10.6
  TOP w0.095: v8(95.17,67.94) 95.21,67.94 95.8,68.52 95.8,68.97 95.61,69.16 94.38,69.16 93.96,68.74 RC121.2 92.97,68.74 v2(92.75,68.96)
  BOTTOM w0.076: v8(95.17,67.94) 95.17,68.22 95.26,68.31 96.03,68.31 97.16,67.18 98.11,67.18 98.72,66.57 98.75,66.57 99.04,66.28 99.04,66.06 99.35,65.75 UCPU1.B67
CFG1_1: length 5.9
  TOP w0.095: JXDP1.11 50.08,74.15 50.65,74.72 54.21,74.72
  TOP w0.305: T111.1 54.41,74.52 54.21,74.72
CFG2: length 8.6
  BOTTOM w0.076: 95.79,69.25 95.86,69.25 97.4,67.71 99.58,67.71 100.37,66.92 100.37,66.71 100.28,66.61 100.28,65.99 100.37,65.9 100.37,64.85 100.7,64.52 UCPU1.D65
  BOTTOM w0.305: 95.79,69.25 T78.1
CFG2_1: length 7.5
  TOP w0.095: JXDP1.15 48.88,71.97 48.99,71.86 53.33,71.86 53.75,71.44 54.42,71.44
  TOP w0.305: 54.42,71.44 T113.1
CFG3: length 9.6
  TOP w0.095: v2(96.01,70.5) 95.44,69.93 v1(95.09,69.93)
  GND1 w0.095: v1(95.09,69.93) 95.09,69.2 v3(95.29,69)
  GND3 w0.095: v3(95.29,69) 95.29,68.66 v4(95.29,68.66)
  BOTTOM w0.076: UCPU1.D67 99.35,65.06 99.54,65.25 99.61,65.48 99.61,65.61 99.56,65.81 99.56,66 99.61,66.11 99.61,66.42 99.32,66.72 99.32,67.03 99,67.34 97.23,67.34 96.1,68.48 95.47,68.48 v4(95.29,68.66)
CFG3_1: length 9.9
  TOP w0.095: 54.99,70.85 54.94,70.9 53.97,70.9 53.24,71.64 48.63,71.64 48.28,71.99 JXDP1.17
  TOP w0.305: T114.1 55.65,70.85 54.99,70.85
CFG4: length 6.7
  TOP w0.095: T81.1 RC123.2 94.88,66.63 v1(94.92,66.59)
  GND1 w0.095: v1(94.92,66.59) 94.93,66.58 v3(95.32,66.58)
  GND3 w0.095: v4(95.65,66.58) v3(95.32,66.58)
  BOTTOM w0.076: v4(95.65,66.58) 96.07,66.58 96.3,66.35 96.3,64.7 96.87,64.13 97.08,64.13 97.29,63.92 UCPU1.E70
CFG4_1: length 13.3
  TOP w0.095: 55.01,68.93 53.01,70.93 45.99,70.93 45.28,71.63 JXDP1.27
  TOP w0.305: 55.01,68.93 T117.1
CFG5: length 8.1
  BOTTOM w0.076: UCPU1.C68 98.63,64.63 99.1,65.11 99.1,65.4 98.42,66.09 98.42,66.27 97.94,66.74 96.84,66.74 96.21,67.38 94.84,67.38 94.53,67.06 93.55,67.06 93.36,66.87
  BOTTOM w0.305: 93.36,66.87 T79.1
CFG5_1: length 13.6
  TOP w0.095: 53.71,68.28 53.71,69.91 52.92,70.7 45.37,70.7 44.68,71.39 JXDP1.29
  TOP w0.305: 53.71,68.28 T118.1
CFG6: length 7
  BOTTOM w0.076: 93.52,66.16 94.09,66.16 94.97,67.04 96.08,67.04 96.63,66.49 96.63,65.63 96.85,65.41 97.09,65.41 97.2,65.3 97.76,65.3 97.98,65.08 UCPU1.D68
  BOTTOM w0.305: 93.52,66.16 T82.1
CFG6_1: length 16.7
  TOP w0.095: 31.49,70.63 31.78,70.91 31.78,73.4 32.93,74.55 43.25,74.55 43.48,74.32 JXDP1.33
  TOP w0.305: T120.1 31.37,70.63 31.49,70.63
CFG7: length 6.2
  BOTTOM w0.076: UCPU1.C67 98.76,65.5 98.34,65.92 97.9,65.92 97.75,66.08 97.75,66.3 97.53,66.53 96.83,66.53 96.15,67.2 94.9,67.2 94.39,66.69 94.02,66.69
  BOTTOM w0.305: 94.02,66.69 T83.1
CFG7_1: length 15.1
  TOP w0.095: 32.51,70.87 32.51,73.82 33.02,74.33 42.78,74.33 42.88,74.23 JXDP1.35
  TOP w0.305: 32.51,70.87 32.39,70.75 T119.1
CFG8: length 4.8
  BOTTOM w0.076: 93.59,65.06 93.73,64.92 95.11,64.92 96.71,63.31 97.11,63.31 97.13,63.29 UCPU1.F71
  BOTTOM w0.305: T84.1 93.44,65.21 93.59,65.06
CFG8_1: length 3.1
  TOP w0.095: JXDP1.10 50.38,68.6
  TOP w0.305: 50.38,68.6 50.38,68.19 T102.1
CFG9: length 6.1
  BOTTOM w0.076: 93.09,64.27 93.2,64.16 93.65,64.16 93.78,64.03 95.02,64.03 96.63,62.41 97.07,62.41 97.16,62.45 97.33,62.45 97.44,62.41 97.73,62.41 97.8,62.44 98.11,62.44 UCPU1.G69
  BOTTOM w0.095: 93.09,64.27 93,64.36
CFG9_1: length 2.8
  TOP w0.095: JXDP1.12 49.78,68.59
  TOP w0.305: 49.78,68.59 49.78,67.43 T101.1
CFG10: length 5.9
  BOTTOM w0.076: UCPU1.F70 97.98,63.23 97.79,63.04 97.21,63.04 97.02,63.13 96.66,63.13 95.04,64.75 93.28,64.75 93.16,64.88 93.09,64.88
  BOTTOM w0.095: 93.09,64.88 92.97,64.88 92.94,64.9
CFG10_1: length 2.7
  TOP w0.095: JXDP1.16 48.58,68.41
  TOP w0.305: 48.58,68.41 48.66,68.34 T122.1
CFG11: length 6.1
  BOTTOM w0.076: 94.39,65.21 95.05,65.21 96.74,63.52 97.12,63.52 97.15,63.55 97.47,63.55 97.66,63.48 98.19,63.48 98.34,63.33 98.34,63.11 UCPU1.G68
  BOTTOM w0.305: 94.39,65.21 T87.1
CFG11_1: length 2.7
  TOP w0.095: JXDP1.18 47.98,68.4
  TOP w0.305: T121.1 47.35,67.76 47.98,68.4
CFG12: length 62.2
  IN1 w0.076: v9(91.41,66.36) 91.41,68.64 89.7,70.34 87.39,70.34 85.3,68.25 78.82,68.25 77.17,69.91 71.82,69.91 71.19,69.28 55.16,69.28 54.9,69.02 52.1,69.02 51.52,68.44 46.94,68.44 45.82,69.56 45.48,69.56 v7(44.98,70.06)
  GND1 w0.095: v9(91.41,66.36) 91.58,66.19 v3(91.58,66.03)
  GND3 w0.095: v3(91.58,66.03) 91.97,65.63 v4(92.24,65.63)
  BOTTOM w0.076: 93.09,63.77 93.54,63.77 93.61,63.7 94.78,63.7 95.89,62.59 95.89,62.02 96.26,61.65 97.41,61.65 97.76,62 UCPU1.H70
  BOTTOM w0.095: v4(92.24,65.63) 92.11,65.51 v2(92.11,64.42) 92.11,64.3 92.64,63.77 93.09,63.77
CFG13: length 4.3
  BOTTOM w0.076: UCPU1.G71 96.87,62.67 96.75,62.79 96.5,62.79 95.81,63.47 95.81,63.51 95.13,64.19 93.85,64.19 93.57,64.47 93.5,64.47
  BOTTOM w0.305: 93.5,64.47 T88.1
CFG13_1: length 1.7
  TOP w0.095: JXDP1.30 44.38,68.84
  TOP w0.305: 44.38,68.84 T103.1
CFG14: length 64.8
  TOP w0.095: JXDP1.34 43.18,70.59 43.29,70.7 44.06,70.7 v7(44.1,70.66)
  IN1 w0.076: v9(91.76,66.68) 91.61,66.82 91.61,68.72 89.79,70.55 87.3,70.55 85.21,68.45 78.91,68.45 77.25,70.11 71.73,70.11 71.11,69.48 55.08,69.48 54.82,69.22 52.01,69.22 51.43,68.64 47.02,68.64 45,70.66 v7(44.1,70.66)
  GND1 w0.095: v9(91.76,66.68) 92.03,66.4 v3(92.03,66.39)
  GND3 w0.095: v4(92.53,65.94) 92.42,65.94 92.03,66.34 v3(92.03,66.39)
  BOTTOM w0.076: UCPU1.H69 98.29,62.27 97.83,62.27 97.67,62.22 97.52,62.22 97.31,62.28 97.21,62.28 97.09,62.23 96.55,62.23 94.92,63.86 93.68,63.86 93.55,63.99 93.09,63.99
  BOTTOM w0.095: 93.09,63.99 92.73,63.99 92.46,64.26 92.46,65.43 92.57,65.54 92.57,65.9 v4(92.53,65.94)
CFG15: length 4.3
  BOTTOM w0.076: 94.39,64.47 95.08,64.47 96.02,63.53 96.02,63.52 96.59,62.95 96.99,62.95 97.32,62.79 97.45,62.67 UCPU1.G70
  BOTTOM w0.305: 94.39,64.47 T89.1
CFG15_1: length 1.5
  TOP w0.095: JXDP1.36 42.58,69.01
  TOP w0.305: 42.58,69.01 42.65,68.94 T104.1
CFG16: length 59
  TOP w0.095: v2(51.16,68.64) 51.58,69.06 v7(51.58,70.06)
  IN1 w0.076: v9(98.58,66.68) 98.51,66.75 98.08,66.75 97.95,66.88 93.86,66.88 92.45,68.29 92.45,69.05 90.13,71.36 86.96,71.36 84.87,69.27 79.25,69.27 77.58,70.93 71.4,70.93 70.77,70.3 55.17,70.3 54.96,70.51 52.04,70.51 v7(51.58,70.06)
  GND1 w0.095: v9(98.58,66.68) 98.58,65.56 100.39,63.75 v3(100.39,63.47)
  GND3 w0.095: v4(101,63.98) 100.9,63.98 v3(100.39,63.47)
  BOTTOM w0.112: v4(101,63.98) 101.52,63.98 UCPU1.E63
CFG17: length 58.6
  TOP w0.095: v7(52.18,70.06) 52.18,69.54 52.55,69.17 v2(52.55,68.59)
  IN1 w0.076: v7(52.18,70.06) 52.18,70.09 52.4,70.31 54.87,70.31 55.09,70.09 70.85,70.09 71.49,70.73 77.5,70.73 79.16,69.06 84.96,69.06 87.05,71.15 90.05,71.15 92.24,68.96 92.24,68.21 93.77,66.68 94.19,66.68 94.65,66.22 96.42,66.22 96.69,66.49 98.21,66.49 v9(98.24,66.45)
  GND1 w0.095: v3(99.99,63.09) 99.83,63.25 99.83,63.99 98.35,65.47 98.35,66.34 v9(98.24,66.45)
  GND3 w0.095: v3(99.99,63.09) 101.02,63.09 v4(101.17,63.24)
  BOTTOM w0.112: UCPU1.F63 101.61,63.24 v4(101.17,63.24)
CFG18: length 62.3
  TOP w0.095: v7(46.18,70.06) 46.18,68.95 45.73,68.5 v2(45.38,68.5)
  IN1 w0.076: v7(46.18,70.06) 49.62,70.06 50.05,69.63 54.65,69.63 54.91,69.89 70.94,69.89 71.57,70.53 77.41,70.53 79.08,68.86 85.04,68.86 87.13,70.95 89.96,70.95 92.02,68.89 92.02,68.09 94.11,66 96.58,66 96.79,66.21 97.83,66.21 97.9,66.14 v9(97.9,66.1)
  GND1 w0.095: v3(99.24,63.73) 99.24,64.23 98.13,65.35 98.13,65.88 v9(97.9,66.1)
  GND3 w0.095: v4(99.9,63.56) 99.73,63.73 v3(99.24,63.73)
CFG19: length 61.7
  TOP w0.095: JXDP1.22 v7(46.78,69.33) 46.78,68.85 v2(46.74,68.8)
  IN1 w0.076: v9(97.63,65.83) 97.61,65.83 97.58,65.8 93.46,65.8 91.82,67.44 91.82,68.81 89.88,70.75 87.22,70.75 85.13,68.66 78.99,68.66 77.34,70.31 71.65,70.31 71.02,69.69 55,69.69 54.74,69.43 49.96,69.43 49.56,69.83 47.29,69.83 v7(46.78,69.33)
  GND1 w0.095: v9(97.63,65.83) 97.9,65.56 97.9,65.25 98.81,64.34 98.81,63.57 v3(99.2,63.18)
  GND3 w0.095: v4(99.49,62.68) 99.2,62.97 v3(99.2,63.18)
  BOTTOM w0.112: UCPU1.F66 99.71,62.91 v4(99.49,62.68)
CFG_RCOMP: length 1.6
  GND1 w0.305: v3(103.67,64.07) 103.35,63.75 v1(103.35,63.42)
  GND3 w0.305: v3(103.67,64.07) 103.44,63.84 v4(103.44,63.82)
  BOTTOM w0.305: v4(103.44,63.82) 103.75,63.5 UCPU1.E60
CHG_ACIN: length 6.6
  TOP w0.095: v2(57.57,9.91) 57.57,11.23 PR305.2
  TOP w0.203: PU300.19 59.95,12.61 PC331.1 59.04,12.63 PR307.1 58.43,12.61 58.12,12.31 PR305.2
CHG_ADP: length 6.2
  TOP w0.203: PR303.2 59.43,17.15 PC332.1 59.86,15.96 60.06,15.75 61.96,15.75 v2(62.19,15.53) 62.62,15.1 PU300.16
CHG_AMON: length 65.4
  TOP w0.203: v1(65.6,5.93) 65.64,5.93 65.91,6.2 v2(65.91,6.23) 65.91,6.89 65.83,6.97 65.83,8.19 65.48,8.54 64.69,8.54 64.22,9.01 PU300.29
  GND1 w0.095: v1(15.36,4.2) 15.36,4.44 v3(15.26,4.53) ; v1(65.6,5.93) 65.6,5.64 v3(65.55,5.59)
  GND3 w0.095: v6(14.9,4.63) 15.16,4.63 v3(15.26,4.53) ; v3(65.55,5.59) 65.55,5.66 v6(65.24,5.98)
  IN4 w0.076: v6(14.9,4.63) 14.64,4.63 14.24,5.03 14.24,7.38 15.4,8.54 17.95,8.54 18.26,8.85 19.39,8.85 20.61,10.08 22.82,10.08 23.04,10.29 23.04,10.49 23.37,10.82 23.68,10.82 23.99,10.5 23.99,9.49 24.44,9.04 26.03,9.04 26.77,8.3 34.44,8.3 35.06,7.68 49.6,7.68 50.92,6.35 58.9,6.35 58.98,6.43 64.79,6.43 v6(65.24,5.98)
CHG_BGATE: length 24.5
  TOP w0.203: PU300.32 65.42,9.66 65.52,9.56 66.84,9.56 67.24,9.16 67.24,8.63 PC339.1 67.6,8.54 v7(67.6,9.13)
  IN1 w0.305: v9(81.89,14.87) 80.99,14.87 76.77,10.64 75.68,10.64 74.83,9.79 74.83,9.05 74.44,8.66 72.28,8.66 72.01,8.93 69.27,8.93 69.07,9.13 v7(67.6,9.13)
  GND1 w0.305: v3(81.55,15.21) v9(81.89,14.87)
  GND3 w0.305: v3(81.55,15.21) 81.73,15.39 v4(81.98,15.39)
  BOTTOM w0.095: v4(81.98,15.39) v2(81.98,15.89)
  BOTTOM w0.254: PQ304.4 82.95,14.61 82.17,15.39 v4(81.98,15.39)
CHG_BST1: length 3.1
  TOP w0.095: PR306.2 64.31,17.25 64.31,18.69 v2(64.84,19.21)
CHG_BST2:
  vias: v2(68.29,12.28) v8(67.98,12.72) v8(68.58,12.73)
CHG_CLK: length 3.7
  TOP w0.203: PU300.22 61.48,11.41 60.82,10.75 60.82,9.51 60.28,8.96 PR314.2
CHG_CMIN: length 2.8
  TOP w0.203: PR334.2 59.97,10.9 60.86,11.78 v2(60.86,12.05) 61.02,12.21 PU300.20
CHG_COMP: length 3
  TOP w0.203: PU300.28 63.82,8.88 64.17,8.52 PC348.1 64.17,8.06 PR327.1
CHG_CSIN: length 5.7
  TOP w0.203: PU300.14 63.42,15.07 v2(63.78,15.43) PC312.2 63.79,16.8 PR301.2 63.63,17.84 v8(63.11,17.32)
  BOTTOM w0.254: v8(63.11,17.32) 63.28,17.32 PR301.2
CHG_CSIP: length 7.4
  TOP w0.095: PR302.2 61.57,17.84 v2(61.24,18.17)
  TOP w0.203: v8(63.08,17.95) 62.97,17.84 PR302.2 62.38,17.82 PC312.1 62.38,16.1 63.02,15.47 PU300.15
  BOTTOM w0.254: PC313.1 62.74,18.75 63.08,18.41 v8(63.08,17.95)
CHG_CSON: length 4.6
  TOP w0.178: PU300.1 66.45,10.61 67.38,9.67 PC346.2
  TOP w0.254: PC347.1 69.23,8.43 PR324.2 69.12,9.31 68.76,9.67 PC346.2
CHG_CSOP: length 4.5
  TOP w0.178: PU300.2 66.5,11.01 67.06,10.45 67.55,10.45 PC346.1
  TOP w0.254: PC346.1 68.18,11.09 PC345.2 PR323.2
CHG_DAT: length 3.2
  TOP w0.203: PU300.21 61.4,11.81 60.49,10.89 60.49,10.09 60.29,9.88 60.04,9.88 PR313.2
CHG_DCIN: length 7.4
  TOP w0.203: 61.65,13.41 PU300.17
  TOP w0.508: v8(62.1,14.35) 62.1,14.61 61.59,15.12 v2(58.59,15.12) 58.04,15.12 57.74,14.82 PR309.2
  BOTTOM w0.508: PC333.2 v8(62.1,14.35)
CHG_LG1: length 13.9
  TOP w0.095: v8(62.98,28.19) v2(62.98,28.71)
  IN2 w0.762: 62.61,27.55 62.61,27.55 62.61,23.87 67.01,19.47 67.01,15.97
  vias: v8(62.39,28.19) v8(65.89,14.35) v8(66.32,14.78)
CHG_LG2: length 7
  IN2 w0.762: 69.06,20.36 69.37,20.06 69.37,16.57 68.08,15.28
  GND3 w0.095: v4(68.76,20.83) v3(68.76,21.19) ; v4(68.26,20.83) v3(68.26,21.18)
  BOTTOM w0.095: v8(66.9,13.48) v2(66.37,13.48)
  vias: v8(67.26,13.96)
CHG_LX1: length 5.2
  IN4 w0.762: 66.28,16.91 66.28,22.09
  vias: v2(65.82,24.55) v8(59.53,25.27) v8(59.53,24.54) v8(59.53,23.81) v8(60.59,25.27) v8(60.59,24.54) v8(60.59,23.81) v8(61.65,25.27) v8(61.65,24.54) v8(61.65,23.81) v8(64.77,27.82) v8(65.54,14.97) v8(65.97,15.39) v8(66.02,27.79) v8(66.7,23.31) v8(66.72,22.69)
CHG_LX2: length 8
  IN4 w0.61: 68.81,15.53 68.81,15.89 69.34,16.43 69.34,21.17 70.23,22.05 v8(71.16,22.05)
  vias: v2(68.21,14.03) v8(68.77,14.23) v8(68.95,14.81) v8(70.08,27.71) v8(70.66,20.1) v8(70.66,19.04) v8(70.66,17.98) v8(71.03,27.69) v8(71.16,22.69) v8(71.39,20.1) v8(71.39,19.04) v8(71.39,17.98) v8(72.12,20.1) v8(72.12,19.04) v8(72.12,17.98)
CHG_PROCHOT#: length 23.7
  TOP w0.095: PR315.2 59.54,8.48 58.64,8.48 58.54,8.57 v7(58.54,8.96) ; PR209.2 51.37,18.19 51.37,17.13 50.56,16.32 50.56,14.05 49.69,13.18 v2(49.69,12.52) v7(49.99,12.22)
  TOP w0.203: PU300.23 61.56,11.01 61.15,10.6 61.15,9.36 60.7,8.91 60.7,8.61 60.1,8.01 PR315.2
  IN1 w0.076: v7(58.54,8.96) 58.54,8.86 58.36,8.68 53.37,8.68 49.99,12.06 v7(49.99,12.22)
CHG_PSYS: length 5.6
  TOP w0.203: PU300.30 64.62,9.13 64.87,8.88 66.05,8.88 66.28,8.65 v2(66.28,8.03) 66.28,7.41 67.45,6.25 PR329.1
CHG_UG1: length 4.8
  TOP w0.095: v8(63.22,20.92) v2(62.5,20.92)
  IN4 w0.762: 63.68,20.19 64.84,19.03 64.84,16.62
  vias: v8(63.81,20.92) v8(64.97,15.42) v8(65.45,15.77)
CHG_UG2: length 14.9
  TOP w0.095: v8(75.02,21.65) v2(75.02,21.11)
  IN2 w0.762: 74.91,21.24 74.91,17.59 74.44,17.12 72.37,17.12 71.79,16.54 71.79,13.46 71.21,12.87 69.97,12.87 69,11.91 68.38,11.91
  vias: v8(66.83,12.11) v8(67.32,12.47) v8(74.44,21.65)
CHG_VBAT1: length 7.7
  TOP w0.095: PR330.1 69.88,6.88 v2(69.88,6.48)
  TOP w0.203: PR330.1 69.08,7.36 69.08,7.18 68.83,6.94 68.04,6.94 PC351.1 67.46,7.54 66.84,8.16 66.84,8.65 66.28,9.22 65.22,9.22 65.02,9.42 PU300.31
CHG_VDDP: length 3
  TOP w0.095: PR308.1 68.15,16.24 v2(68.26,16.35)
  TOP w0.508: 66.97,14.57 67.33,14.93 PC334.1 67.33,16.12 PR308.1
CL_CLK: length 213.2
  GND1 w0.095: v3(284.33,45.5) 284.51,45.68 v1(285.23,45.68)
  IN2 w0.064: v3(284.33,45.5) 283.89,45.06 283.89,44.36 283.59,44.07 278.05,44.07 272.6,38.62 272.6,34.09 271.58,33.07 270.34,33.07 267.72,30.45 267.72,28.59 267.3,28.18 267.3,25.09 264.8,22.58 264.8,19.8 260.31,15.31 259.56,15.31 256.89,12.63 256.89,11.79 255.72,10.62 254.9,10.62 252.98,8.7 251.17,8.7 250.02,7.55 230.87,7.55 229.35,9.06 227.06,9.06 226.02,10.1 217.24,10.1 215.77,11.57 211.37,11.57 207.3,7.5 186.81,7.5 185.11,9.2 174.39,9.2 170.51,13.08 169.89,13.08 164.97,18 162.42,18 160.62,19.8 160.62,27.23 159.81,28.04 159.81,31.27 158.79,32.28 158.79,36.09 153.67,41.22 153.67,45.75 148.55,50.86 148.55,53.23 143.5,58.28 142.41,58.28 141.48,59.21 141.48,60.51 139.12,62.87 139.12,62.96 v3(139.21,63.05)
  GND3 w0.095: v3(139.21,63.05) 138.95,62.79 v4(138.95,62.77)
  BOTTOM w0.076: UCPU1.G3 136.49,62.71 136.68,62.52 136.82,62.45 137.13,62.45 137.21,62.37 137.46,62.27 138.45,62.27 v4(138.95,62.77)
CL_CLK_R: length 1.9
  TOP w0.095: R24.2 283.41,45.68 v8(283.33,45.75)
  BOTTOM w0.095: WL1.42 283.74,46.07 283.43,45.75 v8(283.33,45.75)
CL_DAT: length 212.6
  GND1 w0.095: v3(284.32,44.87) 284.37,44.87 284.46,44.79 v1(285.23,44.79)
  IN2 w0.064: v3(138.74,63.35) 138.74,63.36 138.74,62.98 141.29,60.43 141.29,59.13 142.33,58.09 143.42,58.09 148.36,53.15 148.36,50.78 153.48,45.67 153.48,41.14 158.6,36.01 158.6,32.2 159.62,31.19 159.62,27.96 160.43,27.15 160.43,19.72 162.34,17.81 164.9,17.81 169.81,12.89 170.43,12.89 174.31,9.01 185.03,9.01 186.73,7.31 207.38,7.31 211.44,11.38 215.69,11.38 217.16,9.91 225.94,9.91 226.98,8.87 229.27,8.87 230.79,7.36 250.1,7.36 251.25,8.51 253.06,8.51 254.98,10.43 255.8,10.43 257.08,11.71 257.08,12.56 259.64,15.12 260.39,15.12 264.99,19.72 264.99,22.51 267.49,25.01 267.49,28.1 267.91,28.52 267.91,30.37 270.42,32.88 271.66,32.88 272.8,34.01 272.8,38.54 278.13,43.88 283.67,43.88 284.08,44.28 284.08,44.62 v3(284.32,44.87)
  GND3 w0.095: v4(138.63,62.99) 138.75,63.11 138.75,63.34 v3(138.74,63.35)
  BOTTOM w0.076: v4(138.63,62.99) 138.63,62.84 138.22,62.43 137.5,62.43 137.3,62.51 137.1,62.71 UCPU1.G2
CL_DAT_R: length 2.1
  TOP w0.095: R25.2 283.72,44.79 v8(283.35,45.16)
  BOTTOM w0.095: WL1.43 283.93,45.57 283.52,45.16 v8(283.35,45.16)
CL_RST#: length 211.9
  GND1 w0.095: v3(284.28,43.65) 284.53,43.9 v1(285.23,43.9)
  IN2 w0.064: v3(138.19,63.27) 138.26,63.2 138.26,62.87 140.53,60.6 140.53,59.23 142.25,57.51 142.25,57.51 143.55,57.51 146.7,54.36 146.7,52 153.14,45.55 153.14,41.01 158.27,35.88 158.27,31.98 159.29,30.97 159.29,27.75 160.06,26.98 160.06,19.63 163.15,16.54 165.35,16.54 170.6,11.28 v3(170.67,11.28) ; v3(284.28,43.65) 284.19,43.56 278.42,43.56 273.11,38.25 273.11,33.88 271.78,32.55 270.54,32.55 268.23,30.23 268.23,28.38 267.82,27.97 267.82,23.59 v3(266.64,22.41)
  GND3 w0.095: v3(266.64,22.41) 266.84,22.21 v6(266.84,22.07) ; v3(170.67,11.28) 170.63,11.24 170.52,11.24 v6(170.39,11.1) ; v3(138.19,63.27) 138.19,63.24 138.11,63.16 v4(138.11,62.93)
  IN4 w0.076: v6(266.84,22.07) 266.84,21.32 265.8,20.27 265.09,20.27 261.16,16.34 258.9,16.34 252.63,10.08 246.71,10.08 246.07,9.43 226.35,9.43 222.65,13.14 218.84,13.14 217.99,13.99 211.64,13.99 206.59,8.94 202.38,8.94 200.38,6.94 196.25,6.94 196.08,6.77 186.36,6.77 184.46,8.67 177.12,8.67 174.69,11.1 v6(170.39,11.1)
  BOTTOM w0.076: v4(138.11,62.93) 138.11,62.79 138.04,62.71 UCPU1.G1
CL_RST#_R: length 2.2
  TOP w0.095: v8(283.35,44.52) 283.97,43.9 R26.2
  BOTTOM w0.095: v8(283.35,44.52) 283.41,44.52 283.96,45.07 WL1.44
CLK0_PCIE_TBT: length 121.7
  IN2 w0.089: v3(25.54,44.55) 25.43,44.55 25.26,44.72 25.26,45.23 25.06,45.44 25.06,49.44 25.64,50.02 25.64,54.42 25.49,54.58 25.49,57.61 35.21,67.33 40.24,67.33 42.77,69.87 42.77,70.75 43.68,71.66 43.68,72.2 44.98,73.49 78.75,73.49 80.51,71.74 82.58,71.74 84.35,73.5 101.32,73.5 101.77,73.05 105.08,73.05 105.53,73.5 111.45,73.5 112.59,72.35 112.85,72.35 113.11,72.09 113.11,71.19 113.46,70.84 113.46,70.48 113.62,70.33 v3(113.85,70.33)
  GND3 w0.102: v4(113.44,70.21) 113.49,70.21 113.66,70.38 113.8,70.38 v3(113.85,70.33) ; v4(25.79,44.3) v3(25.54,44.55)
  BOTTOM w0.076: v4(113.44,70.21) 113.32,70.32 113.11,70.32 112.73,69.95 v10(112.73,67.98) 112.73,67.67 113.03,67.38 113.03,66.61 112.82,66.4 112.82,66.11 112.86,66.01 112.86,65.77 112.82,65.67 112.82,65.48 112.89,65.36 112.89,65.25 112.89,65.18 112.76,64.93 112.77,64.71 112.89,64.58 113.27,64.58 113.34,64.66 113.34,64.85 113.27,64.92 UCPU1.C42
CLK0_PCIE_TBT#: length 121.6
  IN2 w0.089: v3(24.91,44.56) 24.91,45.09 24.7,45.29 24.7,49.58 25.29,50.17 25.29,54.28 25.14,54.43 25.14,57.76 35.06,67.69 40.09,67.69 42.41,70.01 42.41,70.9 43.32,71.8 43.32,72.34 44.83,73.85 78.9,73.85 80.66,72.09 82.44,72.09 84.2,73.86 101.46,73.86 101.92,73.41 104.93,73.41 105.38,73.85 111.6,73.85 112.74,72.71 113,72.71 113.47,72.24 113.47,71.34 v3(113.81,71)
  GND3 w0.102: v3(113.81,71) v4(113.42,70.61) ; v4(25.14,44.3) 25.14,44.32 v3(24.91,44.56)
  BOTTOM w0.076: v4(113.42,70.61) 113.3,70.49 113.04,70.49 112.57,70.02 112.57,68.32 112.53,68.27 112.53,67.65 112.87,67.31 112.87,66.68 112.66,66.47 112.66,66.08 112.69,65.98 112.69,65.8 112.66,65.7 112.66,65.44 112.73,65.31 112.73,65.26 112.73,65.22 112.6,64.97 112.6,64.64 112.86,64.39 112.97,64.39 UCPU1.D42
CLK1_PCIE_WLAN: length 262.3
  IN2 w0.089: v3(249.87,11.77) 249.8,11.84 249.2,11.84 247.89,10.53 232.73,10.53 231.19,12.07 228.34,12.07 225.66,14.74 209.93,14.74 205.67,10.48 188.17,10.48 186.59,12.06 184.21,13.11 183.27,13.11 v3(183,12.84)
  IN3 w0.089: v3(249.87,11.77) 249.9,11.81 250.7,11.81 251.78,12.88 253.84,12.88 258.62,17.66 259.68,17.66 262.17,20.15 262.17,22.65 263.99,26.41 265.14,27.56 265.14,29.51 267.93,32.29 274.74,32.29 276.21,33.76 276.21,35.68 278.9,38.37 278.9,48.74 281.48,51.32 284.33,51.32 284.77,50.88 284.77,50.03 285.17,49.63 285.37,49.63 v3(285.52,49.48) ; v3(183,12.84) 183.08,12.84 183.21,12.98 183.21,13.2 183.13,13.29 182.04,13.29 176.09,19.23 170.39,19.23 165.98,23.64 165.98,26.02 164.47,27.53 164.47,33.05 165.06,33.64 165.06,35.14 164.53,35.68 164.53,38.95 162.91,40.57 162.91,45.42 161.2,47.13 161.2,48.46 154.73,54.94 154.73,55.67 153.61,56.79 153.61,58.52 152.14,60 152.14,62.08 151.53,62.68 151.53,65.35 150.72,66.16 150.72,69.54 147.51,72.75 145.22,72.75 143.67,74.31 115.8,74.31 114.47,72.98 114.47,72.92 113.39,71.84 113.39,69.23 113.53,69.09 113.69,69.09 v3(113.85,69.25)
  GND3 w0.102: v4(285.98,48.76) 285.52,49.21 v3(285.52,49.48) ; v3(113.85,69.25) 113.81,69.21 113.62,69.21 v4(113.48,69.08)
  BOTTOM w0.076: UCPU1.A42 113.03,66.16 113.03,66.04 113.19,65.87 113.3,65.87 113.4,65.97 113.4,67.49 113.03,67.86 113.03,68.56 113.22,68.74 113.22,68.82 v4(113.48,69.08)
  BOTTOM w0.102: WL1.34 284.38,50.07 284.45,50.14 284.82,50.14 285.12,49.84 285.12,49.42 285.43,49.11 285.63,49.11 v4(285.98,48.76)
CLK1_PCIE_WLAN#: length 262
  IN2 w0.089: v3(183.03,13.73) 183.29,13.47 184.28,13.47 186.79,12.36 188.32,10.83 205.52,10.83 209.79,15.1 225.81,15.1 228.48,12.42 231.33,12.42 232.87,10.88 247.74,10.88 249.05,12.2 249.75,12.2 v3(249.87,12.31)
  IN3 w0.089: v3(285.53,50.03) 285.49,49.99 285.31,49.99 285.12,50.17 285.12,51.03 284.48,51.68 281.34,51.68 278.54,48.89 278.54,38.52 275.85,35.83 275.85,33.9 274.59,32.65 267.78,32.65 264.79,29.65 264.79,27.71 263.69,26.62 261.81,22.73 261.81,20.3 259.53,18.02 258.47,18.02 253.7,13.24 251.63,13.24 250.56,12.17 250.01,12.17 v3(249.87,12.31) ; v3(113.86,68.71) 113.83,68.74 113.38,68.74 113.03,69.09 113.03,71.99 114.11,73.07 114.11,73.13 115.65,74.67 143.82,74.67 145.37,73.11 147.66,73.11 151.08,69.69 151.08,66.31 151.89,65.5 151.89,62.83 152.49,62.23 152.49,60.14 153.96,58.67 153.96,56.93 155.08,55.82 155.08,55.08 161.55,48.61 161.55,47.28 163.27,45.57 163.27,40.71 164.88,39.1 164.88,35.83 165.42,35.29 165.42,33.49 164.82,32.9 164.82,27.68 166.34,26.16 166.34,23.79 170.53,19.59 176.24,19.59 182.19,13.64 182.94,13.64 v3(183.03,13.73)
  GND3 w0.102: v3(285.53,50.03) v4(285.98,49.59) ; v3(113.86,68.71) 113.82,68.68 v4(113.52,68.68)
  BOTTOM w0.076: UCPU1.B42 113.22,65.71 113.37,65.71 113.56,65.9 113.56,67.56 113.2,67.93 113.2,68.49 113.38,68.68 v4(113.52,68.68)
  BOTTOM w0.102: v4(285.98,49.59) 285.73,49.34 285.53,49.34 285.35,49.52 285.35,49.93 284.92,50.37 284.53,50.37 284.33,50.57 WL1.33
