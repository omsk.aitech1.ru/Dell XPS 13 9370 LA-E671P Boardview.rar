# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D49: length 42.9
  TOP w0.152: v8(145.69,26.83) 145.69,26.75 UD43.T11
  IN3 w0.095: v8(145.69,26.83) 145.61,26.83 145.11,27.32 145.11,27.67 144.64,28.15 144.64,28.54 143.46,29.72 140.1,29.72 137.23,32.58 135.28,32.58 134.61,33.25 134.48,33.25 134.32,33.09 134.18,33.09 134.05,33.23 134.05,33.36 134.21,33.52 134.21,33.65 134.05,33.81 133.91,33.81 133.76,33.65 133.62,33.65 133.49,33.79 133.49,33.92 133.64,34.08 133.64,34.21 133.49,34.37 133.35,34.37 133.19,34.22 133.06,34.22 132.92,34.35 132.92,34.48 133.08,34.64 133.08,34.78 132.95,34.91 132.81,34.91 132.66,34.75 132.52,34.75 132.39,34.89 132.39,35.02 132.54,35.18 132.54,35.32 132.38,35.47 132.25,35.47 132.1,35.32 131.96,35.32 131.83,35.45 131.83,35.59 131.98,35.74 131.98,35.88 131.78,36.07 130.94,36.07 130.74,36.28 129.76,36.28 129.49,36.01 129.36,36.01 129.12,36.25 129.12,36.39 129.43,36.7 129.43,36.83 129.3,36.97 129.16,36.97 128.79,36.6 128.65,36.6 128.52,36.73 128.52,36.87 128.78,37.12 128.78,37.26 128.64,37.39 128.51,37.39 128.25,37.14 128.12,37.14 125.75,39.5 125.75,43.04 124.6,44.19 122.46,44.19 121.11,45.54 121.11,46.41 121.62,46.91 v8(121.62,47.01)
  BOTTOM w0.152: v8(121.62,47.01) 121.75,47.01 UCPU1.AT27
DDR_B_D50: length 42.7
  TOP w0.152: v8(145.04,24.43) 145.04,24.5 UD43.T9
  IN3 w0.076: v8(122.58,47.01) 123.91,45.69 124.92,45.69 125.36,45.24 125.85,45.24 125.94,45.16
  IN3 w0.095: 125.94,45.16 127.89,43.21 127.89,42.37 128.08,42.18 128.08,42.17 128.33,41.92 128.33,40.39 129.3,39.42 130.6,39.42 130.75,39.42 135.84,34.33 138.66,34.33 141.04,31.95 142,31.95 142.53,31.42 144.44,31.42 144.61,31.26 146.01,29.85 147.13,29.85 148.26,28.72 148.26,25.37 147.44,24.56 145.17,24.56 v8(145.04,24.43)
  BOTTOM w0.152: UCPU1.AT25 122.67,47.01 v8(122.58,47.01)
DDR_B_D51: length 42.6
  TOP w0.152: UD43.R9 144.39,24.5 v8(144.39,24.43)
  IN3 w0.076: v8(122.57,46.38) 123.99,44.96 125.73,44.96 125.73,44.95
  IN3 w0.095: v8(144.39,24.43) 144.39,24.59 144.69,24.88 147.36,24.88 147.97,25.5 147.97,28.61 147.14,29.44 146.02,29.44 144.32,31.14 142.41,31.14 141.88,31.67 140.92,31.67 138.61,33.98 135.8,33.98 130.64,39.14 129.06,39.14 128.05,40.16 128.05,41.8 127.79,42.05 127.79,42.06 127.59,42.26 127.59,43.1 125.73,44.95
  BOTTOM w0.152: v8(122.57,46.38) 122.68,46.38 UCPU1.AU25
DDR_B_D52: length 42.9
  TOP w0.152: UD43.R11 144.81,26.52 145.04,26.75 v8(145.04,26.83)
  IN3 w0.095: v8(145.04,26.83) 144.78,27.08 144.08,27.08 143.55,27.62 143.55,28.99 143.11,29.42 142.56,29.42 142.46,29.33 142.46,28.12 142.37,28.02 142.18,28.02 142.08,28.12 142.08,29.33 141.99,29.42 141.8,29.42 141.7,29.33 141.7,28.83 141.61,28.73 141.42,28.73 141.32,28.83 141.32,29.33 141.23,29.42 139.97,29.42 137.1,32.29 134.58,32.29 131.66,35.2 129.6,35.2 125.43,39.37 125.43,42.61 125.43,42.95 124.46,43.92 122.33,43.92 120.82,45.43 120.82,46.52 121.17,46.88 121.17,47.81 v8(121.64,48.28)
  BOTTOM w0.152: UCPU1.AP27 121.72,48.28 v8(121.64,48.28)
DDR_B_D53: length 43.2
  TOP w0.152: v8(145.04,26.03) 145.04,25.95 UD43.R10
  IN3 w0.095: v8(145.04,26.03) 145.01,26.03 144.52,26.52 143.68,26.52 143.52,26.68 143.52,27.07 143.35,27.25 142.69,27.25 142.56,27.12 142.56,26.52 142.48,26.45 142.23,26.45 142.13,26.55 142.13,27.7 142.03,27.79 141.84,27.79 141.75,27.7 141.75,27.31 141.65,27.21 141.43,27.21 141.29,27.35 141.29,28.23 141.14,28.37 140.49,28.37 136.93,31.93 134.54,31.93 131.55,34.92 129.48,34.92 124.93,39.46 124.93,42.27 124.61,42.6 124.61,43.06 124.08,43.6 122.25,43.6 120.31,45.53 120.31,47.9 120.56,48.15 120.88,48.15 v8(121.64,48.92)
  BOTTOM w0.152: v8(121.64,48.92) 121.71,48.92 UCPU1.AN27
DDR_B_D54: length 46.2
  TOP w0.152: v8(145.02,23.61) 145.02,23.72 UD43.R8
  IN3 w0.076: 126.02,45.77 125.34,45.77 125.08,46.02 124.25,46.02 123.89,46.38 123.89,47.74 122.71,48.92 v8(122.56,48.92)
  IN3 w0.095: 126.02,45.77 126.14,45.77 128.54,43.37 128.54,42.55 128.92,42.17 128.92,41.14 130.05,40.01 130.99,40.01 136.03,34.98 138.82,34.98 141.27,32.53 142.23,32.53 142.76,32 144.69,32 146.09,30.59 147.19,30.59 148.67,29.12 148.86,28.93 148.86,25.15 147.51,23.81 146.92,23.21 145.41,23.21 v8(145.02,23.61)
  BOTTOM w0.152: v8(122.56,48.92) 122.62,48.92 UCPU1.AN25
DDR_B_D55: length 44.3
  TOP w0.152: UD43.T8 145.69,23.7 v8(145.69,23.63)
  IN3 w0.076: 126.02,45.49 125.98,45.53 125.35,45.53 125.02,45.86 123.97,45.86 122.99,46.84 122.99,47.85 v8(122.56,48.28)
  IN3 w0.095: 126.02,45.49 128.15,43.35 128.15,43.35 128.18,43.33 128.18,42.48 128.62,42.04 128.62,40.51 129.42,39.71 130.48,39.71 130.88,39.71 135.9,34.69 138.7,34.69 141.16,32.24 142.12,32.24 142.64,31.71 144.56,31.71 145.97,30.31 147.07,30.31 148.55,28.83 148.55,25.25 146.93,23.63 v8(145.69,23.63)
  BOTTOM w0.152: UCPU1.AP25 122.64,48.28 v8(122.56,48.28)
DDR_B_D56: length 34.1
  TOP w0.152: v8(143.1,24.43) 142.76,24.77 UD43.M9
  IN2 w0.095: v8(124.36,47.01) 124.15,46.8 124.15,46.69 123.89,46.43 123.89,45.16 124.52,44.53 125.34,44.53 126.05,43.82 126.05,43.82 126.78,43.08 127.31,43.08 127.69,42.7 127.69,42.04 128.38,41.35 128.38,40.19 131.21,37.36 131.21,36.63 131.52,36.32 131.52,35.83 134.42,32.94 136.14,32.94 140.41,28.67 140.41,27.67 140.71,27.37 140.71,26.05 140.99,25.78 141.59,25.18 142.35,25.18 v8(143.1,24.43)
  BOTTOM w0.152: v8(124.36,47.01) 124.5,47.01 UCPU1.AT22
DDR_B_D57: length 33.3
  TOP w0.152: UD43.N9 143.09,25.15 v8(143.09,25.23)
  IN2 w0.095: v8(143.09,25.23) 142.83,25.48 141.73,25.48 141.36,25.85 141.36,26.42 141.55,26.61 141.55,27 141.55,27 141.55,27.87 141.23,28.19 141.23,29.01 141.19,29.04 140.94,29.29 140.22,29.29 136.26,33.25 134.54,33.25 131.81,35.98 131.81,36.44 131.5,36.75 131.5,37.48 128.76,40.22 128.76,41.4 128,42.16 128,43.09 127.72,43.37 126.9,43.37 125.32,44.95 124.59,44.95 124.25,45.29 124.25,46.25 124.43,46.43 v8(124.43,46.43)
  BOTTOM w0.152: UCPU1.AU22 124.57,46.43 124.43,46.43
  BOTTOM w0.173: 124.43,46.43 v8(124.43,46.43)
DDR_B_D58: length 33.2
  TOP w0.076: UD43.M11 142.46,26.73 142.46,27.49
  TOP w0.173: 142.46,27.49 142.46,27.79 v8(142.93,28.26)
  IN2 w0.095: v8(142.93,28.26) 142.52,28.66 142.52,30.06 141.92,30.66 141.38,30.66 140.98,31.06 140.98,31.46 140.58,31.86 139.94,31.86 139.74,32.06 139.74,32.22 139.92,32.4 139.92,32.57 139.76,32.73 139.6,32.73 139.42,32.55 139.26,32.55 138.98,32.82 138.98,32.98 139.18,33.17 139.18,33.34 139.02,33.5 138.85,33.5 138.66,33.3 138.5,33.3 138.34,33.47 138.34,33.63 138.53,33.82 138.53,33.98 138.37,34.14 138.21,34.14 138.01,33.95 137.85,33.95 137.49,34.31 135.41,34.31 132.54,37.18 132.54,37.93 130.49,39.98 130.49,41.81 129.77,42.53 129.77,42.92 129.83,42.98 129.83,43.27 129.49,43.62 128.98,43.62 128.09,44.51 127.42,44.51 127.41,44.52 127.08,44.52 125.33,46.27 v8(125.33,46.36)
  BOTTOM w0.152: UCPU1.AU21 125.41,46.36 v8(125.33,46.36)
DDR_B_D59: length 33.5
  TOP w0.152: v8(143.1,26.83) 143.1,26.74 UD43.N11
  IN2 w0.095: v8(125.33,47.01) 125.33,46.94 125.73,46.54 125.73,46.18 127.12,44.8 128.23,44.8 129.11,43.92 129.69,43.92 131.06,42.55 131.06,42.14 130.82,41.9 130.82,40.06 132.82,38.05 132.82,37.33 135.53,34.62 138.33,34.62 140.61,32.34 140.97,32.34 141.11,32.2 141.11,32.06 141.01,31.97 141.01,31.83 141.15,31.7 141.28,31.7 141.39,31.81 141.69,31.81 142.35,31.14 142.35,30.98 142.28,30.91 142.28,30.74 142.44,30.58 142.6,30.58 142.67,30.66 142.84,30.66 143.3,30.19 143.3,30.04 143.17,29.9 143.02,29.9 142.89,29.78 142.89,29.57 143.02,29.45 143.29,29.45 143.4,29.33 143.4,27.13 v8(143.1,26.83)
  BOTTOM w0.152: UCPU1.AT21 125.41,47.01 v8(125.33,47.01)
DDR_B_D60: length 39
  TOP w0.152: v8(143.09,23.63) 143.09,23.7 UD43.M8
  IN2 w0.095: v8(143.09,23.63) 142.53,23.63 142.12,24.04 140.27,24.04 140.03,24.28 140.03,27.19 139.8,27.42 139.8,28.36 135.82,32.33 134.16,32.33 130.91,35.58 130.91,35.9 130.32,36.49 129.83,36.49 128.82,37.5 128.82,38.82 127.71,39.92 127.71,41.15 126.9,41.96 126.75,41.96 126.27,42.44 126.27,42.76 125.04,43.98 123.8,43.98 123.05,44.74 123.05,47.96 123.43,48.34 123.81,48.34 v8(124.39,48.92)
  BOTTOM w0.152: UCPU1.AN22 124.45,48.92 v8(124.39,48.92)
DDR_B_D61: length 37
  TOP w0.152: UD43.P9 143.74,24.5 v8(143.74,24.43)
  IN2 w0.095: v8(143.74,24.43) 143.35,24.04 142.79,24.04 141.95,24.87 141.43,24.87 140.33,25.97 140.33,27.32 140.1,27.55 140.1,28.48 135.95,32.64 134.29,32.64 131.2,35.73 131.2,36.04 130.45,36.79 129.96,36.79 129.12,37.62 129.12,38.93 128.02,40.03 128.02,41.28 127.05,42.25 126.87,42.25 126.56,42.56 126.56,42.87 125.1,44.33 124.26,44.33 123.53,45.06 123.53,46.48 123.88,46.82 123.88,47.78 v8(124.39,48.28)
  BOTTOM w0.152: UCPU1.AP22 124.47,48.28 v8(124.39,48.28)
DDR_B_D62: length 34.3
  TOP w0.152: UD43.M10 143.09,25.96 v8(143.09,26.03)
  IN2 w0.095: v8(125.3,48.28) 125.81,47.78 125.81,46.87 126.02,46.65 126.02,46.33 126.66,45.69 127.35,45.69 127.89,45.15 128.31,45.15 129.24,44.23 129.91,44.23 131.38,42.76 131.38,41.35 131.6,41.13 131.6,39.71 133.11,38.2 133.11,37.47 135.66,34.92 138.46,34.92 140.74,32.64 141.29,32.64 143.71,30.22 143.71,26.64 v8(143.09,26.03)
  BOTTOM w0.152: UCPU1.AP21 125.38,48.28 v8(125.3,48.28)
DDR_B_D63: length 38.9
  TOP w0.152: v8(143.74,25.24) 143.74,25.3 UD43.N10
  IN2 w0.095: v8(143.74,25.24) 145.49,25.24 145.79,25.54 146.09,25.84 146.09,28.26 141.54,32.81 141.52,32.81 141.41,32.92 140.89,32.92 138.58,35.23 135.79,35.23 133.39,37.62 133.39,38.32 131.89,39.82 131.89,41.31 131.71,41.49 131.71,42.86 130.04,44.53 129.34,44.53 128.43,45.43 128.01,45.43 127.46,45.99 126.81,45.99 126.63,46.16 126.63,48.37 126.38,48.63 125.59,48.63 v8(125.3,48.92)
  BOTTOM w0.152: v8(125.3,48.92) 125.37,48.92 UCPU1.AN21
DDR_B_DQS0: length 25.5
  TOP w0.14: v8(123.63,26.02) 123.63,25.94 UD44.G10
  IN2 w0.108: v3(116.04,41.61) 116.22,41.43 116.54,41.43 116.83,41.15 116.83,40.04 116.57,39.78 116.57,36.02 119.56,33.03 120.36,33.03 123.42,29.97 123.42,29.3 123.68,29.04 124.07,29.04 124.37,28.74 124.37,26.54 124.07,26.25 123.86,26.25 123.78,26.17 123.78,26.17 v8(123.63,26.02)
  GND3 w0.14: v4(115.81,41.88) 115.81,41.84 v3(116.04,41.61)
  BOTTOM w0.076: UCPU1.AY38 115.98,45.07 115.91,45 115.85,45 115.74,44.89 115.64,44.71 115.63,44.69 115.63,44.46 115.69,44.29 115.69,44.21 115.62,43.99 115.62,43.82 115.68,43.66 115.9,43.44 115.9,42.24 116.09,42.06 116.09,41.9 115.99,41.81 115.88,41.81 v4(115.81,41.88)
DDR_B_DQS1: length 36.2
  TOP w0.14: UD44.P10 128.49,25.71 v8(128.17,26.03)
  IN3 w0.108: v8(128.17,26.03) 128.36,25.84 128.36,25.62 128.76,25.21 130.9,25.21 131.63,25.94 131.63,27.72 130.62,28.72 129.67,28.72 128.28,30.1 124.82,30.1 124.36,30.55 124.04,30.55 123.7,30.55 122.69,31.57 121.87,31.57 121.64,31.8 121.64,31.95 121.8,32.12 121.8,32.46 121.44,32.82 121.1,32.82 120.93,32.66 120.78,32.66 120.55,32.89 120.55,33.04 120.71,33.2 120.71,33.55 120.35,33.91 120.01,33.91 119.85,33.75 119.69,33.75 119.47,33.98 119.47,34.13 119.63,34.29 119.63,34.63 118.65,35.61 118.65,40.45 118.98,40.78 119.39,40.78 v3(119.49,40.67)
  GND3 w0.14: v3(119.49,40.67) 119.4,40.67 v4(119.2,40.47)
  BOTTOM w0.076: UCPU1.BA34 118.43,44.75 118.51,44.83 118.61,44.83 118.67,44.77 118.72,44.6 118.72,44.48 118.66,44.35 118.66,44.15 118.73,43.96 118.73,43.85 118.66,43.69 118.66,41.46 v2(119.2,40.91) v4(119.2,40.47)
DDR_B_DQS2: length 30.2
  TOP w0.14: v8(121.67,25.23) 121.67,25.3 UD44.D10
  IN3 w0.076: 115.25,45.36 115.25,45.38 115.28,45.41 115.28,45.51 114.71,46.08 114.71,47.32 114.92,47.53 115.15,47.53 115.31,47.69 v8(115.31,47.7)
  IN3 w0.108: 115.25,45.36 115.25,45.08 113.45,43.29 113.45,39.03 112.94,38.52 112.94,34.85 117.47,30.32 117.47,30.31 117.48,30.3 117.48,27.15 119.18,25.45 119.85,25.45 120.08,25.69 120.46,25.69 120.76,25.39 121.51,25.39 v8(121.67,25.23)
  BOTTOM w0.14: UCPU1.AR38 115.39,47.7 v8(115.31,47.7)
DDR_B_DQS3: length 38.5
  TOP w0.14: UD44.L10 126.23,25.94 v8(126.23,26.02)
  IN2 w0.076: v8(118.9,47.72) 119.09,47.53 119.19,47.53 119.43,47.29 119.43,45.8 119.24,45.6 119.24,44.94 119.27,44.91 119.27,44.89
  IN2 w0.108: v8(126.23,26.02) 126.23,25.05 126.99,24.29 128.69,24.29 129.02,24.62 129.02,25 129.35,25.33 129.44,25.33 131.02,25.33 131.69,25.99 131.69,27.57 130.82,28.44 130.01,28.44 123.52,34.93 122.79,34.93 121.93,35.79 121.93,36.41 121.2,37.15 121.2,39.29 121.04,39.46 121.04,42 120.33,42.72 120.33,43.54 120.76,43.98 120.76,44.32 120.38,44.7 120.04,44.7 119.59,44.26 119.43,44.26 119.27,44.42 119.27,44.89
  BOTTOM w0.14: v8(118.9,47.72) 119.07,47.72 UCPU1.AR32
DDR_B_DQS4: length 34.9
  TOP w0.14: UD43.G10 139.19,25.95 v8(139.19,26.03)
  IN3 w0.108: v3(120.33,39.97) 120.55,40.19 120.74,40.19 120.91,40.03 120.91,39.87 122.13,38.66 122.13,36.92 122.88,36.17 123.19,36.17 123.98,35.38 124.17,35.38 125.8,35.38 128.16,33.03 130.75,33.03 133.75,30.03 134.34,30.03 134.73,29.65 135.15,29.65 135.54,30.03 136.01,30.03 136.25,29.79 136.25,29.64 135.91,29.3 135.91,28.96 136.27,28.6 136.62,28.6 136.95,28.93 137.11,28.93 137.67,28.37 137.67,27.83 138.38,27.12 138.38,26.73 138.74,26.37 138.98,26.37 139.19,26.16 v8(139.19,26.03)
  GND3 w0.14: v3(120.33,39.97) 120.43,39.97 v4(120.62,39.78)
  BOTTOM w0.076: UCPU1.AY30 120.96,45.13 120.89,45.06 120.72,44.89 120.61,44.69 120.61,44.46 120.67,44.29 120.67,44.21 120.6,43.99 120.6,43.82 120.67,43.64 120.67,43.43 120.56,43.33 120.56,42.51 120.53,42.48 120.53,40.5 120.83,40.2 120.83,40 v4(120.62,39.78)
DDR_B_DQS5: length 32.4
  TOP w0.14: UD43.D10 137.24,25.3 v8(137.24,25.23)
  IN2 w0.076: 135.3,27.79 135.3,27.78 135.33,27.74 135.33,27.5 135.39,27.45 135.39,26.41 136.34,25.46 136.86,25.46 136.93,25.53 137.15,25.53 137.24,25.44 v8(137.24,25.23)
  IN2 w0.108: 135.3,27.79 135.3,28.02 135.7,28.42 135.7,28.66 135.57,28.79 135.57,29.18 135.7,29.31 135.7,29.55 135.19,30.05 134.95,30.05 134.84,29.95 134.84,29.78 134.63,29.57 134.09,29.57 130.89,32.77 130.15,32.77 127.74,35.19 127.74,35.54 127.78,35.58 127.78,35.74 127.53,35.98 127.37,35.98 127.34,35.94 126.98,35.94 126.61,36.32 126.61,36.67 126.83,36.9 126.83,37.06 126.59,37.3 126.43,37.3 126.2,37.07 125.85,37.07 125.06,37.87 125.06,38.62 124.77,38.91 124.77,39.36 125.02,39.61 125.11,39.61 125.21,39.71 125.21,40.03 125.02,40.23 124.44,40.23 v3(124.21,40)
  GND3 w0.14: v4(124.54,39.87) 124.42,40 v3(124.21,40)
  BOTTOM w0.076: v4(124.54,39.87) 124.37,40.05 124.16,40.05 123.84,40.37 123.84,43.11 123.64,43.31 123.64,43.69 123.71,43.85 123.71,43.96 123.64,44.15 123.64,44.35 123.7,44.48 123.7,44.6 123.65,44.77 123.59,44.83 123.51,44.83 123.41,44.73 UCPU1.BA26
DDR_B_DQS6: length 44.7
  TOP w0.14: v8(144.41,26.03) 144.41,25.97 UD43.P10
  IN3 w0.076: 125.28,44.5 125.26,44.51 125.26,44.55 125.19,44.62 123.6,44.62 122.45,45.78 122.34,45.78 122.02,46.09 122.02,47.35 122.16,47.48 122.16,47.81 122.07,47.9 121.77,47.9 121.64,47.77 v8(121.64,47.65)
  IN3 w0.108: v8(144.41,26.03) 144.19,25.81 144.19,25.66 144.32,25.52 144.42,25.52 145.44,25.52 146.46,25.52 146.95,26.01 146.95,26.27 146.85,26.37 146.85,27.63 144.07,30.41 140.4,30.41 139.59,31.23 139.59,31.57 139.76,31.74 139.76,31.9 139.53,32.13 139.38,32.13 139.2,31.96 139.11,31.96 138.86,31.96 138.51,32.31 138.51,32.65 138.7,32.84 138.7,32.99 138.44,33.24 138.31,33.24 138.12,33.05 138.02,33.05 137.77,33.05 137.54,33.28 135.56,33.28 132,36.84 131.16,36.84 130.77,37.22 130.77,37.78 130.12,38.43 128.83,38.43 127.32,39.95 127.32,41.44 126.48,42.28 126.48,43.3 125.28,44.5
  BOTTOM w0.14: v8(121.64,47.65) 121.74,47.65 UCPU1.AR27
DDR_B_DQS7: length 35.1
  TOP w0.14: v8(142.44,26.03) 142.44,25.95 UD43.L10
  IN2 w0.076: v8(125.33,47.65) 124.96,47.28 124.96,46 125.56,45.41 125.72,45.41 126.39,44.73 126.44,44.73 126.45,44.72
  IN2 w0.108: v8(142.44,26.03) 142.2,26.26 142.2,26.74 142.38,26.92 142.38,27.95 142.05,28.28 142.05,29.83 141.63,30.25 141.2,30.25 140.95,30.5 140.33,30.5 140.21,30.38 140.05,30.38 139.81,30.62 139.81,30.78 139.93,30.9 139.93,31.25 139.55,31.63 139.2,31.63 139.08,31.51 138.92,31.51 138.68,31.75 138.68,31.91 138.8,32.03 138.8,32.38 138.42,32.76 138.07,32.76 137.95,32.64 137.79,32.64 137.54,32.88 137.54,33.04 137.66,33.16 137.66,33.52 137.29,33.89 134.81,33.89 134.55,34.15 134.55,34.53 134.08,35 133.71,35 133.48,35.22 133.48,35.6 133.07,36 132.7,36 132.44,36.26 132.44,36.7 132.13,37.01 132.13,37.75 129.46,40.42 129.46,41.61 128.65,42.43 128.65,43.36 127.9,44.11 127.06,44.11 126.45,44.72
  BOTTOM w0.14: v8(125.33,47.65) 125.4,47.65 UCPU1.AR21
DDR_B_DQS#0: length 25.5
  TOP w0.14: UD44.G11 123.63,26.74 v8(123.63,26.83)
  IN2 w0.108: v3(116,40.97) 116,41.08 116.12,41.21 116.45,41.21 116.6,41.05 116.6,40.13 116.34,39.87 116.34,35.93 119.46,32.81 120.26,32.81 123.19,29.88 123.19,29.2 123.59,28.81 123.97,28.81 124.14,28.64 124.14,26.64 123.98,26.47 123.74,26.47 123.63,26.58 v8(123.63,26.83)
  GND3 w0.14: v3(116,40.97) 115.77,41.2 v4(115.77,41.22)
  BOTTOM w0.076: UCPU1.BA38 116.08,44.76 116,44.84 115.92,44.84 115.87,44.79 115.79,44.65 115.79,44.49 115.85,44.32 115.85,44.18 115.78,43.96 115.78,43.85 115.82,43.75 115.88,43.69 116.07,43.51 116.07,42.31 116.25,42.13 116.25,41.84 116.02,41.6 116.02,41.4 115.84,41.22 v4(115.77,41.22)
DDR_B_DQS#1: length 36.2
  TOP w0.14: v8(128.83,26.02) 128.49,26.36 UD44.P11
  IN3 w0.108: v3(119.47,41.49) 119.61,41.35 119.61,41.2 119.5,41.09 119.37,41.09 119.29,41 118.88,41 118.42,40.55 118.42,35.51 119.4,34.54 119.4,34.39 119.24,34.22 119.24,33.88 119.6,33.52 119.94,33.52 120.1,33.68 120.26,33.68 120.49,33.45 120.49,33.3 120.32,33.14 120.32,32.79 120.69,32.43 121.03,32.43 121.19,32.59 121.34,32.59 121.57,32.36 121.57,32.21 121.41,32.05 121.41,31.71 121.77,31.34 122.59,31.34 123.61,30.33 124.14,30.33 124.27,30.33 124.73,29.87 128.19,29.87 129.57,28.49 130.53,28.49 131.4,27.62 131.4,26.03 130.81,25.44 128.86,25.44 128.59,25.71 128.59,25.89 128.72,26.02 v8(128.83,26.02)
  GND3 w0.14: v3(119.47,41.49) 119.31,41.65 v4(119.14,41.65)
  BOTTOM w0.076: UCPU1.AY34 118.53,45.14 118.81,44.86 118.89,44.62 118.89,44.44 118.82,44.31 118.82,44.18 118.89,43.99 118.89,43.82 118.82,43.65 118.82,41.53 119.07,41.27 119.2,41.27 119.28,41.35 119.28,41.5 v4(119.14,41.65)
DDR_B_DQS#2: length 30.2
  TOP w0.14: v8(121.66,26.02) 121.66,26.09 UD44.D11
  IN3 w0.076: 115.48,45.36 115.48,45.38 115.44,45.41 115.44,45.58 114.88,46.15 114.88,47.25 114.99,47.36 115.17,47.36 115.31,47.22 v8(115.31,47.07)
  IN3 w0.108: v8(121.66,26.02) 121.71,26.02 121.81,25.92 121.81,25.72 121.7,25.62 120.85,25.62 120.55,25.91 119.99,25.91 119.75,25.68 119.27,25.68 117.71,27.24 117.71,30.39 117.7,30.41 117.7,30.41 113.17,34.94 113.17,38.43 113.68,38.94 113.68,43.19 115.48,44.99 115.48,45.36
  BOTTOM w0.14: v8(115.31,47.07) 115.41,47.07 UCPU1.AT38
DDR_B_DQS#3: length 38.4
  TOP w0.14: UD44.L11 126.72,26.43 126.86,26.29 v8(126.86,26.01)
  IN2 w0.076: v8(118.85,47.04) 118.76,47.13 118.76,47.26 118.87,47.37 119.12,47.37 119.27,47.22 119.27,45.86 119.07,45.67 119.07,44.94 119.04,44.91 119.04,44.89
  IN2 w0.108: v8(126.86,26.01) 126.86,25.81 126.74,25.69 126.57,25.69 126.46,25.57 126.46,25.15 127.08,24.52 128.6,24.52 128.79,24.71 128.79,25.1 129.25,25.55 129.54,25.55 130.92,25.55 131.46,26.09 131.46,27.48 130.72,28.21 129.92,28.21 123.43,34.7 122.7,34.7 121.71,35.69 121.71,36.32 120.97,37.05 120.97,39.2 120.81,39.36 120.81,41.91 120.1,42.62 120.1,43.63 120.54,44.07 120.54,44.22 120.28,44.47 120.13,44.47 119.69,44.03 119.34,44.03 119.04,44.32 119.04,44.89
  BOTTOM w0.14: v8(118.85,47.04) 118.94,46.95 119.13,46.95 119.36,47.18 UCPU1.AT32
DDR_B_DQS#4: length 34.9
  TOP w0.14: UD43.G11 139.33,26.43 139.19,26.57 v8(139.19,26.83)
  IN3 w0.108: v8(139.19,26.83) 139.19,26.7 139.08,26.59 138.84,26.59 138.61,26.83 138.61,27.21 137.9,27.92 137.9,28.47 137.2,29.16 136.86,29.16 136.52,28.82 136.37,28.82 136.14,29.05 136.14,29.21 136.48,29.54 136.48,29.88 136.1,30.26 135.44,30.26 135.06,29.87 134.82,29.87 134.44,30.26 133.85,30.26 130.85,33.26 128.25,33.26 125.9,35.61 124.07,35.61 123.28,36.4 122.98,36.4 122.36,37.01 122.36,38.75 121.14,39.97 121.14,40.12 120.84,40.42 120.4,40.42 v3(120.31,40.51)
  GND3 w0.14: v3(120.31,40.51) 120.48,40.67 v4(121.02,40.67)
  BOTTOM w0.076: UCPU1.BA30 121.12,44.63 121.12,44.83 121.07,44.89 120.96,44.89 120.85,44.79 120.77,44.65 120.77,44.49 120.83,44.32 120.83,44.19 120.76,43.97 120.76,43.85 120.83,43.67 120.83,43.37 120.73,43.26 120.73,42.44 120.69,42.41 120.69,40.57 120.77,40.5 120.94,40.5 121.02,40.57 v4(121.02,40.67)
DDR_B_DQS#5: length 32.4
  TOP w0.14: UD43.D11 137.24,26.1 v8(137.24,26.03)
  IN2 w0.076: 135.53,27.79 135.53,27.78 135.5,27.74 135.5,27.57 135.55,27.52 135.55,26.48 136.41,25.63 136.79,25.63 136.86,25.7 137.1,25.7 137.24,25.84 v8(137.24,26.03)
  IN2 w0.108: 135.53,27.79 135.53,27.93 135.93,28.33 135.93,28.76 135.8,28.89 135.8,29.09 135.93,29.22 135.93,29.64 135.29,30.28 134.85,30.28 134.61,30.04 134.61,29.87 134.54,29.8 134.18,29.8 130.98,33 130.25,33 127.97,35.28 127.97,35.44 128,35.48 128,35.83 127.63,36.21 127.28,36.21 127.24,36.17 127.08,36.17 126.84,36.41 126.84,36.58 127.06,36.8 127.06,37.15 126.69,37.53 126.33,37.53 126.11,37.3 125.95,37.3 125.29,37.96 125.29,38.72 125,39 125,39.27 125.11,39.38 125.2,39.38 125.44,39.62 125.44,40.12 125.11,40.45 124.41,40.45 v3(124.21,40.66)
  GND3 w0.14: v3(124.21,40.66) 124.26,40.66 124.52,40.39 v4(124.52,40.38)
  BOTTOM w0.076: v4(124.52,40.38) 124.36,40.22 124.23,40.22 124.01,40.44 124.01,43.18 123.8,43.38 123.8,43.65 123.87,43.82 123.87,43.99 123.81,44.18 123.81,44.31 123.87,44.44 123.87,44.62 123.8,44.86 123.66,44.99 123.6,44.99 123.51,45.08 UCPU1.AY26
DDR_B_DQS#6: length 44.7
  TOP w0.14: v8(143.75,26.03) 143.75,26.11 UD43.P11
  IN3 w0.076: 125.44,44.66 125.42,44.67 125.37,44.67 125.25,44.79 123.67,44.79 122.51,45.94 122.4,45.94 122.19,46.16 122.19,47.28 v8(122.56,47.65)
  IN3 w0.108: v8(143.75,26.03) 143.96,25.83 143.96,25.75 143.96,25.56 144.23,25.29 145.44,25.29 145.44,25.29 146.56,25.29 147.18,25.91 147.18,26.37 147.08,26.47 147.08,27.73 144.16,30.64 140.5,30.64 139.82,31.33 139.82,31.48 139.99,31.65 139.99,32 139.62,32.36 139.28,32.36 139.15,32.23 139.15,32.23 139.11,32.19 138.96,32.19 138.74,32.4 138.74,32.56 138.92,32.74 138.92,33.09 138.54,33.47 138.22,33.47 138.06,33.32 138.02,33.27 137.87,33.27 137.63,33.51 135.65,33.51 132.09,37.07 131.25,37.07 131,37.32 131,37.88 130.22,38.66 128.92,38.66 127.55,40.04 127.55,41.54 126.7,42.38 126.7,43.39 125.92,44.17 125.44,44.66
  BOTTOM w0.14: UCPU1.AR25 122.65,47.65 v8(122.56,47.65)
DDR_B_DQS#7: length 35.1
  TOP w0.14: v8(141.78,26.02) 141.78,26.1 UD43.L11
  IN2 w0.076: v8(124.41,47.65) 124.47,47.65 124.79,47.32 124.79,45.94 125.49,45.24 125.65,45.24 126.28,44.62 126.28,44.57 126.29,44.56
  IN2 w0.108: v8(141.78,26.02) 141.98,26.21 141.98,26.84 142.16,27.02 142.16,27.85 141.82,28.19 141.82,29.73 141.54,30.02 141.11,30.02 140.86,30.27 140.43,30.27 140.31,30.15 139.96,30.15 139.58,30.52 139.58,30.87 139.7,31 139.7,31.16 139.46,31.4 139.3,31.4 139.18,31.28 138.82,31.28 138.45,31.66 138.45,32.01 138.57,32.13 138.57,32.29 138.32,32.53 138.16,32.53 138.04,32.41 137.69,32.41 137.32,32.79 137.32,33.14 137.44,33.26 137.44,33.42 137.19,33.66 134.72,33.66 134.32,34.06 134.32,34.44 133.99,34.77 133.61,34.77 133.25,35.13 133.25,35.5 132.98,35.78 132.6,35.78 132.21,36.17 132.21,36.61 131.9,36.92 131.9,37.65 129.23,40.32 129.23,41.52 128.42,42.34 128.42,43.27 127.8,43.88 126.97,43.88 126.29,44.56
  BOTTOM w0.14: UCPU1.AR22 124.48,47.65 v8(124.41,47.65)
DDR_B_ODT0: length 78.5
  TOP w0.152: v8(124.91,23.51) 125.24,23.84 UD44.J8 ; RD74.1 132.2,15.81 132.46,16.07 132.46,16.71 133.22,17.47 133.22,18.31 133.55,18.64 133.55,20.92 134.11,21.48 v8(134.11,22.29)
  TOP w0.173: v8(141.14,23.63) 140.81,23.95 UD43.J8
  IN1 w0.114: v9(114.73,41.21) 114.73,40.61 115.69,39.65 115.69,37.45 115.41,37.17 115.41,37.04 115.54,36.9 115.68,36.9 115.91,37.14 116.05,37.14 116.18,37 116.18,36.87 115.72,36.41 115.72,36.27 115.85,36.14 115.99,36.14 116.45,36.6 116.59,36.6 116.72,36.46 116.72,36.33 116.26,35.87 116.26,35.73 116.39,35.6 116.53,35.6 116.99,36.06 117.12,36.06 117.26,35.92 117.26,35.79 116.71,35.24 116.71,35.1 116.84,34.97 116.98,34.97 117.53,35.52 117.66,35.52 117.8,35.38 117.8,35.25 117.2,34.65 117.2,34.51 117.33,34.38 117.47,34.38 118.07,34.98 118.2,34.98 118.34,34.85 118.34,34.71 117.72,34.1 117.72,33.96 117.86,33.83 117.99,33.83 118.61,34.44 118.74,34.44 118.9,34.28 118.9,34.15 118.69,33.94 118.69,33.81 118.83,33.67 118.96,33.67 119.17,33.88 119.3,33.88 119.49,33.7 122.27,33.7 122.36,33.79 122.36,34.17 122.46,34.26 122.65,34.26 122.74,34.17 122.74,33.73 122.84,33.64 123.03,33.64 123.12,33.73 123.12,34.16 123.22,34.26 123.41,34.26 123.51,34.16 123.51,33.73 123.6,33.64 123.79,33.64 123.89,33.73 123.89,34.18 123.98,34.27 125.58,34.27 125.97,33.89 125.97,33.48 125.82,33.32 125.82,32.91 126.16,32.57 126.35,32.57 126.47,32.44 126.47,32.27 126.85,31.9 129.87,31.9 133.83,27.93 133.83,23.97 134.41,23.4 134.41,23.04 134.41,22.7 134.41,22.69 134.41,22.58 v8(134.11,22.29)
  GND1 w0.152: v9(114.73,41.21) 114.73,41.22 114.72,41.22 v3(114.27,41.22)
  IN3 w0.095: v8(124.91,23.51) 125.49,22.93 125.65,22.77 129.48,22.77 129.8,22.44 131.86,22.44 132.19,22.77 133.64,22.77 v8(134.11,22.29) 134.91,22.29 135.27,22.65 135.69,22.65 135.87,22.83 135.87,23.08 135.96,23.17 136.16,23.17 136.25,23.08 136.25,22.74 136.35,22.65 136.54,22.65 136.63,22.74 136.63,23.08 136.73,23.17 136.92,23.17 137.01,23.08 137.01,22.74 137.11,22.65 137.3,22.65 137.39,22.74 137.39,23.08 137.49,23.17 137.68,23.17 137.77,23.08 137.77,22.74 137.87,22.65 140.16,22.65 v8(141.14,23.63)
  GND3 w0.152: v3(114.27,41.22) 114.39,41.34 114.48,41.34 v4(114.57,41.42)
  BOTTOM w0.076: UCPU1.BA42 114.14,44.01 114.39,43.76 114.39,43.44 114.13,43.18 114.13,41.86 v4(114.57,41.42)
DDR_CHA_EN: length 10.3
  BOTTOM w0.095: RH68.1 145.72,58.76 145.4,59.09 144.43,59.09 RH66.1 143.85,58.51 143.47,58.51 v2(142.97,59.01) 142.87,59.01 142.37,58.51 142.25,58.51 141.98,58.24 139.07,58.24 138.54,57.72 137.36,57.72 137.06,57.41 UCPU1.U2
DDR_CHB_EN: length 9.2
  BOTTOM w0.095: UCPU1.U1 138.57,57.41 139.18,58.02 142.58,58.02 142.92,57.68 v2(143.07,57.68) RH67.1 144.07,57.68 144.58,57.17 145.79,57.17 145.98,57.36 RH69.1
DDR_VTT_CNTL: length 81
  BOTTOM w0.076: UCPU1.AW67 98.95,45.54 98.8,45.69 96.8,45.69 95.74,44.63 95.74,42.45 94.16,40.86
  BOTTOM w0.095: 94.16,40.86 93,39.71 93,39.53 88.46,34.99 85.55,34.99 81.45,30.89 81.45,26.13 77.11,21.78 77.11,18.8 v2(78.83,17.07) 87.17,17.07 88.58,15.66 89.66,15.66 90.01,16.01 91.65,16.01 91.88,16.24 103.04,16.24 103.13,16.15 108.48,16.15 110.55,14.07 112.54,14.07 RC383.1 112.96,13.66 UC9.2
DDR_XDP_SMBCLK: length 144.3
  TOP w0.095: RC388.2 147.26,57.15 148.7,57.15 v2(149.04,56.81) v1(149.68,56.81)
  IN1 w0.076: v7(37.48,73.31) 37.74,73.57 37.74,73.99 38.49,74.74 79.2,74.74 80.98,72.96 82.09,72.96 83.81,74.69 137.71,74.69 139.08,73.32 143.89,73.32 145.52,71.69 147.31,71.69 150.33,68.67 150.33,64.78 152.14,62.97 152.14,59.86 151.35,59.07 151.35,58.06 150.43,57.14 149.86,57.14 149.68,56.96 v1(149.68,56.81)
  GND1 w0.095: v1(149.68,56.81) 149.55,56.94 149.41,56.94 v3(149.31,56.84)
  GND3 w0.095: v4(149.65,56.71) 149.65,56.73 149.54,56.84 v3(149.31,56.84)
  BOTTOM w0.095: QC1.1 144.1,53.47 144.43,53.14 RN2.2 145.33,52.65 146.12,52.65 146.98,53.51 147.4,53.51 149.69,55.8 149.69,56.67 v4(149.65,56.71)
DDR_XDP_SMBDAT: length 139.7
  TOP w0.095: v1(149.6,55.83) v2(149.15,55.39) 148.84,55.07 147.74,55.07 146.98,55.84 RC387.2
  IN1 w0.076: v7(38.08,73.31) 37.94,73.45 37.94,73.91 38.58,74.54 79.12,74.54 80.9,72.76 82.17,72.76 83.9,74.48 137.63,74.48 139,73.11 143.81,73.11 145.43,71.49 147.22,71.49 150.12,68.59 150.12,64.7 151.94,62.88 151.94,59.95 151.14,59.15 151.14,58.14 150.34,57.34 149.78,57.34 149.35,56.91 149.35,56.07 v1(149.6,55.83)
  GND1 w0.095: v1(149.6,55.83) 149.61,55.85 v3(149.61,56.19)
  GND3 w0.095: v3(149.61,56.19) 149.49,56.19 v4(149.3,56.38)
  BOTTOM w0.095: v4(149.3,56.38) 149.11,56.19 148.14,56.19 147.75,55.8 147.03,55.8 RN1.2 146.16,55.72 QC1.4
DEBUG_TX: length 9.8
  IN4 w0.076: v8(14.12,12.82) 14.12,12.89 14.44,13.21 16.88,13.21 16.93,13.16 17.22,13.16 17.49,12.89 17.49,12.71 17.93,12.28 18.58,12.28 19.24,11.61 19.96,11.61 20.22,11.87 v4(20.3,11.87)
  BOTTOM w0.095: RE203.2 11.93,13.48 11.94,13.47 RE209.2 13.34,13.47 13.99,12.82 v8(14.12,12.82)
DISPOFF#: length 314.2
  TOP w0.095: v7(85.13,11.55) 85.11,11.55 81.75,14.91 v2(80.51,14.91) 80.45,14.91 78.83,16.53 v1(78.83,16.59)
  IN1 w0.076: v7(85.13,11.55) 85.34,11.55 85.47,11.43 91.28,11.43 91.78,11.92 99.69,11.92 102.05,14.29 103.47,14.29 104.09,14.9 105.52,14.9 106.45,13.98 115.09,13.98 116.46,15.35 126.28,15.35 126.77,14.85 131.93,14.85 132.44,14.35 137.36,14.35 137.91,14.9 144.1,14.9 145.42,16.21 146.85,16.21 147.16,15.91 152.73,15.91 154.62,17.8 158.17,17.8 158.64,17.32 161.07,17.32 161.29,17.55 168.19,17.55 168.83,16.91 173.33,16.91 173.61,17.2 176.56,17.2 180.09,13.66 180.09,13.54 v9(180.3,13.33)
  GND1 w0.095: v3(78.72,16.28) 78.69,16.31 78.69,16.45 v1(78.83,16.59) ; v9(180.3,13.33) 180.3,13.08 v3(180.42,12.96)
  IN2 w0.064: v3(78.72,16.28) 79.08,15.92 79.08,13.54 76.58,11.04 75.27,11.04 74.81,10.58 71.13,10.58 70.42,9.87 60.52,9.87 59.44,10.94 57.72,10.94 57.3,11.36 55.39,11.36 52.78,13.97 45.39,13.97 42.59,16.77 39.86,16.77 36.42,20.21 36.42,24.71 37.62,25.91 37.62,28.57 37.42,28.77 37.42,35.68 37.08,36.01 36.52,36.01 36.08,36.46 36.08,39.31 36.99,40.23 38.27,40.23 39.29,41.25 39.29,42.26 39.09,42.46 39.09,43.56 39.67,44.13 39.67,50.21 41.08,51.62 v3(42.57,51.62)
  GND3 w0.095: v3(42.57,51.62) 42.67,51.51 v4(43.03,51.51) ; v3(180.42,12.96) 180.41,12.95 v6(180.41,12.55)
  IN4 w0.076: v6(180.41,12.55) 180.49,12.47 182.38,12.47 183.82,11.03 185.05,11.03 187.71,8.37 195.41,8.37 195.59,8.54 199.71,8.54 201.54,10.37 203.09,10.78 205.95,10.78 207.7,12.53 208.7,12.53 211.13,14.95 219.34,14.95 219.71,14.59 224.14,14.59 227.27,11.46 230.8,11.46 232.36,9.9 246.02,9.9 246.52,10.41 252.49,10.41 258.81,16.72 260.77,16.72 265.07,21.02 v5(265.8,21.02)
  BOTTOM w0.095: JCAM1.10 277.79,23.94 277.66,23.81 277.66,21.55 277.35,21.23 266.01,21.23 v5(265.8,21.02) ; D5.1 42.76,52.03 R13.1
DMIC_CLK_CODEC: length 326.3
  TOP w0.127: RA6.1 272.79,58.6 D10.2 272.75,56.45 v7(272.86,56.34)
  IN1 w0.127: v7(272.86,56.34) 275.94,53.27 v7(275.94,51.4) 275.94,51.4 275.94,36.86 277.18,35.63 277.18,31.88 277.73,31.33 277.73,27.87 v9(277.69,27.83)
  GND1 w0.127: v9(277.69,27.83) v3(277.69,27.45)
  IN2 w0.127: v8(16.76,4.96) 16.92,4.96 16.99,5.03 19.68,5.03 20.46,4.25 25.04,4.25 26.37,2.92 29.01,2.92 29.21,2.71 50.71,2.71 50.77,2.65 53.74,2.65 53.74,2.65 77.72,2.65 80.52,5.45 109.47,5.45 112.63,2.29 127.71,2.29 128.88,3.45 131.37,3.45 132.53,2.29 153.79,2.29 155.07,3.57 160.59,3.57 161.63,2.53 165.82,2.53 166.7,3.41 176.78,3.41 177.36,4 182.54,4 184.29,2.25 221.1,2.25 222.5,3.65 225.88,3.65 227.21,2.32 261.48,2.32 265.7,6.54 265.7,7.41 266.93,8.64 267.49,8.64 268.16,9.32 268.16,9.64 270.98,12.45 272.73,12.45 274.41,14.12 275.18,14.12 277.1,16.05 277.1,17.8 278.8,19.5 278.8,22.12 278.12,22.79 278.12,27.01 v3(277.69,27.45)
  BOTTOM w0.127: JKB1.11 16.18,8.59 16.01,8.42 16.01,5.79 16.76,5.03 v8(16.76,4.96)
DMIC_CLK_CODEC_R: length 1.9
  TOP w0.127: v8(272.75,61.39) 272.75,61.27 272.79,61.24 RA6.2
  BOTTOM w0.127: v8(272.75,61.39) 272.86,61.28 U5.5
DMIC_DAT12_CODEC: length 326.2
  TOP w0.127: RA5.1 271.72,58.6 D10.3 271.75,56.38 v7(271.74,56.37)
  IN1 w0.127: v7(271.74,56.37) 272.15,55.96 272.15,55.47 275.43,52.19 275.43,36.42 v7(276.14,35.71) 276.67,35.18 276.67,31.67 277.22,31.12 277.22,27.43 v9(277.23,27.41)
  GND1 w0.127: v3(277.23,27.78) 277.18,27.73 277.18,27.47 v9(277.23,27.41)
  IN2 w0.127: v8(16.89,5.59) 16.95,5.54 19.93,5.54 20.67,4.8 25.21,4.8 26.2,3.8 32.67,3.8 33.25,3.22 49.26,3.22 49.83,3.79 50.42,3.79 51.04,3.16 53.53,3.16 77.49,3.16 80.29,5.96 109.68,5.96 112.84,2.8 127.46,2.8 128.62,3.96 131.58,3.96 132.67,2.86 153.64,2.86 154.85,4.08 160.8,4.08 161.84,3.04 165.38,3.04 166.26,3.92 176.51,3.92 177.09,4.51 182.93,4.51 184.66,2.78 220.9,2.78 221.23,3.11 221.23,3.11 222.28,4.15 226.09,4.15 227.42,2.83 261.27,2.83 265.08,6.64 265.08,7.69 267.48,10.09 267.88,10.09 270.87,13.09 272.43,13.09 274.06,14.72 275.05,14.72 276.6,16.26 276.6,18.01 278.29,19.71 278.29,21.76 277,23.05 277,24.03 277.61,24.64 277.61,26.8 277.23,27.19 v3(277.23,27.78)
  BOTTOM w0.127: JKB1.10 16.68,6.85 16.89,6.64 v8(16.89,5.59)
DMIC_DAT12_CODEC_R: length 2.7
  TOP w0.127: v8(272.14,61.27) 271.72,60.85 RA5.2
  BOTTOM w0.127: U5.4 272.47,60.88 v2(272.46,60.87) 272.14,61.19 v8(272.14,61.27)
DMIC_DAT34_CODEC: length 330
  TOP w0.127: RA61.1 274.79,58.66 D73.3 274.8,57.93 274.49,57.62 CA83.1
  IN1 w0.127: v7(274.48,57.01) 274.51,56.98 274.6,56.98 274.96,56.62 274.96,55.2 v7(276.46,53.7) 276.46,53.7 276.46,37.14 277.68,35.92 277.68,32.09 278.23,31.55 v9(278.23,27.71)
  GND1 w0.127: v9(278.23,27.71) 278.24,27.71 279.02,27.71 v3(279.09,27.79)
  IN2 w0.127: v8(16.03,5.06) 15.83,4.85 15.83,4.31 16.13,4 17.96,4 18.49,4.53 19.45,4.53 20.24,3.74 24.83,3.74 26.2,2.38 27.45,2.38 27.85,1.97 31.82,1.97 32.04,2.2 50.39,2.2 50.45,2.15 53.95,2.15 77.93,2.15 80.73,4.94 109.25,4.94 112.41,1.78 127.95,1.78 129.11,2.94 131.15,2.94 132.32,1.78 154,1.78 155.28,3.06 160.38,3.06 161.42,2.03 166.03,2.03 166.86,2.86 177.16,2.86 177.79,3.49 182.33,3.49 184.08,1.74 221.31,1.74 222.71,3.14 225.67,3.14 227.07,1.74 262.24,1.74 268.05,7.56 268.05,8.21 271.79,11.94 273.27,11.94 274.81,13.49 275.3,13.49 277.61,15.8 277.61,17.59 279.31,19.29 279.31,22.39 278.63,23.07 278.63,27.33 v3(279.09,27.79)
  BOTTOM w0.127: JKB1.12 15.68,8.71 15.3,8.33 15.3,5.58 15.82,5.06 v8(16.03,5.06)
DMIC_DAT34_CODEC_R: length 1.1
  GND1 w0.127: v3(274.06,59.32) 273.85,59.52 v1(273.85,59.6)
  GND3 w0.127: v4(273.7,59.32) v3(274.06,59.32)
  BOTTOM w0.127: v4(273.7,59.32) 273.61,59.41 U5.1
DPEQ0: length 5.7
  TOP w0.095: U30.14 270.31,21.52 269.64,20.84 R51.1 269.17,19.95 269.17,18.92 R5800.1 269.71,18.5 270.42,17.79 R5801.2
DPEQ1: length 5
  TOP w0.095: v2(263.69,24.99) 264.03,25.33 264.03,25.72 R5797.1 264.46,25.57 265.46,25.57 R54.2 266.17,26.05 266.94,25.28 U30.2
DPSNK_RBIAS: length 7.3
  TOP w0.095: RT23.1 25.26,41.17 v2(25.66,41.56) 25.66,42.64 v1(25.04,43.26)
  GND1 w0.095: v1(25.04,43.26) 24.94,43.26 24.8,43.39 v3(24.72,43.39)
  GND3 w0.095: v3(24.72,43.39) v6(24.72,43.74)
  IN4 w0.076: v5(26.12,43.95) 26.1,43.98 24.95,43.98 v6(24.72,43.74)
  BOTTOM w0.076: UT2.Y18 26.79,44.64 26.79,44.07 26.71,43.99 26.17,43.99 v5(26.12,43.95)
DPSRC_RBIAS: length 4.2
  TOP w0.095: v1(23.53,50.96) 23.57,50.96 23.66,51.06 23.66,52.63 24.01,52.98 24.27,52.98 24.6,53.32 RT9.2
  GND1 w0.095: v1(23.53,50.96) 23.53,50.95 v3(24.09,50.39)
  GND3 w0.095: v3(24.09,50.39) 24.09,50.39 v4(23.84,50.15)
EC_I2C_CLK: length 278.6
  TOP w0.095: UE3.F7 v8(20.28,13.64)
  GND1 w0.095: v1(271.96,16.55) 271.96,16.36 271.73,16.14 v3(271.73,15.98)
  IN2 w0.064: v3(28.74,14.69) 28.83,14.6 28.83,13.62 31.87,10.58 33.06,10.58 34.7,8.95 47.05,8.95 47.47,9.38 51.62,9.38 54.22,6.79 70.95,6.79 71.46,6.28 76.2,6.28 79.16,9.24 106.69,9.24 107.65,10.19 109.26,10.19 111.09,12.02 121.13,12.02 122.07,12.97 136.56,12.97 137.02,13.43 144.86,13.43 145.39,12.9 148.34,12.9 150.38,10.86 151.84,10.86 152.93,11.95 157.32,11.95 157.66,11.62 157.66,11.01 159.69,8.98 161.42,8.98 162.64,7.76 166.86,7.76 170.03,4.59 176.14,4.59 176.72,5.18 183.28,5.18 185.01,3.45 220.63,3.45 222,4.82 226.42,4.82 227.74,3.51 260.8,3.51 264.28,6.99 264.28,8.09 268.06,11.87 268.46,11.87 270.84,14.25 271.65,14.25 272.3,14.91 272.3,15.91 272.2,16.01 271.78,16.01 271.76,15.98 v3(271.73,15.98)
  GND3 w0.095: v3(28.74,14.69) 28.73,14.67 28.73,14.53 v4(28.89,14.37)
  IN4 w0.076: v5(23.66,15.86) 22.7,15.86 22.35,15.51 22.02,15.51 20.28,13.77 v8(20.28,13.64)
  BOTTOM w0.095: v5(23.66,15.86) 24.39,15.86 24.68,15.58 24.68,15.17 25.07,14.78 25.77,14.78 26.07,15.08 27.51,15.08 RE243.1 28.35,15.89 v2(28.35,14.76) 28.35,14.68 28.66,14.37 v4(28.89,14.37)
EC_I2C_DAT: length 273.2
  TOP w0.095: RA25.2 272.87,16.67 v1(273.29,16.25)
  IN1 w0.076: v7(20.7,10.81) 21.26,10.81 22.24,9.84 26.07,9.84 v9(26.1,9.86)
  GND1 w0.095: v9(26.1,9.86) 26.15,9.92 26.15,10.52 v3(26.18,10.55) ; v1(273.29,16.25) 273,16.25 v3(272.95,16.2)
  IN2 w0.064: v3(30.04,10.7) 30.21,10.7 30.64,10.27 33.02,10.27 34.53,8.76 47.12,8.76 47.55,9.19 51.55,9.19 54.14,6.59 70.87,6.59 71.38,6.09 76.28,6.09 79.24,9.05 106.77,9.05 107.72,10 109.34,10 111.17,11.83 121.21,11.83 122.15,12.78 136.64,12.78 137.1,13.24 144.78,13.24 145.31,12.71 148.26,12.71 150.3,10.67 151.92,10.67 153.01,11.76 157.24,11.76 157.47,11.54 157.47,10.93 159.61,8.79 161.34,8.79 162.56,7.57 166.78,7.57 169.95,4.4 176.21,4.4 176.8,4.99 183.2,4.99 184.93,3.26 220.71,3.26 222.08,4.63 226.34,4.63 227.66,3.32 260.88,3.32 264.47,6.91 264.47,8.01 268.14,11.68 268.54,11.68 270.92,14.06 271.72,14.06 272.49,14.83 272.49,15.84 272.82,16.17 272.92,16.17 v3(272.95,16.2)
  GND3 w0.095: v3(30.04,10.7) 29.89,10.55 v4(28.88,10.55) ; v4(26.84,10.55) v3(26.18,10.55)
  BOTTOM w0.095: v4(26.84,10.55) 26.93,10.64 v2(27.76,10.64) 28.79,10.64 v4(28.88,10.55)
EDP_1: length 3
  BOTTOM w0.095: RR17.2 51.54,60.1 v2(51.47,60.17) 51.47,60.56 51.08,60.96 JEDP1.1
EDP_2: length 5.9
  BOTTOM w0.095: JEDP1.2 50.58,60.52 51.09,60 51.09,58.25 v2(51.35,58) RR16.2
EDP_3: length 6
  BOTTOM w0.095: RR15.2 50.87,56.52 50.87,59.77 50.08,60.56 JEDP1.3
EDP_AUXN: length 120.5
  IN3 w0.076: 113.37,64.45 113.37,64.43 113.28,64.33 113.28,64.16 112.87,63.75 112.35,63.75 112.22,63.63 112.22,63.32 v3(112.34,63.21)
  IN3 w0.089: 113.37,64.45 113.37,67.34 112.54,68.18 112.54,69.79 112.25,70.08 112.25,72.74 110.82,74.16 102.46,74.16 101.95,74.67 83.86,74.67 82.06,72.88 81.04,72.88 79.23,74.69 36.54,74.69 34.18,72.33 34.18,69.17 33.18,68.17 33.18,55.16 34.37,53.97 v3(35.12,53.97)
  GND3 w0.102: v3(35.12,53.97) 35.25,54.1 35.41,54.1 v4(35.5,54.02) ; v3(112.34,63.21) 112.12,63.21 112.02,63.31 112.02,63.48 v4(112.04,63.5)
  BOTTOM w0.102: C1060.1 41.38,55.25 40.95,54.82 40.1,54.82 39.3,54.02 v10(37.96,54.02) v4(35.5,54.02)
EDP_AUXN_C: length 0.6
  BOTTOM w0.102: C1060.2 R257.1
EDP_AUXN_CONN: length 4.3
  BOTTOM w0.102: JEDP1.22 40.58,61.11 40.44,60.97 40.44,60.61 40.79,60.26 41.18,59.87 v10(41.18,58.85) 41.18,58.1 R257.2
EDP_AUXP: length 120.5
  IN3 w0.076: v3(111.59,63.21) 111.3,63.21 111.23,63.13 111.23,62.92 111.3,62.84 111.87,62.84 111.97,62.94 111.97,63.36 112.06,63.45 112.06,63.7 112.28,63.92 112.8,63.92 113.11,64.23 113.11,64.33 113.02,64.43 113.02,64.45
  IN3 w0.089: 113.02,64.45 113.02,67.2 112.18,68.03 112.18,69.64 111.89,69.93 111.89,72.59 110.67,73.81 102.31,73.81 101.8,74.32 84,74.32 82.21,72.52 80.89,72.52 79.09,74.33 36.69,74.33 34.54,72.18 34.54,69.02 33.53,68.02 33.53,55.31 34.52,54.32 34.94,54.32 v3(35.12,54.5)
  GND3 w0.102: v3(111.59,63.21) 111.68,63.21 v4(112.04,62.85) ; v4(35.5,54.4) 35.43,54.33 35.29,54.33 v3(35.12,54.5)
  BOTTOM w0.102: C1057.1 40.74,55.86 40.86,55.75 41.06,55.75 41.15,55.65 41.15,55.35 40.85,55.05 40,55.05 39.2,54.25 v10(36.27,54.25) 35.7,54.25 35.55,54.4 v4(35.5,54.4)
EDP_AUXP_C: length 0.6
  BOTTOM w0.102: R258.1 C1057.2
EDP_AUXP_CONN: length 4.3
  BOTTOM w0.102: R258.2 40.95,58.11 40.95,59.78 40.22,60.51 40.22,60.95 40.08,61.08 JEDP1.23
EDP_BIA_PWM: length 250.2
  IN4 w0.076: v5(58.52,71.67) 53.48,71.67 42.46,60.65 42.46,57.69 42.6,57.55 42.6,56.06 40.03,53.49 39.44,53.49 37.06,51.11 37.06,47.41 36.7,47.05 36.7,39.72 37.32,39.1 37.32,38.41 37.74,38 37.74,31.69 38.32,31.11 38.32,27.27 36.29,25.25 36.29,23.82 36.81,23.31 36.81,21.85 36.62,21.66 36.62,21.25 36.71,21.16 36.71,20.25 36.64,20.18 36.64,15.65 39.29,13 39.46,13 39.46,13 47.39,13 48.58,11.81 50.64,11.81 52.46,9.98 56.18,9.98 56.36,10.15 57.37,10.15 57.69,9.84 61.4,9.84 61.48,9.76 61.48,9.76 61.56,9.68 66.99,9.68 67.67,9 73.72,9 74.61,9.89 74.61,10.5 75.29,11.18 77.57,11.18 78.49,12.11 79.43,12.11 80.84,13.52 82.08,13.52 83.21,14.65 113.16,14.65 114.01,15.5 119.32,15.5 121.22,15.5 121.31,15.41 123.68,15.41 123.8,15.54 131.35,15.54 131.5,15.4 138.06,15.4 138.59,15.93 144.71,15.93 145.12,16.34 147.29,16.34 147.48,16.14 149.05,16.14 150.89,17.99 150.89,28.33 151.4,28.84 151.4,30.77 149.22,32.94 149.22,33.71 148.65,34.28 148.65,34.74 148.9,34.99 148.9,38.03 149.5,38.63 149.5,46.86 143.6,52.77 143.6,54 141.52,56.07 138.18,56.07 137.71,56.53 135.29,56.53 134.85,56.98 133.78,56.98 133.35,56.54 132.48,56.54 131.97,57.06 131.97,57.72 v8(131.94,57.75)
  BOTTOM w0.095: D6.2 59.22,70.96 v2(58.92,71.27) v5(58.52,71.67)
  BOTTOM w0.112: v8(131.94,57.75) 131.58,58.11 UCPU1.R11
EDP_COMP: length 1.4
  TOP w0.508: RC8.2 107.72,63.74 v8(107.83,63.85)
  BOTTOM w0.254: v8(107.83,63.85) 108.19,63.5 UCPU1.E52
EDP_HPD: length 231.7
  TOP w0.095: v1(31.66,59.87) 31.28,60.25 RR22.1 v2(30.24,61.09) ; RC2.2 v8(132.64,59.75)
  GND1 w0.095: v1(31.66,59.87) v3(31.66,59.52)
  GND3 w0.095: v3(31.66,59.52) 31.6,59.46 v6(31.6,59.19)
  IN4 w0.076: v5(32.5,54.05) 34.89,51.66 34.89,39.26 35.43,38.72 35.43,33.81 35.9,33.35 35.9,26.91 34.86,25.88 34.86,23.36 35.38,22.84 35.38,20.54 35.64,20.29 35.64,13.15 35.92,12.87 35.92,12.75 36.33,12.34 47.1,12.34 48.24,11.2 50.39,11.2 52.21,9.37 56.53,9.37 56.7,9.54 57.12,9.54 57.43,9.23 61.14,9.23 61.23,9.14 61.24,9.14 61.3,9.07 66.73,9.07 67.42,8.39 73.97,8.39 75.75,10.17 76.19,10.17 76.59,10.57 77.82,10.57 78.75,11.5 79.96,11.5 81.37,12.91 90.62,12.91 91.2,12.33 99,12.33 99.67,13 100.73,13 101.3,13.57 102.08,13.57 102.56,14.04 113.43,14.04 114.28,14.89 119.57,14.89 119.57,14.89 120.97,14.89 121.06,14.8 123.93,14.8 124.06,14.93 131.1,14.93 131.24,14.79 138.31,14.79 138.84,15.32 149.09,15.32 151.5,17.73 151.5,26.18 152.21,26.89 152.21,31.11 150.03,33.29 150.03,35.19 149.72,35.51 149.72,37.68 150.32,38.29 150.32,44.49 150.7,44.87 150.7,47.14 144.68,53.16 144.68,55.26 142.75,57.2 141.04,57.2 140.5,57.73 137.38,57.73 136.53,58.58 136,58.58 135.73,58.86 134.42,58.86 133.93,59.35 133.05,59.35 v8(132.64,59.75) ; v5(32.5,55.85) 32.5,56.09 31.47,57.12 31.47,59.05 v6(31.6,59.19)
  BOTTOM w0.095: v5(32.5,55.85) 32.72,55.63 32.72,54.27 v5(32.5,54.05)
  BOTTOM w0.112: v8(132.64,59.75) 132.23,60.16 UCPU1.L10
EDP_HPD_R: length 5.9
  TOP w0.095: v2(34.56,62.63) 34.56,62.38 33.28,61.09 RR23.2 33.06,60.79 32.69,60.42 v1(32.27,60.42)
  GND1 w0.095: v3(32.4,60.1) 32.27,60.23 v1(32.27,60.42)
  GND3 w0.095: v3(32.4,60.1) v4(32.65,60.35)
  BOTTOM w0.095: v4(32.65,60.35) 33.08,60.78 JEDP1.37
EDP_TXN_P0: length 110.9
  IN3 w0.089: v3(110.53,65.69) 110.53,65.1 110.66,64.97 110.81,64.97 110.94,65.1 110.94,65.75 111.38,66.19 111.38,69.33 111.14,69.56 111.14,72.12 110.2,73.06 101.25,73.06 100.74,73.57 84.28,73.57 82.51,71.8 80.59,71.8 78.81,73.58 37.46,73.58 36.42,72.53 36.42,69.28 34.42,67.29 34.42,55.67 34.6,55.49 36.72,55.49 37.08,55.13 37.38,55.13 v3(37.59,55.35)
  GND3 w0.102: v3(37.59,55.35) 37.79,55.14 38.08,55.14 38.19,55.24 v4(38.19,55.25) ; v4(110.61,64.92) 110.74,65.05 110.74,65.48 v3(110.53,65.69)
  BOTTOM w0.102: v4(38.19,55.25) 38.19,55.23 38.29,55.13 38.92,55.13 39.68,55.89 39.68,56.01 39.58,56.12 C1055.1
EDP_TXN_P0_C: length 0.6
  BOTTOM w0.102: R14.1 C1055.2
EDP_TXN_P0_CONN: length 4.4
  BOTTOM w0.102: R14.2 39.54,58.16 v10(39.54,58.88) 39.54,59.42 38.72,60.25 38.72,61.01 38.58,61.15 JEDP1.26
EDP_TXN_P1: length 97.1
  IN3 w0.076: 108.44,70.19 108.44,70.17 108.34,70.07 108.34,69.94 108.8,69.48 108.8,68.27 109.55,67.52 109.55,66.62 110.15,66.02 110.15,64.97 110.94,64.18 111.21,64.18 v3(111.53,64.5)
  IN3 w0.089: 108.44,70.19 108.44,70.44 107.73,71.15 101.71,71.15 101.17,70.6 94.52,70.6 94.08,70.16 92.53,70.16 92.19,70.5 91.22,70.5 90.17,71.56 86.89,71.56 86.38,71.05 84.88,71.05 84.55,70.72 84.55,70.1 84.41,69.96 79.83,69.96 78.2,71.59 54.15,71.59 51.04,68.48 44.85,68.48 42.01,65.64 37.77,65.64 37.02,64.89 37.02,61.68 37.32,61.38 37.73,61.38 37.82,61.29 37.82,60.94 37.73,60.85 37.32,60.85 37.02,60.55 37.02,59.9 37.32,59.6 37.73,59.6 37.82,59.51 37.82,59.16 37.73,59.07 37.32,59.07 37.02,58.77 37.02,57.8 37.78,57.05 37.78,56.55 v3(37.71,56.48)
  GND3 w0.102: v4(111.17,64.6) 111.43,64.6 v3(111.53,64.5) ; v3(37.71,56.48) 37.63,56.41 v4(37.63,56.12)
EDP_TXN_P1_C: length 0.6
  BOTTOM w0.102: R256.1 C1064.2
EDP_TXN_P1_CONN: length 4.3
  BOTTOM w0.102: JEDP1.29 37.08,61.07 37.22,60.94 37.22,60.43 v10(37.54,60.11) 37.83,59.82 37.83,58.1 R256.2
EDP_TXN_P2: length 99.1
  IN3 w0.089: v3(36.36,56.47) 36.36,57.3 36.2,57.46 36.2,58.84 36.12,58.93 35.89,58.93 35.59,59.22 35.59,59.87 35.89,60.17 36.12,60.17 36.2,60.26 36.2,60.62 36.12,60.7 35.89,60.7 35.59,61 35.59,61.65 35.89,61.95 36.12,61.95 36.2,62.04 36.2,62.39 36.12,62.48 35.89,62.48 35.59,62.78 35.59,63.43 35.89,63.73 36.12,63.73 36.2,63.82 36.2,64.17 36.12,64.26 35.89,64.26 35.59,64.56 35.59,65.74 37.21,67.35 39.46,67.35 42.1,69.98 51.41,69.98 53.78,72.35 78.48,72.35 80.14,70.69 82.97,70.69 84.08,71.81 86.07,71.81 86.66,72.4 90.39,72.4 91.43,71.35 96.14,71.35 96.51,71.72 97.22,71.72 97.55,71.4 97.97,71.4 98.29,71.72 99,71.72 99.32,71.4 100.87,71.4 101.37,71.9 108.13,71.9 109.56,70.48 109.56,68.91 v3(109.62,68.86)
  GND3 w0.102: v4(109.27,68.81) 109.32,68.86 v3(109.62,68.86) ; v4(36.36,56.12) v3(36.36,56.47)
  BOTTOM w0.076: UCPU1.A45 111.74,66.13 111.65,66.04 111.5,66.04 111.43,66.12 111.43,67.97 110.78,68.62 109.46,68.62 v4(109.27,68.81)
EDP_TXN_P2_C: length 0.6
  BOTTOM w0.102: R260.1 C1056.2
EDP_TXN_P2_CONN: length 4.4
  BOTTOM w0.102: R260.2 36.6,58.15 v10(36.6,58.81) 36.6,59.31 35.72,60.2 35.72,60.9 35.58,61.04 JEDP1.32
EDP_TXN_P3: length 101.3
  IN3 w0.089: v3(110.94,67.28) 110.94,68.81 110.71,69.03 110.71,71.83 109.88,72.67 101.01,72.67 100.5,73.17 94.87,73.17 94.58,72.88 94.58,72.65 94.49,72.56 94.13,72.56 94.04,72.65 94.04,72.88 93.75,73.17 92.23,73.17 91.6,72.54 91.31,72.54 90.7,73.15 84.38,73.15 82.65,71.42 80.44,71.42 78.72,73.14 48.14,73.14 45.89,70.89 44.33,70.89 43.8,71.42 39.65,71.42 38.84,70.61 38.84,70.19 39.27,69.76 39.27,69.29 38.38,68.41 36.16,68.41 34.85,67.1 34.85,57.76 35.05,57.56 35.05,56.6 v3(34.92,56.47)
  GND3 w0.102: v4(34.9,56.12) 34.9,56.31 34.92,56.33 v3(34.92,56.47) ; v4(110.97,66.75) 110.88,66.84 110.88,67.23 v3(110.94,67.28)
  BOTTOM w0.076: UCPU1.A47 110.61,66.1 110.69,66.03 110.85,66.03 110.97,66.14 110.97,66.31 110.73,66.54 110.73,66.67 110.82,66.75 v4(110.97,66.75)
EDP_TXN_P3_C: length 0.6
  BOTTOM w0.102: R262.1 C1062.2
EDP_TXN_P3_CONN: length 4.4
  BOTTOM w0.102: JEDP1.35 34.08,61.04 34.22,60.9 34.22,60.4 34.76,59.85 34.76,59.57 35.1,59.24 v10(35.1,58.88) 35.1,58.1 R262.2
EDP_TXP_P0: length 110.9
  IN3 w0.089: v3(37.59,54.78) 36.93,54.78 36.58,55.14 34.45,55.14 34.06,55.52 34.06,67.43 36.06,69.43 36.06,72.68 37.31,73.93 78.96,73.93 80.73,72.16 82.36,72.16 84.13,73.92 100.89,73.92 101.4,73.42 110.35,73.42 111.5,72.27 111.5,69.71 111.73,69.48 111.73,65.98 v3(111.38,65.63)
  GND3 w0.102: v3(37.59,54.78) 37.72,54.91 38.09,54.91 v4(38.17,54.83) ; v4(111.17,65.25) 111.08,65.25 110.97,65.36 110.97,65.51 111.13,65.68 111.34,65.68 v3(111.38,65.63)
  BOTTOM w0.102: C1058.1 39.91,55.98 39.91,55.8 v10(39.32,55.2) 39.01,54.9 38.24,54.9 v4(38.17,54.83)
EDP_TXP_P0_C: length 0.6
  BOTTOM w0.102: R15.1 C1058.2
EDP_TXP_P0_CONN: length 4.4
  BOTTOM w0.102: R15.2 39.77,58.19 39.77,59.52 v10(39.16,60.13) 38.94,60.34 38.94,61 39.08,61.13 JEDP1.25
EDP_TXP_P1: length 97.1
  IN3 w0.076: 108.08,70.19 108.08,70.17 108.18,70.07 108.18,69.87 108.64,69.41 108.64,68.2 109.39,67.45 109.39,66.55 109.98,65.95 109.98,64.9 110.87,64.01 111.28,64.01 111.4,64.13 111.76,64.13 112.06,64.43 v3(112.06,64.74)
  IN3 w0.089: v3(38.24,56.51) 38.13,56.62 38.13,57.2 37.38,57.95 37.38,58.63 37.47,58.71 37.88,58.71 38.17,59.01 38.17,59.66 37.88,59.96 37.47,59.96 37.38,60.05 37.38,60.4 37.47,60.49 37.88,60.49 38.17,60.79 38.17,61.44 37.88,61.74 37.47,61.74 37.38,61.83 37.38,64.74 37.92,65.29 42.16,65.29 44.99,68.12 51.19,68.12 54.3,71.23 78.06,71.23 79.69,69.6 84.56,69.6 84.9,69.95 84.9,70.57 85.03,70.7 86.53,70.7 87.04,71.21 90.02,71.21 91.07,70.15 92.04,70.15 92.38,69.81 94.23,69.81 94.67,70.25 101.32,70.25 101.86,70.79 107.58,70.79 108.08,70.29 108.08,70.19
  GND3 w0.102: v4(38.27,56.12) 38.27,56.44 38.24,56.46 v3(38.24,56.51) ; v3(112.06,64.74) 111.92,64.74 v4(111.74,64.92)
EDP_TXP_P1_C: length 0.6
  BOTTOM w0.102: C1063.2 R259.1
EDP_TXP_P1_CONN: length 4.3
  BOTTOM w0.102: JEDP1.28 37.58,61.11 37.44,60.97 37.44,60.53 37.7,60.27 38.06,59.91 v10(38.06,58.82) 38.06,58.12 R259.2
EDP_TXP_P2: length 99.1
  IN3 w0.089: v3(109.62,68.27) 109.29,68.27 109.2,68.36 109.2,70.33 107.98,71.55 101.51,71.55 101.01,71.05 99.18,71.05 98.86,71.37 98.44,71.37 98.11,71.05 97.4,71.05 97.08,71.37 96.66,71.37 96.29,71 91.29,71 90.24,72.04 86.81,72.04 86.21,71.45 84.23,71.45 83.11,70.34 79.99,70.34 78.33,72 53.92,72 51.56,69.63 42.24,69.63 39.61,66.99 37.35,66.99 35.95,65.59 35.95,64.7 36.04,64.62 36.26,64.62 36.56,64.32 36.56,63.67 36.26,63.37 36.04,63.37 35.95,63.28 35.95,62.93 36.04,62.84 36.26,62.84 36.56,62.54 36.56,61.89 36.26,61.59 36.04,61.59 35.95,61.5 35.95,61.15 36.04,61.06 36.26,61.06 36.56,60.76 36.56,60.11 36.26,59.81 36.04,59.81 35.95,59.73 35.95,59.37 36.04,59.28 36.26,59.28 36.56,58.98 36.56,57.61 36.72,57.45 36.72,56.59 36.85,56.46 v3(37,56.46)
  GND3 w0.102: v3(109.62,68.27) 109.37,68.27 v4(109.27,68.37) ; v4(37,56.12) v3(37,56.46)
  BOTTOM w0.076: UCPU1.B45 111.74,65.68 111.54,65.88 111.43,65.88 111.26,66.05 111.26,67.89 v10(110.94,68.21) 110.7,68.45 109.36,68.45 v4(109.27,68.37)
EDP_TXP_P2_C: length 0.6
  BOTTOM w0.102: R261.1 C1061.2
EDP_TXP_P2_CONN: length 4.4
  BOTTOM w0.102: R261.2 36.83,58.07 36.83,59.41 v10(36.18,60.05) 35.94,60.29 35.94,60.96 36.08,61.09 JEDP1.31
EDP_TXP_P3: length 101.3
  IN3 w0.089: v3(110.15,67.28) 110.15,67.07 110.36,66.86 110.53,66.86 110.62,66.95 110.62,67.07 110.55,67.15 110.55,67.4 110.58,67.44 110.58,68.66 110.36,68.89 110.36,71.69 109.73,72.31 100.87,72.31 100.36,72.82 95.02,72.82 94.93,72.73 94.93,72.5 94.64,72.21 93.98,72.21 93.69,72.5 93.69,72.73 93.6,72.82 92.38,72.82 91.74,72.18 91.16,72.18 90.55,72.79 84.53,72.79 82.8,71.07 80.29,71.07 78.57,72.78 48.29,72.78 46.04,70.54 44.19,70.54 43.65,71.07 39.79,71.07 39.19,70.46 39.19,70.34 39.62,69.91 39.62,69.15 38.53,68.05 36.31,68.05 35.2,66.95 35.2,57.91 35.41,57.71 35.41,56.61 v3(35.54,56.48)
  GND3 w0.102: v4(35.54,56.12) v3(35.54,56.48) ; v3(110.15,67.28) 110.45,66.98 v4(110.45,66.77)
  BOTTOM w0.076: v4(110.45,66.77) 110.52,66.69 110.52,66.56 110.33,66.37 110.33,65.94 110.61,65.66 UCPU1.B47
