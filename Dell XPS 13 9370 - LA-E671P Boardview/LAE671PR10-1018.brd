# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_USB3_RX1_P: length 14.4
  TOP w0.102: JUSBC1.B11 6.43,49.09 arc(6.54,49.12) v8(6.63,49.17)
  BOTTOM w0.089: 16.47,46.44 16.49,46.43 16.5,46.4 16.63,46.32 arc(16.89,46.24) 17.17,46.22 17.58,46.22 arc(17.65,46.23) 17.71,46.27 17.77,46.33 arc(17.85,46.39) 17.95,46.41 18.21,46.41 arc(18.31,46.33) 18.29,46.21 arc(18.25,46.18) 18.2,46.17 UT2.A15
  BOTTOM w0.102: v8(6.63,49.17) 6.75,49.05 arc(6.83,49) 6.92,48.98 7.21,48.98 arc(7.37,49.01) 7.5,49.1 7.84,49.44 arc(7.94,49.51) 8.06,49.53 8.13,49.53 arc(8.32,49.57) 8.49,49.68 D34.1 arc(8.79,49.62) 9.05,49.57 9.22,49.57 arc(9.56,49.51) 9.84,49.32 11.57,47.6 arc(11.99,47.31) 12.48,47.22 13.7,47.22 arc(15.14,47.02) 16.47,46.44
TBT_USB3_RX2_N: length 21.3
  TOP w0.102: JUSBC2.A10 8.39,61.3 arc(8.4,61.3) 8.4,61.3 arc(8.4,61.3) 8.41,61.3 8.41,61.29 arc(8.66,61.24) 8.88,61.09 9.24,60.74 arc(9.32,60.67) 9.41,60.61 D43.1 9.67,60.55 arc(9.63,60.49) 9.61,60.42 9.61,60.26 arc(9.63,60.19) 9.67,60.12 10.35,59.45 10.73,59.07 arc(11.26,58.28) 11.44,57.35 11.44,53.56 arc(11.89,51.3) 13.17,49.39 14.57,47.99 arc(15.38,47.45) 16.33,47.26 16.44,47.26 arc(16.64,47.34) v8(16.72,47.53)
  BOTTOM w0.089: v8(16.72,47.53) 16.74,47.51 arc(16.89,47.39) 17.06,47.3 arc(17.1,47.29) 17.15,47.28 arc(17.25,47.26) 17.36,47.25 arc(17.36,47.25) 17.37,47.25 17.77,47.25 arc(17.79,47.25) 17.82,47.27 arc(17.88,47.31) 17.95,47.32 18.12,47.32 arc(18.16,47.32) 18.21,47.32 arc(18.24,47.31) 18.28,47.3 arc(18.41,47.25) 18.52,47.16 UT2.B13
TBT_USB3_RX2_P: length 21.3
  TOP w0.102: JUSBC2.A11 7.96,60.8 arc(8.04,60.81) 8.11,60.86 8.26,61 arc(8.32,61.05) 8.4,61.06 arc(8.57,61.03) 8.72,60.93 9.07,60.58 arc(9.11,60.53) 9.13,60.46 9.13,60.43 D41.1 9.3,60.02 arc(9.39,60) 9.49,59.97 9.55,59.91 9.57,59.91 10.19,59.28 10.57,58.9 arc(11.05,58.19) 11.21,57.35 11.21,53.56 arc(11.68,51.21) 13,49.23 14.41,47.83 arc(15.29,47.24) 16.33,47.03 16.43,47.03 arc(16.6,47) v8(16.74,46.9)
  BOTTOM w0.089: UT2.A13 18.18,47.09 arc(18.24,47.08) 18.29,47.04 arc(18.31,46.98) 18.29,46.92 arc(18.23,46.88) 18.15,46.86 18.03,46.86 arc(17.94,46.88) 17.87,46.93 17.82,46.97 arc(17.71,47.04) 17.58,47.07 17.45,47.07 17.37,47.07 arc(17.36,47.07) 17.35,47.07 arc(17.23,47.08) 17.11,47.1 16.94,47.1 arc(16.8,47.05) v8(16.74,46.9)
TBT_USB3_RX3_N: length 26
  TOP w0.102: v8(6.54,65.16) arc(6.49,65.2) 6.42,65.21 6.2,65.21 arc(5.98,65.17) JUSBC2.B10
  BOTTOM w0.089: UT2.A7 18.18,49.85 arc(18.27,49.81) 18.31,49.72 arc(18.28,49.64) 18.2,49.61 18,49.61 arc(17.95,49.62) 17.91,49.65 17.77,49.79 arc(17.7,49.84) 17.63,49.87 17.58,49.88 arc(17.58,49.88) 17.57,49.88 17.56,49.88 arc(17.54,49.88) 17.52,49.88 17.29,49.88
  BOTTOM w0.102: 17.29,49.88 14.62,49.88 arc(14.28,49.95) 13.99,50.14 12.91,51.22 arc(12.58,51.72) 12.46,52.31 12.46,54.73 arc(12.52,55.02) 12.68,55.27 12.95,55.54 arc(13.06,55.69) 13.09,55.88 13.09,57.87 arc(13.02,58.25) 12.8,58.58 10.3,61.07 arc(9.99,61.54) 9.88,62.1 9.88,64.84 arc(9.84,64.98) 9.78,65.1 arc(9.77,65.1) 9.77,65.1 arc(9.77,65.11) 9.76,65.11 9.66,65.22 arc(9.6,65.26) 9.53,65.29 arc(9.47,65.29) 9.41,65.3 arc(9.24,65.25) 9.1,65.16 D48.1 arc(8.8,65.29) 8.5,65.35 7,65.35 arc(6.76,65.3) v8(6.54,65.16)
TBT_USB3_RX3_P: length 26
  TOP w0.102: JUSBC2.B11 6.01,65.55 arc(6.3,65.6) v8(6.54,65.77)
  BOTTOM w0.089: 17.29,50.11 17.85,50.11 arc(17.87,50.1) 17.89,50.09 arc(17.91,50.08) 17.92,50.08 18.23,50.08 arc(18.35,50.05) 18.46,49.98 UT2.B7
  BOTTOM w0.102: 17.29,50.11 14.62,50.11 arc(14.36,50.16) 14.15,50.3 13.07,51.38 arc(12.79,51.81) 12.69,52.31 12.69,54.73 arc(12.73,54.94) 12.84,55.11 13.11,55.38 arc(13.27,55.61) 13.32,55.88 13.32,57.92 arc(13.23,58.39) 12.96,58.79 10.47,61.28 arc(10.2,61.68) 10.11,62.15 10.11,64.86 arc(10.06,65.05) 9.96,65.23 arc(9.94,65.25) 9.93,65.27 9.82,65.38 arc(9.71,65.46) 9.58,65.51 arc(9.49,65.52) 9.4,65.52 arc(9.3,65.54) 9.22,65.59 D50.1 arc(8.86,65.62) 8.63,65.58 7,65.58 arc(6.76,65.63) v8(6.54,65.77)
TBT_USB3_TX0_N: length 10.1
  TOP w0.102: v8(6.55,45.09) JUSBC1.B3
  BOTTOM w0.102: v8(6.55,45.09) 6.68,45.09 arc(6.82,45.07) 6.94,44.99 6.98,44.95 6.99,44.94 7.02,44.9 7.05,44.88 7.08,44.85 7.09,44.84 7.22,44.7 7.85,44.08 arc(7.94,44.01) 8.04,43.97 arc(8.09,43.96) 8.15,43.95 arc(8.33,43.99) 8.49,44.09 D26.1 arc(8.79,43.99) 9.07,43.93 arc(9.07,43.93) 9.08,43.93 14.76,43.93 arc(15.02,43.99) CT45.2
TBT_USB3_TX0_N_C: length 3
  BOTTOM w0.089: UT2.B19 18.49,44.43 18.49,44.43 arc(18.35,44.52) 18.19,44.55 17.79,44.55
  BOTTOM w0.102: 17.79,44.55 17.53,44.55 arc(17.34,44.52) 17.18,44.41 17.01,44.24 arc(16.85,44.13) 16.66,44.1 15.93,44.1 arc(15.88,44.11) CT45.1
TBT_USB3_TX0_P: length 10.1
  TOP w0.102: JUSBC1.B2 6.33,44.59 arc(6.44,44.57) v8(6.54,44.51)
  BOTTOM w0.102: v8(6.54,44.51) arc(6.65,44.65) 6.82,44.7 arc(6.91,44.68) 6.98,44.63 7.06,44.54 7.06,44.54 7.69,43.92 arc(7.82,43.81) 7.98,43.75 arc(8.06,43.73) 8.15,43.72 arc(8.33,43.69) 8.48,43.59 D24.1 8.6,43.57 arc(8.75,43.67) 8.93,43.71 14.76,43.71 arc(15.02,43.65) CT43.2
TBT_USB3_TX0_P_C: length 3
  BOTTOM w0.089: 17.76,44.28 17.91,44.14 arc(17.96,44.1) 18.02,44.09 18.09,44.09 arc(18.13,44.1) 18.17,44.12 18.22,44.17 arc(18.24,44.23) 18.22,44.28 18.2,44.3 arc(18.17,44.32) UT2.A19
  BOTTOM w0.102: CT43.1 15.92,43.59 arc(16.23,43.8) 16.59,43.87 16.66,43.87 arc(16.94,43.92) 17.17,44.08 17.34,44.24 arc(17.43,44.3) 17.53,44.32 17.66,44.32 arc(17.72,44.31) 17.76,44.28
TBT_USB3_TX1_N: length 9.4
  TOP w0.102: JUSBC1.A3 7.7,48.34 arc(7.81,48.37) 7.91,48.43 8.04,48.55 arc(8.12,48.6) 8.21,48.61 10.84,48.61 arc(10.91,48.6) 10.97,48.56 11.5,48.03 arc(11.56,47.94) 11.58,47.83 D33.1 arc(11.79,47.47) 11.97,47.35 13.2,46.12 arc(13.27,46.01) 13.3,45.89 13.3,45.83 v8(13.3,45.83)
  BOTTOM w0.102: CT41.2 arc(14.8,45.16) 14.59,45.2 14.38,45.2 arc(14.12,45.26) 13.9,45.4 13.6,45.7 arc(13.46,45.8) v8(13.3,45.83)
TBT_USB3_TX1_N_C: length 3.2
  BOTTOM w0.089: 17.77,45.02 18.3,45.02 arc(18.36,45.04) 18.42,45.07 UT2.B17
  BOTTOM w0.102: 17.77,45.02 17.28,45.02 arc(17.02,45.08) 16.79,45.23 arc(16.73,45.27) 16.65,45.28 16.09,45.28 arc(16.08,45.28) 16.07,45.28 arc(15.8,45.2) CT41.1
TBT_USB3_TX1_P: length 9.4
  TOP w0.102: JUSBC1.A2 7.54,48.84 10.84,48.84 arc(10.99,48.81) 11.13,48.72 11.79,48.06 arc(11.79,48.06) 11.8,48.06 arc(11.85,48.01) 11.91,47.99 12.03,47.96 D35.1 12.03,47.88 arc(12.08,47.63) 12.22,47.42 13.21,46.43 arc(13.35,46.34) 13.51,46.31 v8(13.68,46.31)
  BOTTOM w0.102: v8(13.68,46.31) 13.68,46.05 arc(13.7,45.96) 13.75,45.88 14.06,45.56 arc(14.21,45.47) 14.38,45.43 14.64,45.43 arc(14.73,45.45) 14.81,45.5 CT39.2
TBT_USB3_TX1_P_C: length 3.2
  BOTTOM w0.089: UT2.A17 18.16,45.25 arc(18.22,45.26) 18.27,45.29 arc(18.3,45.37) 18.27,45.44 18.27,45.44 arc(18.22,45.47) 18.17,45.48 18.03,45.48 arc(17.94,45.47) 17.87,45.41 17.78,45.33
  BOTTOM w0.102: CT39.1 15.64,45.61 arc(15.78,45.51) 15.95,45.48 16.65,45.48 arc(16.8,45.45) 16.93,45.36 arc(17.09,45.25) 17.28,45.21 17.52,45.21 arc(17.65,45.24) 17.77,45.31 17.78,45.33
TBT_USB3_TX2_N: length 16.3
  TOP w0.102: JUSBC2.B3 6.17,61.55 arc(6.36,61.51) v8(6.51,61.4)
  BOTTOM w0.102: v8(6.51,61.4) 6.6,61.32 arc(6.75,61.22) 6.92,61.18 7.02,61.18 arc(7.24,61.14) 7.42,61.02 7.94,60.49 arc(8.01,60.44) 8.08,60.41 arc(8.33,60.46) 8.55,60.6 D42.1 arc(8.66,60.53) 8.78,60.5 8.99,60.5 arc(9.33,60.43) 9.63,60.24 9.7,60.17 arc(10.55,58.89) 10.85,57.39 10.85,50.5 arc(10.91,50.17) 11.1,49.89 11.84,49.15 arc(11.9,49.11) CT46.2
TBT_USB3_TX2_N_C: length 6.6
  BOTTOM w0.089: 16.35,48.21 16.37,48.21 16.39,48.18 17.78,48.18 arc(17.85,48.2) 17.9,48.23 arc(17.92,48.24) 17.95,48.24 18.24,48.24 arc(18.35,48.22) 18.44,48.16 UT2.B11
  BOTTOM w0.102: CT46.1 12.37,48.64 arc(12.4,48.49) 12.49,48.36 arc(12.66,48.25) 12.86,48.21 16.35,48.21
TBT_USB3_TX2_P: length 16.3
  TOP w0.102: JUSBC2.B2 5.88,61.05 arc(6.21,60.98) v8(6.49,60.79)
  BOTTOM w0.102: CT44.2 11.56,48.85 arc(11.52,49.09) 11.38,49.29 10.94,49.73 arc(10.7,50.08) 10.62,50.5 10.62,57.39 arc(10.34,58.81) 9.53,60.01 9.47,60.08 arc(9.25,60.22) 8.99,60.27 arc(8.88,60.25) 8.79,60.19 arc(8.76,60.17) 8.73,60.14 D40.1 8.48,60.03 arc(8.34,60.12) 8.18,60.15 arc(8.09,60.16) 8,60.18 arc(7.9,60.24) 7.8,60.31 7.26,60.85 arc(7.16,60.92) 7.05,60.94 6.86,60.94 arc(6.66,60.9) v8(6.49,60.79)
TBT_USB3_TX2_P_C: length 6.6
  BOTTOM w0.089: 16.35,47.98 16.37,47.98 16.39,48.01 17.51,48.01 arc(17.63,47.98) 17.74,47.91 17.76,47.89 arc(17.87,47.82) 18,47.79 18.13,47.79 arc(18.16,47.8) 18.19,47.82 arc(18.22,47.89) 18.19,47.96 18.18,47.97 UT2.A11
  BOTTOM w0.102: CT44.1 12.1,48.29 arc(12.22,48.27) 12.33,48.2 arc(12.57,48.04) 12.86,47.98 16.35,47.98
TBT_USB3_TX3_N: length 23.8
  TOP w0.102: JUSBC2.A3 7.98,64.8 arc(8.02,64.8) 8.05,64.82 8.13,64.9 arc(8.17,64.93) 8.21,64.93 arc(8.26,64.94) 8.31,64.95 arc(8.52,65.03) 8.7,65.16 arc(9.01,65.38) 9.39,65.45 11.59,65.45 arc(11.62,65.45) 11.65,65.45 arc(11.84,65.39) 12.01,65.28 12.19,65.1 arc(12.22,65.06) 12.24,65.01 12.24,64.93 arc(12.21,64.8) D49.1 12.19,64.69 arc(12.57,64.61) 12.89,64.4 13.19,64.1 arc(13.51,63.62) 13.63,63.05 13.63,58.55 arc(13.55,58.17) 13.33,57.84 12.94,57.45 arc(12.83,57.38) 12.71,57.35 12.46,57.35 arc(12.36,57.37) 12.28,57.43 arc(12.24,57.49) 12.22,57.56 arc(12.25,57.72) 12.34,57.85 v8(12.36,57.87)
  BOTTOM w0.102: v8(12.36,57.87) 12.34,57.85 arc(12.28,57.8) 12.22,57.76 arc(12.21,57.75) 12.2,57.75 12.12,57.71 arc(12.07,57.69) 12.03,57.69 arc(11.83,57.65) 11.67,57.54 11.57,57.44 arc(11.5,57.33) 11.47,57.21 11.47,51.39 arc(11.54,51.01) 11.73,50.68 12.22,50.19 arc(12.32,50.04) CT42.2
TBT_USB3_TX3_N_C: length 6.1
  BOTTOM w0.089: 16.55,49.01 16.57,49.01 16.58,49.02 17.29,49.02 arc(17.37,49.01) 17.44,48.96 17.48,48.93 17.67,48.81 17.7,48.79 18,48.71 18.04,48.7 18.24,48.7 18.33,48.73 UT2.B9
  BOTTOM w0.102: CT42.1 13.18,49.22 13.41,49.08 arc(13.53,49.03) 13.67,49.01 16.55,49.01
TBT_USB3_TX3_P: length 23.9
  TOP w0.102: v8(12.36,56.86) 12.56,57.07 arc(12.57,57.08) 12.58,57.09 arc(12.63,57.11) 12.69,57.12 12.71,57.12 arc(12.92,57.17) 13.1,57.29 13.49,57.68 arc(13.76,58.08) 13.85,58.55 13.85,63.05 arc(13.73,63.7) 13.36,64.26 12.89,64.73 arc(12.73,64.96) D51.1 arc(12.52,65.25) 12.37,65.3 arc(12.26,65.36) 12.17,65.44 arc(11.94,65.6) 11.67,65.68 arc(11.63,65.68) 11.59,65.68 9.39,65.68 arc(8.93,65.59) 8.53,65.33 arc(8.41,65.23) 8.26,65.17 8.17,65.17 arc(8.1,65.19) 8.04,65.23 arc(7.96,65.28) 7.88,65.3 JUSBC2.A2
  BOTTOM w0.102: CT40.2 arc(12.44,50.4) 12.14,50.6 11.9,50.83 arc(11.75,51.09) 11.7,51.39 11.7,57.21 arc(11.71,57.25) 11.73,57.28 11.83,57.38 arc(11.92,57.44) 12.03,57.46 arc(12.07,57.46) 12.11,57.47 12.21,57.47 arc(12.25,57.46) 12.28,57.44 12.36,57.36 arc(12.42,57.27) 12.44,57.16 12.44,57.07 arc(12.42,56.96) v8(12.36,56.86)
TBT_USB3_TX3_P_C: length 6.1
  BOTTOM w0.089: 16.55,49.24 16.56,49.24 16.6,49.2 17.29,49.2 arc(17.44,49.17) 17.57,49.09 arc(17.58,49.08) 17.59,49.07 arc(17.61,49.06) 17.63,49.05 arc(17.63,49.04) 17.64,49.04 arc(17.64,49.04) 17.65,49.04 arc(17.65,49.04) 17.66,49.04 17.71,49.03 arc(17.71,49.03) 17.72,49.03 arc(17.72,49.03) 17.73,49.03 arc(17.77,49.04) 17.8,49.06 17.87,49.14 arc(17.9,49.16) 17.94,49.16 18.21,49.16 arc(18.26,49.15) 18.3,49.13 arc(18.32,49) 18.21,48.93 18.13,48.93 UT2.A9
  BOTTOM w0.102: 16.55,49.24 13.67,49.24 arc(13.6,49.25) 13.53,49.28 13.3,49.42 arc(13.19,49.55) 13.18,49.72 arc(13.19,49.82) CT40.1
THERMATRIP1#: length 4.3
  TOP w0.095: UE3.B12 15.55,10.46 14.92,10.46 13.83,9.36 13.83,8.54 14.14,8.24 RE124.1
THERMATRIP2#: length 23.6
  TOP w0.095: v1(23.1,15.62) 23.1,15.72 23.47,16.09 23.47,16.61 23.62,16.76 23.88,16.76 23.89,16.75 24.03,16.89 24.04,16.89 24.22,17.08 24.22,17.09 24.3,17.17 24.3,18.16 24.5,18.36 24.56,18.36 24.56,18.36 24.85,18.36 24.85,18.36 24.94,18.36 25.22,18.64 26.08,18.64 v2(26.23,18.8) 26.82,19.39 CE86.1 RE215.2
  GND1 w0.095: v3(23.05,16.06) 23.1,16.01 v1(23.1,15.62)
  IN3 w0.064: v3(23.05,16.06) 23.52,16.06 24,16.54 24,17.76 23.6,18.17 23.6,19.1 23.02,19.67 21.57,19.67 19.98,21.27 19.16,21.27 16.83,23.6 16.83,23.79 15.84,24.78 v3(15.84,25.69)
  GND3 w0.095: v3(15.84,25.69) 15.92,25.69 16.01,25.79 16.01,25.9 v4(16.23,26.12)
TOP_MUX_N: length 40.9
  TOP w0.102: v1(284.42,50) ML6.1
  GND1 w0.102: v3(283.96,50.03) 283.99,50 v1(284.42,50)
  IN3 w0.089: v3(287.39,19.13) 287.58,19.13 287.97,19.53 287.97,21.23 288.55,21.8 288.55,22.65 288.46,22.74 288.46,26.58 292.84,30.96 292.84,33.1 291.88,34.06 291.88,35.74 288.29,39.33 286.59,39.33 282.56,43.35 282.56,49.23 283.25,49.92 283.84,49.92 v3(283.96,50.03)
  GND3 w0.102: v4(287.52,18.83) 287.52,19.01 v3(287.39,19.13)
TOP_MUX_N_R: length 3.6
  TOP w0.102: JUSBC3.A7 288.59,50.55 288.45,50.42 288.21,50.42 287.88,50.09 287.88,49.95 287.71,49.78 287.54,49.78 D70.1 287.21,50.06 287.01,49.86 286.82,49.86 286.67,50 ML6.2
TOP_MUX_P: length 41
  TOP w0.102: v1(284.42,49.5) ML6.4
  GND1 w0.102: v3(283.97,49.45) 284.02,49.5 v1(284.42,49.5)
  IN3 w0.089: v3(283.97,49.45) 283.85,49.56 283.4,49.56 282.92,49.08 282.92,43.5 286.73,39.68 288.44,39.68 292.23,35.89 292.23,34.21 293.2,33.25 293.2,30.81 288.82,26.43 288.82,22.89 288.9,22.8 288.9,21.66 288.33,21.08 288.33,19.38 287.69,18.75 287.69,18.62 287.82,18.5 v3(287.82,18.47)
  GND3 w0.102: v4(287.52,18.33) 287.67,18.48 287.82,18.48 v3(287.82,18.47)
TOP_MUX_P_R: length 3.5
  TOP w0.102: JUSBC3.A6 288.62,50.05 288.49,50.19 288.3,50.19 288.11,49.99 288.11,49.86 287.8,49.55 287.39,49.55 D68.1 287.06,49.63 286.78,49.63 286.66,49.5 ML6.3
TOUCH_SCREEN_PD#: length 111.4
  IN4 w0.076: v5(137.94,69.96) 137.94,71.13 134.27,74.8 108.85,74.8 108.35,74.3 96.02,74.3 94.94,73.22 94.29,73.22 93.95,73.56 91.36,73.56 91.06,73.86 86.69,73.86 85.32,72.5 83.7,72.5 82.94,71.74 80.08,71.74 78.35,73.47 60.51,73.47 v5(60.42,73.38)
  BOTTOM w0.095: UCPU1.A7 134.04,66.53 134.89,67.38 135.27,67.38 135.48,67.59 136.8,67.59 137.94,68.73 v5(137.94,69.96) ; v5(60.42,73.38) v2(60.42,72.43) 61.24,71.61 61.24,67.2 60.46,66.42 58.77,66.42 58.71,66.48 52.79,66.48 52.25,65.95 52.25,64.29 50.67,62.71 49.33,62.71 49.08,62.46 JEDP1.5
TOUCHPAD_INTR#: length 7.6
  BOTTOM w0.095: UCPU1.BA5 135.38,43.86 135.38,43.51 135.65,43.25 135.94,43.25 136.42,42.77 139.95,42.77 141.06,41.66 RC379.1
TP_INTR#: length 231.3
  TOP w0.095: v7(162.85,16.42) 162.43,16.83 v2(162.43,23.02) 162.43,26.18 164.32,28.07 164.32,32.47 165.81,33.95 v8(166.1,33.95)
  IN1 w0.076: v9(142.4,42.68) 142.4,43.83 144.31,45.74 147.2,45.74 147.88,45.07 150.06,45.07 150.24,45.25 154.18,45.25 156.18,43.25 156.18,40.8 159.12,37.86 160.07,37.86 160.26,37.68 160.26,37.68 162.41,35.53 162.57,35.53 164.02,34.07 165.98,34.07 v8(166.1,33.95) ; v7(162.85,16.42) 162.71,16.28 156.65,16.28 156.27,15.89 153.34,15.89 152.95,15.5 146.84,15.5 146.66,15.32 145.11,15.32 144.27,14.49 138.09,14.49 137.53,13.94 132.27,13.94 131.77,14.45 126.6,14.45 126.11,14.94 116.63,14.94 114.47,12.78 109.48,12.78 108.6,11.91 106.02,11.91 104.12,10.01 80.43,10.01 76.05,5.63 73.2,5.63 72.9,5.34 70.85,5.34 70.84,5.35 70.73,5.35 70.23,5.84 66.1,5.84 65.7,6.24 60.77,6.24 60.19,6.82 52.21,6.82 47.77,11.26 35.38,11.26 35.21,11.43 31.83,11.43 31.2,12.06 30.71,12.06 29.67,13.1 29.67,14.3 29.97,14.61 29.97,15.03 29.11,15.89 v7(28.46,15.89)
  GND1 w0.095: v3(141.52,42.88) 142.2,42.88 v9(142.4,42.68)
  GND3 w0.095: v4(141.26,42.58) 141.26,42.63 v3(141.52,42.88)
  BOTTOM w0.095: JTP1.5 176.58,8.93 175.78,9.72 R117.2 175.78,10.93 176.88,12.02 176.88,13.21 177.66,13.99 177.66,15.42 177.4,15.69 176.58,15.69 176.28,15.99 176.28,18.96 172.42,22.82 172.42,24.96 170.59,26.8 170.59,30.5 167.76,33.32 166.84,33.32 166.21,33.95 v8(166.1,33.95)
TP_PW_EN: length 165.9
  TOP w0.095: UE3.H9 18.32,15.62 18.71,16 v8(18.71,16.02)
  IN1 w0.076: v8(18.71,16.02) 19.67,16.02 20.04,15.64 21.39,15.64 21.93,15.1 22.47,15.1 22.7,14.87 22.7,14.76 22.94,14.52 23.29,14.52 23.52,14.74 24.17,14.74 24.74,14.17 26.2,14.17 28.3,12.07 29.39,12.07 30.52,10.94 31.45,10.94 31.56,10.82 34.95,10.82 35.13,10.65 47.43,10.65 51.87,6.21 59.94,6.21 60.52,5.63 63.01,5.63 63.83,4.82 69.08,4.82 69.17,4.73 73.16,4.73 73.45,5.02 76.3,5.02 80.15,8.86 99.06,8.86 99.59,9.4 104.37,9.4 106.27,11.3 108.86,11.3 109.55,11.98 114.27,11.98 116.82,14.53 125.84,14.53 126.33,14.04 131.6,14.04 132.1,13.53 137.7,13.53 138.26,14.08 147.14,14.08 147.55,14.48 156.67,14.48 157.24,15.06 161.22,15.06 v9(161.56,14.71)
  GND1 w0.095: v9(161.56,14.71) v3(161.56,14.33)
  GND3 w0.095: v3(161.56,14.33) 161.57,14.34 162.38,14.34 v4(162.48,14.44)
  BOTTOM w0.095: v4(162.48,14.44) 162.48,14.27 162.68,14.08 162.68,11.03 v2(162.88,10.83) 163.29,10.42 R270.2 162.31,9.86 161.94,9.49 161.94,7.56 161.73,7.36 161.73,6.15 162.07,5.8 U10.2
TPM_DET: length 2.6
  TOP w0.095: v1(134.32,50.51) RH72.1
  GND1 w0.095: v1(134.32,50.51) 134.32,50.5 v3(134.58,50.24)
  GND3 w0.095: v3(134.58,50.24) 134.74,50.39 v4(135.21,50.39)
  BOTTOM w0.076: UCPU1.AM5 134.9,50.09 v4(135.21,50.39)
TPM_PIRQ#: length 72
  IN1 w0.076: v9(151.68,46.48) 152.74,46.48 153.45,45.78 154.23,45.78 156.62,43.38 156.62,40.93 159.29,38.27 160.24,38.27 160.42,38.08 160.43,38.08 162.58,35.93 162.73,35.93 164.18,34.48 165.25,34.48 165.53,34.77 166.3,34.77 166.59,34.48 166.59,33.68 v8(166.21,33.3)
  GND1 w0.095: v3(151.08,46.61) 151.21,46.48 v9(151.68,46.48)
  GND3 w0.095: v3(151.08,46.61) 150.49,46.61 150.47,46.59 v6(150.41,46.59)
  IN4 w0.076: v5(135.21,58.56) 135.27,58.56 135.35,58.48 135.69,58.48 135.85,58.33 136.38,58.33 137.22,57.49 140.41,57.49 140.92,56.97 141.83,56.97 144.44,54.36 144.44,53.09 150.41,47.12 v6(150.41,46.59)
  BOTTOM w0.076: UCPU1.M3 136.11,60.06 135.25,59.2 135.25,58.61 v5(135.21,58.56)
  BOTTOM w0.095: U7.18 174.89,15.14 175.01,15.26 175.01,16.19 175.41,16.59 RH75.2 175.57,16.59 176,17.02 176,18.93 174.95,19.98 v2(174.14,19.98) 174.14,20.78 172.2,22.73 172.2,24.87 170.36,26.71 170.36,30.41 167.67,33.1 166.41,33.1 v8(166.21,33.3)
TS_I2C_RST#: length 137.1
  IN1 w0.076: v9(120.5,60.1) 120.5,60.58 120.35,60.73 120.35,61.61 121.07,62.33 121.07,62.71 120.78,63 119.29,63 118.23,64.07 112.54,64.07 110.55,66.06 110.55,66.78 110.18,67.15 105.69,67.15 105.54,67.01 99.48,67.01 99.05,67.44 98.12,67.44 97.76,67.09 93.94,67.09 92.65,68.38 92.65,69.13 90.22,71.56 86.88,71.56 84.79,69.47 79.33,69.47 77.65,71.15 58.29,71.15 57.86,70.72 51.95,70.72 51.75,70.51 45.44,70.51 44.95,71 44.02,71 43.21,70.19 43.21,68.98 43.72,68.47 44.11,68.47 46.6,65.98 51.25,65.98 52.74,64.49 52.74,60.9 51.42,59.58 45.8,59.58 45.55,59.33 v9(45.55,58.56)
  GND1 w0.095: v3(45.27,58.29) v9(45.55,58.56) ; v9(120.5,60.1) v3(120.5,59.69)
  IN2 w0.064: v3(120.5,59.69) 120.66,59.53 120.66,53.64 120.83,53.46 121.18,53.46 122.28,52.36 126.63,52.36 127.01,52.75 130.64,52.75 130.89,52.49 131.3,52.49 131.58,52.21 131.58,50.91 132.46,50.04 132.86,50.04 133.02,49.88 133.02,49.2 132.76,48.95 v8(132.62,48.95)
  GND3 w0.095: v4(44.87,58.12) 45.11,58.12 v3(45.27,58.29)
  BOTTOM w0.112: UCPU1.AN8 132.98,49.31 v8(132.62,48.95)
TYPE_ID: length 7.7
  TOP w0.095: v1(24.09,14.38) 24.09,14.21 UE3.F2
  GND1 w0.095: v1(24.09,14.38) 24.14,14.33 v3(24.47,14.33)
  GND3 w0.095: v4(24.82,14.33) v3(24.47,14.33)
  BOTTOM w0.095: v4(24.82,14.33) 24.85,14.3 26.14,14.3 26.37,14.54 v2(26.48,14.54) 27.09,14.54 27.76,13.87 29.1,13.87 29.36,13.61 CE78.1 30,13.6 RE196.1
UART1_RXD: length 31.4
  TOP w0.095: RH65.2 149.87,46.98 v1(149.29,46.4) 149.58,46.11 v2(150.74,46.11) 158.97,46.11 161.4,43.68 JUART1.3
  GND1 w0.095: v1(149.29,46.4) 149.09,46.6 v3(148.98,46.6)
  GND3 w0.095: v6(148.25,46.55) 148.6,46.55 148.65,46.59 148.97,46.59 v3(148.98,46.6)
  IN4 w0.076: v5(139.85,53.76) 140.4,53.2 140.59,53.2 141.19,52.6 141.19,51.75 141.93,51.01 141.93,50.68 144.24,48.37 144.73,48.37 145.79,47.31 147.49,47.31 v6(148.25,46.55)
  BOTTOM w0.095: UCPU1.AC1 137.86,54.09 137.95,54 139.4,54 139.65,53.76 v5(139.85,53.76)
UART1_TXD: length 33.9
  TOP w0.095: RH64.2 148.98,46.25 v1(149.26,45.96) 149.45,45.78 158.81,45.78 v2(159.88,44.7) 161.7,42.88 JUART1.2
  GND1 w0.095: v1(149.26,45.96) 149.24,45.98 148.97,45.98 v3(148.91,46.04)
  GND3 w0.095: v6(148.2,45.74) 148.61,45.74 v3(148.91,46.04)
  IN4 w0.076: v5(140.75,52.62) 140.83,52.62 140.98,52.48 140.98,51.68 141.67,50.99 141.67,50.03 141.88,49.82 142.49,49.82 144.06,48.25 144.06,47.16 145.22,46 147.95,46 v6(148.2,45.74)
  BOTTOM w0.076: v5(140.75,52.62) 139.94,53.44 139.69,53.44 139.3,53.82 137.88,53.82 137.8,53.9 137.52,53.9 137.39,53.84 137.1,53.84 137.09,53.85 136.9,53.85 136.66,54.09 UCPU1.AC2
UART_MISO: length 25.8
  TOP w0.076: 20,34.54 19.83,34.37 19.71,34.37 19.23,33.89 19.23,33.06 U19.F2
  TOP w0.095: 20,34.54 20,36.17 20.82,36.99 R5748.2 v2(20.82,38.2) 20.82,38.34 21.4,38.92 24.4,38.92 27.48,42 29.44,42 32.13,39.32 v7(32.13,39.03) ; v7(31.81,34.73) 32.02,34.95 U20.E2
  IN1 w0.076: v7(31.81,34.73) 31.8,34.73 31.8,36.29 32.61,37.09 32.61,38.43 32.13,38.91 v7(32.13,39.03)
UART_MOSI: length 25
  TOP w0.076: U19.E2 19.73,33.06 19.73,33.19 19.73,33.2 19.73,33.2 19.73,33.47 19.63,33.57 19.63,33.81 19.8,33.98 20.43,33.98 20.87,34.42
  TOP w0.095: v7(31.79,39.22) 29.23,41.78 28.07,41.78 v2(27.74,41.45) 27.53,41.25 27.04,41.25 24.48,38.69 21.5,38.69 21.28,38.47 21.28,36.81 20.92,36.45 20.92,35.39 R5750.2 20.87,34.42
  IN1 w0.076: v7(31.79,39.22) 31.82,39.19 31.82,38.91 32.39,38.34 32.39,37.28 31.52,36.41 v7(31.52,35.04)
UPD1_ALERT#: length 27.7
  TOP w0.095: v8(17.11,14.43) 17.5,14.04 UE3.F10
  IN1 w0.076: v9(12.72,20.72) 12.72,21.01 13.97,22.26 15,22.26 16.2,23.47 16.2,24.36 16.35,24.51 17.68,24.51 18.04,24.87 18.04,26.25 18.41,26.63 18.83,26.63 20.73,28.53 20.73,28.73 21.46,29.47 21.46,30.32 v7(20.98,30.81)
  GND1 w0.095: v3(12.94,20.23) 12.72,20.45 v9(12.72,20.72)
  IN2 w0.064: v3(12.56,16.66) 12.56,17.75 12.94,18.12 v3(12.94,20.23)
  IN3 w0.064: v3(12.56,16.66) 12.39,16.48 12.39,15.22 12.98,14.62 13.2,14.62 13.85,13.98 16.66,13.98 v8(17.11,14.43)
  GND3 w0.095: v4(12.56,17.02) v3(12.56,16.66)
UPD1_SMBCLK: length 43.2
  TOP w0.095: v8(22.71,11.19) 22.71,11.24 23.09,11.61 UE3.C3
  GND1 w0.095: v3(14.04,34.48) 13.91,34.6 13.43,34.6 v1(13.27,34.45) ; v3(20.9,30.97) 20.98,31.04 v1(20.98,31.31)
  IN2 w0.064: v3(14.04,34.48) 14.18,34.62 14.52,34.62 14.68,34.46 14.68,33.64 15.7,32.62 20.38,32.62 21.08,31.92 21.08,31.14 v3(20.9,30.97)
  IN3 w0.064: v3(20.9,30.97) 20.9,30.92 21.57,30.26 21.78,30.26 23.83,28.21 24.38,28.21 24.85,27.73 24.85,26.56 25.07,26.34 25.07,23.24 26.91,21.4 26.91,16.1 25.15,14.34 25.15,13.67 22.71,11.24 v8(22.71,11.19) 22.65,11.12 22.6,11.12 22.31,10.83 22.31,10.05 23.05,9.3 25.01,9.3 25.62,9.92 v3(25.62,9.94)
  GND3 w0.095: v4(25.47,10.27) 25.62,10.11 v3(25.62,9.94)
  BOTTOM w0.095: v4(25.47,10.27) 25.47,10.13 25.96,9.63 RE107.1
UPD1_SMBDAT: length 42.5
  TOP w0.095: UE3.B4 v8(22.67,10.45)
  GND1 w0.095: v3(21.46,30.97) 21.48,30.99 v1(21.48,31.31) ; v3(14.05,35.02) 13.59,35.02 v1(13.27,35.34)
  IN2 w0.064: v3(14.05,35.02) 14.26,34.81 14.6,34.81 14.87,34.54 14.87,33.72 15.78,32.81 20.46,32.81 21.27,32 21.27,31.17 v3(21.46,30.97)
  IN3 w0.064: v3(21.46,30.97) 21.46,30.63 21.65,30.45 21.86,30.45 23.91,28.4 24.46,28.4 25.04,27.81 25.04,26.64 25.26,26.42 25.26,23.32 27.1,21.48 27.1,16.02 25.34,14.26 25.34,13.59 25.15,13.4 25.15,12.47 23.55,10.87 23.1,10.87 v8(22.67,10.45) 22.99,10.45 23.39,10.05 24.97,10.05 v3(25.08,9.94)
  GND3 w0.095: v4(25.08,10.27) v3(25.08,9.94)
  BOTTOM w0.095: v4(25.08,10.27) 25.08,10.03 v2(25.57,9.54) 26.37,8.74 RE105.1
UPD2_ALERT#: length 35.2
  IN1 w0.076: v9(25.35,29.47) 25.51,29.63 25.51,30.13 25.59,30.21 28.62,30.21 30.12,31.7 31.16,31.7 31.88,32.42 31.88,32.82 32.37,33.32 32.64,33.32 32.74,33.22 33.35,33.22 v7(33.52,33.04)
  GND1 w0.095: v1(21.5,14.01) 21.21,13.73 v3(21.13,13.73) ; v9(25.35,29.47) 25.35,29.41 25.12,29.18 v3(25.12,29.11)
  IN3 w0.064: v3(25.12,29.11) 25.39,28.83 25.39,26.67 25.64,26.43 25.64,23.64 27.41,21.87 27.41,16.75 v3(27.5,16.67)
  GND3 w0.095: v4(26.71,16.64) 27.47,16.64 v3(27.5,16.67) ; v3(21.13,13.73) 21.26,13.85 v6(21.47,13.85)
  IN4 w0.076: v4(26.71,16.64) 25.99,15.92 25.27,15.92 23.84,14.5 22.12,14.5 v6(21.47,13.85)
  BOTTOM w0.095: RE109.1 28.25,16.82 27.79,17.28 26.95,17.28 26.71,17.04 v4(26.71,16.64) 26.43,16.36 v2(26.29,16.36)
UPD2_SMBCLK: length 46.9
  TOP w0.095: v8(20.31,12.83) 20.31,12.82 UE3.D7 ; v1(25.19,36.33) 25.55,36.68 R208.1
  GND1 w0.095: v1(33.52,33.54) 33.77,33.79 33.78,33.79 v3(33.81,33.82) ; v1(25.19,36.33) 25.19,35.91 v3(25.27,35.82)
  IN2 w0.064: v3(33.81,33.82) 33.81,34.08 33.53,34.36 33.53,35.72 33.34,35.92 31.09,35.92 29.62,34.45 28.45,34.45 26.9,36 25.46,36 v3(25.27,35.82) ; v8(20.31,12.83) 20.7,12.45 22.19,12.45 22.63,12.89 24.59,12.89 24.67,12.81 v8(26.14,12.81)
  IN3 w0.064: v8(26.14,12.81) 26.14,14.35 28.05,16.26 28.05,17.12 27.86,17.31 27.86,22.05 26.13,23.78 26.13,26.59 25.85,26.87 25.85,29.55 24.02,31.38 24.02,34.56 v3(25.27,35.82)
  BOTTOM w0.095: v8(26.14,12.81) 26.15,12.83 RPE4.3
UPD2_SMBDAT: length 50.3
  TOP w0.095: UE3.E7 19.51,13.61 v8(19.51,13.63) ; v1(34.45,33.83) 34.42,33.83 34.13,33.54 U20.A5 ; R210.1 25.35,37.57 v2(24.87,37.1) 24.8,37.02 v1(24.8,36.31)
  GND1 w0.095: v1(34.45,33.83) 34.45,33.48 v3(34.41,33.43) ; v3(24.7,35.86) 24.89,36.05 24.89,36.22 v1(24.8,36.31)
  IN2 w0.064: v8(25.7,13.22) 25.68,13.25 22.08,13.25 22.07,13.25 21.75,13.25 21.74,13.25 20.07,13.25 19.68,13.63 v8(19.51,13.63) ; v3(24.7,35.86) 25.03,36.19 26.97,36.19 28.53,34.64 29.54,34.64 31.01,36.11 33.42,36.11 33.72,35.8 33.72,34.43 34.19,33.97 34.19,33.65 v3(34.41,33.43)
  IN3 w0.064: v3(24.7,35.86) 24.7,35.57 23.83,34.7 23.83,31.3 25.66,29.47 25.66,26.79 25.94,26.51 25.94,23.7 27.67,21.97 27.67,17.23 27.86,17.05 27.86,16.45 25.94,14.53 25.94,13.47 v8(25.7,13.22)
  BOTTOM w0.095: v8(25.7,13.22) 25.81,13.33 RPE4.4
UPD3_ALERT#: length 291.3
  TOP w0.095: v1(31.04,11.51) 30.64,11.51 RE231.1
  IN1 w0.076: v1(31.04,11.51) 30.55,11.51 28.51,13.55 28.13,13.55 27.14,14.54 26.7,14.54 26.43,14.81 25.08,14.81 24.27,15.62 v7(23.9,15.62)
  GND1 w0.095: v3(31.59,11.49) 31.06,11.49 v1(31.04,11.51)
  IN3 w0.064: v3(31.59,11.49) 32.24,10.84 32.24,8.59 32.95,7.88 32.95,6.73 36.43,3.25 49.35,3.25 49.96,3.86 50.75,3.86 51.38,3.23 58.15,3.23 58.52,2.87 77.6,2.87 79.82,5.08 109.75,5.08 113.81,9.14 134.98,9.14 135.46,9.62 139.61,9.62 139.98,9.25 143.53,9.25 v3(144.12,8.66)
  GND3 w0.095: v6(144.6,9.33) 144.6,9.14 v3(144.12,8.66)
  IN4 w0.076: v4(287.06,14.71) 286.75,15.03 286.15,15.03 286.07,14.95 285.96,14.95 285.96,14.95 285.72,14.95 285.72,14.95 284.63,14.95 283.77,14.09 282.49,14.09 281.55,15.03 280.84,15.03 279.5,16.37 277.43,16.37 277.28,16.52 275.84,16.52 273.46,14.14 267.7,14.14 266.79,15.05 264.72,15.05 261.93,12.26 257.23,12.26 255.52,10.55 254.92,10.55 253.91,9.54 250.22,9.54 249.5,8.82 226.17,8.82 223.67,11.32 219.7,11.32 217.36,13.66 211.78,13.66 206.72,8.61 202.51,8.61 200.52,6.61 196.39,6.61 196.21,6.44 186.22,6.44 184.33,8.34 176.95,8.34 174.73,10.57 170.47,10.57 170.01,11.03 167.68,11.03 167.23,11.49 165.51,11.49 165.05,11.03 162.52,11.03 161.13,9.64 159.88,9.64 157.78,7.54 153.93,7.54 153.16,8.31 153.16,9.1 152.94,9.32 144.61,9.32 v6(144.6,9.33)
  BOTTOM w0.095: v4(287.06,14.71) 287.45,14.32 U21.B6
UPD3_SMBCLK: length 326.9
  TOP w0.095: v8(21.94,18.43) 22.3,18.79 UE3.M4 ; R55.2 276.55,18.69 v10(276.55,17.06) 276.55,16.7 277.36,15.89 277.36,15.7 277.63,15.43 277.73,15.43 v1(277.74,15.42)
  GND1 w0.095: v1(277.74,15.42) 277.75,15.43 277.96,15.43 v3(278.09,15.3)
  IN2 w0.064: v3(26.43,12.07) 26.78,12.43 27.47,12.43 27.68,12.22 27.68,11.78 30.54,8.92 32.93,8.92 34.57,7.28 52.57,7.28 53.7,6.15 70.69,6.15 71.19,5.65 76.46,5.65 79.39,8.57 108.53,8.57 111.35,11.39 122.84,11.39 123.45,12 148.34,12 150.87,9.47 152.29,9.47 v3(152.38,9.56)
  GND3 w0.095: v4(278.87,15.79) 278.46,15.39 278.33,15.39 278.25,15.3 v3(278.09,15.3) ; v3(26.43,12.07) 26.69,12.33 v4(26.8,12.33) ; v6(152.19,8.9) 152.25,8.97 152.25,9.37 152.38,9.5 v3(152.38,9.56)
  IN4 w0.076: v5(287.02,14.32) 287.14,14.32 287.34,14.13 287.34,13.74 286.87,13.27 286.53,13.27 285.56,12.3 284.69,12.3 284.08,11.69 283.48,11.69 283.21,11.96 v5(283.21,12.03) 283.21,12.75 282.81,13.16 282.07,13.16 279.34,15.89 278.94,15.89 278.87,15.81 v4(278.87,15.79) 278.65,15.57 277.58,15.57 277.09,16.06 276.06,16.06 273.68,13.68 267.51,13.68 266.6,14.59 264.91,14.59 262.1,11.78 257.39,11.78 255.71,10.09 255.11,10.09 254.1,9.08 250.41,9.08 249.69,8.37 225.73,8.37 223.24,10.86 218.94,10.86 216.6,13.2 211.96,13.2 206.87,8.11 202.66,8.11 200.71,6.16 196.57,6.16 196.4,5.98 186.04,5.98 184.48,7.54 175.71,7.54 173.15,10.1 170.23,10.1 169.75,10.58 167.43,10.58 166.99,11.02 165.74,11.02 165.29,10.57 162.74,10.57 161.31,9.15 160.09,9.15 158.01,7.07 155.2,7.07 154.72,6.6 153.03,6.6 152.19,7.44 v6(152.19,8.9) ; v8(21.94,18.43) 21.94,18.59 22.49,19.14 23.52,19.14 23.97,18.69 24.71,18.69 25.08,19.06 26.35,19.06 27.24,18.17 27.24,12.82 26.84,12.43 26.84,12.38 v4(26.8,12.33)
  BOTTOM w0.095: v5(283.21,12.03) 283.21,11.95 282.4,11.14 281.75,11.14 281.31,11.59 R5819.2 280.66,11.59 R5816.2 ; R236.1 284.58,21.64 281.21,21.64 279.92,20.35 279.92,18.79 278.84,17.72 278.84,15.82 v4(278.87,15.79) 278.68,15.6 278.68,13.77 278.42,13.51 278.42,13.31 278.04,12.93 277.31,12.93 276.57,13.68 276.57,14.54 276.4,14.7 QC2.6
UPD3_SMBDAT: length 322.7
  TOP w0.095: v1(277.75,15.82) 277.7,15.87 277.7,15.88 276.78,16.8 276.78,18.69 277.1,19.02 R56.2 ; v8(20.31,18.38) 20.31,18.53 20.02,18.82 UE3.M7
  GND1 w0.095: v3(278.07,15.87) 277.79,15.87 v1(277.75,15.82)
  IN2 w0.064: v3(152.68,9.06) 152.35,9.06 152.13,9.28 150.79,9.28 148.26,11.81 123.53,11.81 122.92,11.2 111.43,11.2 108.61,8.38 79.47,8.38 76.54,5.46 71.11,5.46 70.61,5.96 53.62,5.96 52.49,7.09 34.49,7.09 32.85,8.73 30.46,8.73 27.29,11.9 v3(27.29,12.01)
  GND3 w0.095: v3(27.29,12.01) 27.11,11.83 v4(26.89,11.83) ; v3(152.68,9.06) 152.66,9.04 152.66,8.71 v6(152.66,8.71) ; v3(278.07,15.87) v4(278.45,15.87)
  IN4 w0.076: v5(287.02,13.82) 287.02,13.82 287.02,13.72 286.78,13.48 286.45,13.48 285.48,12.5 284.61,12.5 284,11.89 283.69,11.89 v5(283.6,11.99) 283.6,12.07 283.41,12.25 283.41,12.84 282.89,13.36 282.15,13.36 279.42,16.09 278.67,16.09 v4(278.45,15.87) 277.57,15.87 277.18,16.27 275.98,16.27 273.6,13.88 267.59,13.88 266.68,14.79 264.83,14.79 262.01,11.98 257.31,11.98 255.62,10.29 255.02,10.29 254.02,9.29 250.32,9.29 249.6,8.57 225.81,8.57 223.32,11.06 219.03,11.06 216.68,13.41 211.88,13.41 206.79,8.31 202.57,8.31 200.62,6.36 196.49,6.36 196.32,6.19 186.12,6.19 184.56,7.74 175.79,7.74 173.24,10.3 170.32,10.3 169.84,10.78 167.51,10.78 167.07,11.22 165.65,11.22 165.21,10.78 162.65,10.78 161.23,9.35 160,9.35 157.93,7.27 155.11,7.27 154.64,6.8 153.12,6.8 152.39,7.52 152.39,8.63 152.47,8.71 v6(152.66,8.71) ; v4(26.89,11.83) 26.89,11.93 27.51,12.54 27.51,18.29 26.54,19.26 24.99,19.26 24.63,18.89 24.05,18.89 23.61,19.34 21.25,19.34 20.58,18.67 20.58,18.65 v8(20.31,18.38)
  BOTTOM w0.095: QC2.3 277.93,13.4 278.45,13.92 v4(278.45,15.87) 278.45,16.16 278.62,16.33 278.62,17.81 279.69,18.89 279.69,20.44 281.11,21.86 285.01,21.86 285.35,21.52 R238.1 ; v5(283.6,11.99) 282.53,10.92 281.65,10.92 281.59,10.98 R5817.2
UPD_MRESET: length 359.1
  TOP w0.095: RT22.1 18.33,53.04 16.68,53.04 v1(16.03,52.39) ; R209.2 30.52,26.52 30.1,26.1 29.94,26.1 v2(29.55,25.71) v7(29.11,25.27) ; R181.2 18.93,25.72 19.41,26.21 19.41,26.57 v8(19.43,26.59)
  IN1 w0.076: v7(29.11,25.27) 28.85,25.53 24.1,25.53 v9(23.88,25.75)
  GND1 w0.095: v9(23.88,25.75) 23.42,25.75 v3(23.41,25.73) ; v1(16.03,52.39) v3(15.79,52.15)
  IN2 w0.064: v3(275.94,16.16) 275.82,16.28 275.46,16.28 275.16,16.58 271.69,16.58 271.27,16.16 271.27,15.31 268.45,12.49 268.05,12.49 259.52,3.96 228.86,3.96 228.85,3.97 227.9,3.97 226.61,5.27 221.76,5.27 220.4,3.91 185.23,3.91 183.52,5.62 176.5,5.62 175.93,5.06 170.19,5.06 167.04,8.21 164.73,8.21 164.22,8.72 162.36,8.72 161.66,9.43 159.87,9.43 158.64,10.66 158.64,11.85 156.92,13.57 153.6,13.57 152.71,14.46 151.97,14.46 151.39,13.89 145.75,13.89 145.26,14.38 136.51,14.38 136.07,13.95 112.24,13.95 111.59,13.3 110.44,13.3 109.96,12.82 108.92,12.82 106.63,10.52 79.08,10.52 76.44,7.88 71.4,7.88 71.26,7.74 54.66,7.74 52.01,10.39 44.51,10.39 42.12,12.78 38.44,12.78 34.94,16.28 34.94,16.44 32.4,18.97 31.46,18.97 30.78,19.66 29.6,19.66 28.71,20.55 28,20.55 27.48,21.07 27.48,21.89 23.64,25.73 v3(23.41,25.73) 23.25,25.58 21.48,25.58 21.07,25.99 19.95,25.99 19.43,26.51 v8(19.43,26.59)
  IN3 w0.064: v3(15.79,52.15) 15.79,51.95 15.68,51.85 15.09,51.25 15.09,45.91 12.34,43.17 12.34,40.12 11.92,39.7 11.92,34.04 10.95,33.07 10.95,30.94 12.9,28.99 16.65,28.99 17.55,28.09 18.19,28.09 18.27,28.01 19.22,28.01 19.48,27.75 19.48,26.64 v8(19.43,26.59)
  GND3 w0.095: v6(276.19,15.56) 275.94,15.81 v3(275.94,16.16)
  IN4 w0.076: v6(276.19,15.56) 276.89,15.56 277.42,15.04 279.54,15.04 282.46,12.12 282.46,11.62 282.98,11.09 288.84,11.09 289.26,11.51 289.26,13.69 289.52,13.95 289.84,13.95 290.4,14.51 292.09,14.51 292.98,13.62 293.49,13.62 294.82,14.95 294.82,16.48 294.92,16.58 294.92,17.85 294.64,18.13 292.6,18.13 v5(292.34,18.38)
USB2_ID: length 5.9
  BOTTOM w0.095: RC48.1 141.1,51.08 139.38,52.79 138.54,52.79 138.27,52.52 137.79,52.52 137.73,52.46 136.75,52.46 136.39,52.1 UCPU1.AG3
USB3RN1: length 184.7
  TOP w0.102: C67.1 265.3,24.57 264.73,24.57 264.49,24.33 v10(264.49,23.44) 264.49,22.62 264.43,22.56 264.43,21.81 264.68,21.56 264.89,21.56 v1(264.97,21.47)
  GND1 w0.102: v1(264.97,21.47) 265.32,21.47 v3(265.42,21.37)
  IN3 w0.089: v3(265.42,21.37) 265.4,21.36 265.32,21.24 265.32,18.79 259.67,13.14 258.83,13.14 257.69,12 257.69,11.42 255.58,9.31 252.86,9.31 252.09,8.54 251.28,8.54 250.87,8.12 230.65,8.12 228.06,10.71 226.08,10.71 225.31,11.49 222.32,11.49 221.22,12.59 211.22,12.59 206.71,8.08 187.28,8.08 185.72,9.64 178.89,9.64 176.61,11.92 174.46,11.92 173.54,12.85 169.2,12.85 165.43,16.61 160.94,16.61 158.05,19.51 158.05,24.32 156.88,25.49 156.88,32.98 153.53,36.33 153.53,41.71 151.78,43.46 151.78,46.45 149.12,49.11 149.12,49.49 143.56,55.04 142.11,55.04 141.68,55.47 138.29,55.47 137.76,56.01 137.76,56.91 135.02,59.64 135.02,60.01 132.97,62.06 132.71,62.06 132.62,61.97 v8(132.62,61.83)
  BOTTOM w0.097: UCPU1.H8 133.07,61.67 132.92,61.83 v8(132.62,61.83)
USB3RN1_C: length 1.6
  TOP w0.102: C67.2 266.08,24.43 266.08,24.43 266.18,24.43 266.18,24.43 266.97,24.43 267.02,24.48 U30.4
USB3RP1: length 184.8
  TOP w0.102: C66.1 265.28,24.02 264.97,24.34 264.82,24.34 264.72,24.23 264.72,22.52 264.66,22.46 264.66,21.9 264.77,21.79 265.08,21.79 265.18,21.89 265.18,22.03 265.06,22.16 v1(264.97,22.16)
  GND1 w0.102: v3(265.39,21.96) 265.17,21.96 v1(264.97,22.16)
  IN3 w0.089: v8(132.56,62.51) 132.65,62.41 133.12,62.41 135.38,60.15 135.38,59.79 138.11,57.06 138.11,56.16 138.44,55.83 141.83,55.83 142.25,55.4 143.71,55.4 149.48,49.63 149.48,49.26 152.14,46.6 152.14,43.61 153.89,41.86 153.89,36.47 157.23,33.13 157.23,25.64 158.4,24.47 158.4,19.66 161.09,16.97 165.58,16.97 169.35,13.2 173.68,13.2 174.6,12.28 176.76,12.28 179.04,10 185.86,10 187.42,8.44 206.56,8.44 211.07,12.95 221.37,12.95 222.47,11.84 225.46,11.84 226.23,11.07 228.2,11.07 230.79,8.48 250.72,8.48 251.13,8.89 251.94,8.89 252.71,9.66 255.43,9.66 257.33,11.56 257.33,12.14 258.69,13.5 259.52,13.5 264.96,18.94 264.96,21.54 265.06,21.75 265.35,21.96 v3(265.39,21.96)
  BOTTOM w0.097: UCPU1.G8 132.77,62.51 v8(132.56,62.51)
USB3RP1_C: length 1.7
  TOP w0.102: U30.5 267,24.08 266.88,24.2 266.09,24.2 C66.2
USB3TN1: length 187.1
  TOP w0.102: v1(264.23,17.5) 264.23,17.59 263.91,17.91 263.91,19.36 265.81,21.26 265.81,21.45 C69.1
  GND1 w0.102: v3(264.35,17.15) 264.39,17.19 264.39,17.35 v1(264.23,17.5)
  IN2 w0.076: 131.95,64.84 131.93,64.84 131.84,64.75 131.56,64.75 131.27,64.46 130.55,64.46 130.47,64.54 130.47,64.85 130.55,64.92 v3(130.77,64.92)
  IN2 w0.089: 131.95,64.84 132.96,64.84 133.63,64.17 134.61,64.17 135.04,64.6 135.83,64.6 136.98,63.45 136.98,62.94 138.75,61.18 138.75,60.13 139.81,59.07 139.81,58.96 142.51,56.26 142.99,56.26 144.89,54.36 144.89,53.87 145.91,52.85 145.91,51.78 150.59,47.11 150.59,46.32 152.44,44.47 152.44,40.65 153.87,39.22 153.87,36.45 157.55,32.77 157.55,31.66 158.54,30.67 158.54,27.42 159.32,26.65 159.32,19.36 163.11,15.57 164.4,15.57 167.54,12.42 168.43,12.42 171.73,9.12 173.62,9.12 174.13,8.6 184.85,8.6 186.52,6.93 208.49,6.93 212.54,10.99 215.49,10.99 217.56,8.91 226.4,8.91 226.82,8.49 229.07,8.49 230.6,6.96 253.53,6.96 254.04,7.47 256.23,7.47 264.86,16.1 264.86,16.93 264.63,17.15 v3(264.35,17.15)
  GND3 w0.102: v3(130.77,64.92) v4(130.44,64.92)
USB3TN1_C: length 2.5
  TOP w0.102: U30.7 266.94,23.28 266.86,23.36 266.53,23.36 265.75,22.59 265.75,22.4 C69.2
USB3TP1: length 187.1
  TOP w0.102: C68.1 266.04,21.38 266.04,21.17 v10(264.43,19.55) 264.14,19.27 264.14,18.01 264.33,17.82 264.53,17.82 v1(264.64,17.93)
  GND1 w0.102: v3(264.73,17.55) 264.64,17.65 v1(264.64,17.93)
  IN2 w0.076: 131.95,64.49 131.93,64.49 131.84,64.58 131.63,64.58 131.34,64.3 130.92,64.3 v3(130.71,64.09)
  IN2 w0.089: 131.95,64.49 132.81,64.49 133.48,63.82 134.76,63.82 135.19,64.25 135.69,64.25 136.63,63.3 136.63,62.8 138.4,61.03 138.4,59.98 139.46,58.92 139.46,58.81 142.36,55.9 142.84,55.9 144.54,54.21 144.54,53.72 145.56,52.7 145.56,51.63 150.24,46.96 150.24,46.18 152.08,44.33 152.08,40.5 153.51,39.07 153.51,36.3 157.19,32.62 157.19,31.52 158.19,30.52 158.19,27.27 158.96,26.5 158.96,19.21 162.96,15.21 164.25,15.21 167.4,12.07 168.28,12.07 171.59,8.76 173.47,8.76 173.99,8.25 184.7,8.25 186.37,6.58 208.63,6.58 212.69,10.63 215.34,10.63 217.41,8.56 226.25,8.56 226.67,8.13 228.92,8.13 230.45,6.61 253.68,6.61 254.19,7.12 256.38,7.12 265.21,15.95 265.21,17.07 v3(264.73,17.55)
  GND3 w0.102: v3(130.71,64.09) 130.53,64.27 v4(130.44,64.27)
USB3TP1_C: length 2.5
  TOP w0.102: U30.8 266.9,22.88 266.84,22.94 266.84,23.06 266.76,23.13 266.62,23.13 265.98,22.49 265.98,22.35 266.08,22.25 C68.2
USB20_N1: length 214.5
  IN3 w0.089: v8(133.18,54.61) 133.07,54.49 132.78,54.49 132.68,54.59 132.68,54.86 132.8,54.98 134.37,54.98 134.42,55.03 134.7,55.03 134.87,54.86 135.49,54.86 135.97,54.38 135.97,53.96 137.71,52.21 138.43,52.21 138.59,52.37 140.81,52.37 141.44,52.99 143.45,52.99 147.56,48.88 147.56,48.55 149.39,46.71 149.39,45.48 150.27,44.61 150.27,41.28 152.01,39.54 152.01,35.7 155.38,32.33 155.38,22.57 156.01,21.93 156.01,19.42 160.35,15.08 164.64,15.08 170.71,9.02 175.72,9.02 176.62,8.12 185.09,8.12 186.65,6.56 209.04,6.56 213.14,10.66 215.46,10.66 216.13,9.99 224.69,9.99 225.46,9.21 227.35,9.21 229.94,6.62 253.66,6.62 254.44,7.4 255.82,7.4 258.76,10.34 260.02,10.34 265.37,15.69 265.37,16.06 266.75,17.44 266.75,18.07 266.99,18.32 266.99,20.66 269.28,22.94 269.28,25.44 269.69,25.86 274.28,25.86 275,26.59 278.38,26.59 279.25,25.71 280.7,25.71 282.21,24.2 285.11,24.2 285.82,24.91 287.16,24.91 287.71,24.36 287.71,23.32 285.7,21.31 285.7,18.99 286.06,18.63 286.59,18.63 286.74,18.47 286.74,18.29 v3(286.67,18.23)
  GND3 w0.102: v3(286.67,18.23) 286.77,18.33 v4(287.02,18.33)
  BOTTOM w0.097: v8(133.18,54.61) 132.88,54.91 UCPU1.AB9
USB20_N5: length 199
  IN3 w0.089: v3(287.19,23.38) 287.06,23.51 285.97,23.51 285.53,23.08 281.95,23.08 280.49,24.54 277.84,24.54 277.39,24.08 276.75,24.08 276.01,24.82 274.62,24.82 271.5,21.71 269.11,21.71 267.77,20.37 267.77,18.03 267.55,17.81 267.55,17.16 266.12,15.72 266.12,15.38 260.23,9.49 258.99,9.49 256.12,6.62 254.76,6.62 254.02,5.88 229.61,5.88 227.02,8.46 218.73,8.46 216.08,5.81 185.54,5.81 183.99,7.36 175.92,7.36 175.13,8.15 169.68,8.15 165.16,12.67 162.15,12.67 160.91,13.91 159.85,13.91 157.25,16.51 157.25,17.04 155.26,19.03 155.26,21.58 154.63,22.21 154.63,31.86 151.25,35.24 151.25,39.23 149.48,41 149.48,44.33 148.17,45.64 148.17,46.77 146.75,48.2 146.75,48.58 143.08,52.24 141.99,52.24 140.91,51.16 140.03,51.16 139.74,50.87 139.15,50.87 138.63,51.39 138.63,51.62 v3(138.55,51.71)
  GND3 w0.102: v3(287.19,23.38) 287.26,23.44 287.57,23.44 v4(287.61,23.48) ; v4(138.72,51.41) 138.55,51.58 v3(138.55,51.71)
  BOTTOM w0.076: v4(138.72,51.41) 138.72,51.57 138.8,51.66 139,51.66 139.08,51.58 139.08,50.96 138.62,50.5 137.51,50.5 137.43,50.59 137.43,50.7 137.51,50.78 UCPU1.AJ1
USB20_N5_CONN: length 8.9
  BOTTOM w0.102: L1.3 285.75,23.48 285.66,23.38 D3.1 285.14,23.64 284.38,23.64 283.6,22.85 283.3,22.85 283.21,22.76 283.21,22.61 D2.2 282.89,22.64 282.89,22.74 282.77,22.86 282.44,22.86 282.27,22.69 v10(281.69,22.69) 280.85,22.69 280.27,22.11 279.62,22.11 279.45,21.94 JCAM1.14
USB20_N7: length 226.5
  IN3 w0.089: v3(277.75,35.66) 277.78,35.63 279.83,35.63 280.37,35.08 283.35,35.08 284.54,36.27 287.49,36.27 290.73,33.03 290.73,29.46 288.8,27.53 286.89,27.53 285.54,28.89 275.76,28.89 273.56,26.68 269.43,26.68 267.4,24.65 267.4,22.13 266.23,20.96 266.23,18.63 265.98,18.38 265.98,17.74 264.58,16.34 264.58,15.97 260.79,12.18 259.11,12.18 258.54,11.6 258.54,11.2 255.88,8.54 253.18,8.54 252.87,8.23 252.87,7.87 252.38,7.37 230.31,7.37 227.72,9.96 225.77,9.96 225,10.74 216.46,10.74 215.65,11.55 211.31,11.55 207.08,7.32 186.97,7.32 185.42,8.87 177.16,8.87 175.73,10.3 170.53,10.3 164.98,15.85 160.64,15.85 157.3,19.2 157.3,23.91 156.13,25.08 156.13,32.66 152.77,36.01 152.77,41.2 151.01,42.95 151.01,44.92 150.17,45.76 150.17,47 148.35,48.81 148.35,49.18 143.3,54.23 139.67,54.23 139.25,53.82 139.25,53.48 v3(139.34,53.4)
  GND3 w0.102: v3(139.34,53.4) 139.08,53.14 139.08,52.86 138.95,52.73 138.95,52.49 v4(139.04,52.41) ; v4(277.45,35.51) 277.6,35.66 v3(277.75,35.66)
  BOTTOM w0.076: UCPU1.AH1 137.17,51.51 137.17,51.62 137.24,51.68 138.12,51.68 138.55,52.11 138.79,52.11 139.04,52.36 v4(139.04,52.41)
  BOTTOM w0.102: L2.1 276.72,35.32 276.45,35.05 276.45,34.88 276.55,34.78 277.01,34.78 277.45,35.22 277.45,35.5 277.45,35.5 v4(277.45,35.51)
USB20_N7_CONN: length 9.3
  BOTTOM w0.102: WL1.69 273.27,41.92 273.09,41.74 273.09,41.03 274.77,39.35 274.97,39.35 275.1,39.48 275.1,40.19 D74.3 275.5,40.19 275.5,39.83 275.63,39.71 275.88,39.71 276.6,39 276.6,37.4 276.72,37.27 L2.2
USB20_N10: length 186.8
  IN3 w0.089: v8(134.41,51.38) 134.69,51.1 138.34,51.1 139.09,50.35 141.09,50.35 141.23,50.48 144.27,50.48 146.27,48.49 146.27,46.97 149.06,44.18 149.06,40.85 150.85,39.06 150.85,35.06 154.16,31.75 154.16,22.1 154.86,21.4 154.86,18.87 156.82,16.91 156.82,16.38 159.71,13.49 160.7,13.49 162.37,11.83 165.37,11.83 170.25,6.95 183.79,6.95 185.32,5.41 216.4,5.41 219.05,8.07 226.73,8.07 229.32,5.48 257.75,5.48 264.2,11.93 264.52,11.93 265.76,13.17 265.76,13.55 265.69,13.62 265.46,13.62 265.27,13.44 v3(265.27,13.29)
  GND3 w0.102: v3(265.27,13.29) v6(265.52,13.53)
  IN4 w0.095: v6(265.52,13.53) 265.52,12.94 266.74,11.72 270.45,11.72 270.65,11.92 275.77,11.92 276.38,12.53 277.33,12.53 277.7,12.16 279.38,12.16 279.69,12.47 279.69,12.79 v5(279.77,12.86)
  BOTTOM w0.076: UCPU1.AH7 134.18,51.57 134.37,51.38 v8(134.41,51.38)
USB20_N10_CONN: length 7
  BOTTOM w0.102: ML1.3 279.77,11.17 279.63,11.03 v10(279.63,10.55) 279.63,10.07 280.02,9.68 280.02,9.02 279.69,8.7 279.35,8.7 D20.2 279.12,8.81 278.94,8.99 278.65,8.99 278.4,8.73 278.4,7.97 278.35,7.92 278.35,7.71 278.58,7.48 JFP2.6
USB20_P1: length 214.5
  IN3 w0.089: v8(131.88,54.6) 132.18,54.6 132.32,54.74 132.32,55.01 132.66,55.34 134.23,55.34 134.27,55.39 134.85,55.39 135.02,55.22 135.63,55.22 136.32,54.53 136.32,54.11 137.86,52.57 138.28,52.57 138.44,52.72 140.67,52.72 141.29,53.35 143.59,53.35 147.91,49.03 147.91,48.69 149.75,46.85 149.75,45.63 150.62,44.75 150.62,41.42 152.36,39.68 152.36,35.85 155.73,32.48 155.73,22.72 156.37,22.08 156.37,19.57 160.5,15.44 164.79,15.44 170.86,9.37 175.87,9.37 176.77,8.48 185.23,8.48 186.8,6.91 208.89,6.91 212.99,11.01 215.61,11.01 216.28,10.34 224.83,10.34 225.61,9.57 227.5,9.57 230.09,6.98 253.51,6.98 254.29,7.76 255.68,7.76 258.62,10.7 259.87,10.7 265.01,15.84 265.01,16.21 266.39,17.59 266.39,18.22 266.64,18.47 266.64,20.8 268.92,23.09 268.92,25.59 269.55,26.22 274.13,26.22 274.86,26.94 278.53,26.94 279.4,26.07 280.85,26.07 282.36,24.56 284.96,24.56 285.67,25.26 287.31,25.26 288.07,24.51 288.07,23.18 286.06,21.17 286.06,19.13 286.21,18.98 286.68,18.98 v3(286.7,19.01)
  GND3 w0.102: v3(286.7,19.01) 286.88,18.83 v4(287.02,18.83)
  BOTTOM w0.097: v8(131.88,54.6) 132.23,54.96 UCPU1.AB10
USB20_P5: length 199
  IN3 w0.089: v3(287.19,23.99) 287.07,23.86 285.82,23.86 285.39,23.43 282.1,23.43 280.64,24.89 277.69,24.89 277.24,24.44 276.9,24.44 276.16,25.18 274.47,25.18 271.36,22.07 268.97,22.07 267.42,20.52 267.42,18.18 267.2,17.96 267.2,17.3 265.76,15.87 265.76,15.53 260.09,9.85 258.85,9.85 255.97,6.98 254.61,6.98 253.87,6.23 229.76,6.23 227.17,8.82 218.59,8.82 215.93,6.16 185.69,6.16 184.14,7.71 176.06,7.71 175.27,8.5 169.83,8.5 165.3,13.02 162.3,13.02 161.06,14.27 160,14.27 157.61,16.66 157.61,17.19 155.61,19.18 155.61,21.73 154.98,22.36 154.98,32 151.61,35.38 151.61,39.38 149.84,41.14 149.84,44.47 148.53,45.79 148.53,46.92 147.1,48.34 147.1,48.72 143.23,52.6 141.84,52.6 140.76,51.52 139.88,51.52 139.59,51.23 139.29,51.23 138.99,51.53 138.99,51.68 139.15,51.84 139.43,51.84 v3(139.54,51.73)
  GND3 w0.102: v4(287.61,23.98) 287.57,23.94 287.24,23.94 v3(287.19,23.99) ; v4(139.38,51.43) 139.38,51.56 v3(139.54,51.73)
  BOTTOM w0.076: v4(139.38,51.43) 139.24,51.29 139.24,50.89 138.69,50.34 137.44,50.34 137,50.78 UCPU1.AJ2
USB20_P5_CONN: length 8.9
  BOTTOM w0.102: L1.2 285.85,23.98 285.75,24.08 D4.1 285.19,23.87 284.29,23.87 283.5,23.08 283.27,23.08 283.17,23.18 283.17,23.37 D2.3 282.91,23.32 282.91,23.17 282.83,23.09 282.35,23.09 282.18,22.92 280.75,22.92 280.17,22.34 279.52,22.34 279.42,22.44 JCAM1.13
USB20_P7: length 226.5
  IN3 w0.089: v3(277.88,34.89) 277.73,35.04 277.73,35.18 277.82,35.27 279.68,35.27 280.23,34.72 283.5,34.72 284.69,35.92 287.34,35.92 290.37,32.88 290.37,29.6 288.66,27.89 287.04,27.89 285.68,29.24 275.62,29.24 273.41,27.04 269.28,27.04 267.04,24.79 267.04,22.27 265.87,21.1 265.87,18.78 265.62,18.53 265.62,17.89 264.22,16.49 264.22,16.11 260.64,12.53 258.97,12.53 258.18,11.74 258.18,11.34 255.73,8.89 253.03,8.89 252.51,8.38 252.51,8.01 252.23,7.73 230.46,7.73 227.87,10.32 225.92,10.32 225.14,11.09 216.61,11.09 215.8,11.9 211.16,11.9 206.94,7.68 187.12,7.68 185.57,9.23 177.31,9.23 175.88,10.66 170.68,10.66 165.13,16.21 160.79,16.21 157.65,19.34 157.65,24.05 156.48,25.23 156.48,32.8 153.13,36.16 153.13,41.35 151.37,43.1 151.37,45.07 150.52,45.91 150.52,47.14 148.71,48.96 148.71,49.33 143.45,54.59 139.52,54.59 138.9,53.97 138.9,53.65 138.61,53.36 v3(138.54,53.36)
  GND3 w0.102: v3(277.88,34.89) 277.62,34.89 v4(277.55,34.82) ; v4(138.61,52.41) 138.72,52.52 138.72,52.82 138.85,52.95 138.85,53.05 v3(138.54,53.36)
  BOTTOM w0.076: UCPU1.AH2 136.76,51.44 137.17,51.85 138.05,51.85 v4(138.61,52.41)
  BOTTOM w0.102: L2.4 276.22,34.79 276.45,34.55 v10(276.77,34.55) 277.1,34.55 277.37,34.82 v4(277.55,34.82)
USB20_P7_CONN: length 9.3
  BOTTOM w0.102: L2.3 276.22,37.29 276.37,37.43 276.37,38.9 275.79,39.48 275.58,39.48 275.48,39.38 275.48,38.64 D74.2 275.15,38.61 275.15,39.02 275.05,39.12 274.67,39.12 272.86,40.93 272.86,41.79 272.77,41.88 WL1.70
USB20_P10: length 186.8
  IN3 w0.089: v3(266.18,13.86) 266.12,13.8 266.12,13.03 264.67,11.58 264.35,11.58 257.9,5.13 229.17,5.13 226.58,7.71 219.2,7.71 216.54,5.06 216.32,5.06 185.17,5.06 183.64,6.59 170.1,6.59 165.22,11.47 162.22,11.47 160.56,13.14 159.56,13.14 156.46,16.24 156.46,16.76 154.5,18.72 154.5,21.26 153.8,21.95 153.8,31.6 150.5,34.91 150.5,38.91 148.7,40.71 148.7,44.04 145.91,46.82 145.91,48.34 144.12,50.13 141.38,50.13 141.24,49.99 138.94,49.99 138.19,50.74 134.44,50.74 v8(133.8,51.39)
  GND3 w0.102: v6(266.16,13.53) 266.16,13.85 v3(266.18,13.86)
  IN4 w0.095: v6(266.16,13.53) 265.97,13.53 265.87,13.43 265.87,13.09 266.89,12.07 270.3,12.07 270.5,12.28 275.62,12.28 276.23,12.88 277.47,12.88 277.84,12.51 279.24,12.51 279.34,12.62 279.34,12.79 v5(279.27,12.86)
  BOTTOM w0.076: UCPU1.AH8 133.53,51.65 v8(133.8,51.39)
USB20_P10_CONN: length 6.9
  BOTTOM w0.102: ML1.2 279.27,11.18 279.4,11.04 279.4,9.98 279.79,9.59 279.79,9.12 279.6,8.93 279.37,8.93 279.12,9.18 D20.3 278.86,9.21 278.56,9.21 278.17,8.83 v10(278.17,8.44) 278.17,8.07 278.12,8.01 278.12,7.53 278.08,7.49 JFP2.5
USB_OC3#: length 4.6
  BOTTOM w0.095: UCPU1.B9 132.91,65.79 132.8,65.91 132.8,65.91 132.63,66.08 132.63,66.57 132.66,66.6 132.66,68.27 v2(132.96,68.57) 133.64,69.26 RC56.1
USBC_MCP23017_SMBCLK_R_A: length 3.2
  TOP w0.076: U19.L2 16.36,32.81 16.19,32.98 15.34,32.98 14.93,33.39 14.79,33.39
  TOP w0.095: R180.2 14.19,34.31 14.63,33.87 14.63,33.56 14.79,33.39
USBC_MCP23017_SMBCLK_R_B: length 3
  TOP w0.095: R208.2 28.38,35.04 U20.L2
USBC_MCP23017_SMBDAT_R_A: length 4.4
  TOP w0.076: U19.K2 16.72,33.06 16.36,33.06 16.22,33.2
  TOP w0.095: 16.22,33.2 15.41,33.2 14.96,33.65 14.96,33.98 14.74,34.2 14.74,34.73 14.19,35.28 R182.2
USBC_MCP23017_SMBDAT_R_B: length 4.1
  TOP w0.095: v7(28.53,35.55) 28.53,35.7 v2(27.71,36.52) 26.74,37.49 R210.2
  IN1 w0.076: v7(29.52,35.04) 29.19,35.04 28.98,35.24 28.63,35.24 28.53,35.35 v7(28.53,35.55)
USBCOMP: length 1.7
  TOP w0.305: v8(135.24,54.45) 135.44,54.65 RC47.1
  BOTTOM w0.305: UCPU1.AB6 135.12,54.76 135.12,54.58 v8(135.24,54.45)
VCI_IN2#: length 2.5
  GND1 w0.095: v1(22.3,12.41) 22.42,12.41 v3(22.59,12.24)
  GND3 w0.095: v3(22.59,12.24) 22.69,12.24 v4(22.94,11.99)
  BOTTOM w0.095: v4(22.94,11.99) 23.21,11.99 24.04,12.82 RE142.1
VCI_IN3#: length 5.5
  TOP w0.095: v1(22.77,12.78) 22.7,12.78 22.3,13.18 UE3.E4
  GND1 w0.095: v1(22.77,12.78) 23.03,12.53 v3(23.15,12.53)
  GND3 w0.095: v6(23.66,12.02) v3(23.15,12.53)
  IN4 w0.076: v5(24.93,10.62) 24.93,10.92 23.83,12.02 v6(23.66,12.02)
  BOTTOM w0.095: v5(24.93,10.62) 25.11,10.8 RE244.1 25.69,10.8 25.88,10.61 v2(26.39,10.61)
VCORE_B+: length 23.9
  TOP w0.254: v8(57.38,43.11) 57.38,44.9 56.71,45.57 56.59,45.44 v8(50.19,45.44)
  BOTTOM w0.254: PR1002.1 38.65,49.31 43.8,49.31 44.67,48.44 44.67,47.85 45.69,46.83 47.79,46.83 47.98,46.63 49.94,46.63 50.19,46.37 v8(50.19,45.44)
  vias: v1(64.75,56.73) v1(64.77,56.34) v1(64.75,55.8) v1(64.77,55.37) v1(64.78,57.32) v1(64.94,54.95) v1(65.17,47.72) v1(65.13,47.12) v1(65.15,46.74) v1(65.13,46.2) v1(65.15,45.76) v1(65.15,45.35) v2(63.06,43.21) v3(64.4,57.32) v3(64.4,56.86) v3(64.4,56.41) v3(64.4,55.95) v3(64.4,55.49) v3(64.4,55.04) v3(64.78,47.72) v3(64.78,47.26) v3(64.78,46.81) v3(64.78,46.35) v3(64.78,45.89) v3(64.78,45.43) v4(64.05,57.36) v4(64.06,56.91) v4(64.06,56.46) v4(64.06,56) v4(64.06,55.54) v4(64.06,55.08) v4(64.45,47.71) v4(64.45,47.26) v4(64.45,46.81) v4(64.45,46.35) v4(64.45,45.89) v4(64.45,45.43) v4(65.06,57.35) v4(65.07,56.91) v4(65.07,56.46) v4(65.07,56) v4(65.07,55.54) v4(65.07,55.08) v4(65.44,47.7) v4(65.46,47.26) v4(65.46,46.81) v4(65.46,46.35) v4(65.46,45.89) v4(65.46,45.43) v8(57.63,41.85) v8(57.75,42.52) v8(58.17,43.14) v8(58.29,41.86) v8(58.44,42.54) v8(58.9,43.16) v8(58.92,41.86) v8(59.07,42.52) v8(59.49,43.14) v8(59.51,41.83) v8(59.76,42.52) v8(63.58,55.15) v8(63.58,54.57) v8(63.64,62.12) v8(63.64,60.77) v8(63.64,59.43) v8(63.95,63.3) v8(63.95,62.71) v8(63.93,44.56) v8(64.17,39.45) v8(64.21,52.52) v8(64.21,51.17) v8(64.21,49.82) v8(64.32,54.46) v8(64.37,44.13) v8(64.53,62.71) v8(64.66,62.12) v8(64.66,60.77) v8(64.66,59.43) v8(64.81,39.45) v8(65,44.05) v8(65,42.7) v8(65,41.36) v8(65.22,52.52) v8(65.22,51.17) v8(65.22,49.82) v8(66.01,44.05) v8(66.01,42.7) v8(66.01,41.36) v8(66.47,70.73) v8(67.06,70.73)
