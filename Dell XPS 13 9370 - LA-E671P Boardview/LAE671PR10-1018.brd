# Allegro board LAE671PR10-1018.brd (continued)
## Nets (continued)
DDR_A_D56: UCPU1.AT61 UD41.N9
DDR_A_D57: UCPU1.AU61 UD41.M9
DDR_A_D58: UCPU1.AP60 UD41.N11
DDR_A_D59: UCPU1.AN60 UD41.N10
DDR_A_D60: UCPU1.AN61 UD41.M8
DDR_A_D61: UCPU1.AP61 UD41.P9
DDR_A_D62: UCPU1.AT60 UD41.M10
DDR_A_D63: UCPU1.AU60 UD41.M11
DDR_A_DQS0: UCPU1.AM69 UD42.D10
DDR_A_DQS1: UCPU1.AT70 UD42.P10
DDR_A_DQS2: UCPU1.AH65 UD42.L10
DDR_A_DQS3: UCPU1.AG70 UD42.G10
DDR_A_DQS4: UCPU1.AY64 UD41.D10
DDR_A_DQS5: UCPU1.BA60 UD41.P10
DDR_A_DQS6: UCPU1.AR65 UD41.G10
DDR_A_DQS7: UCPU1.AR60 UD41.L10
DDR_A_DQS#0: UCPU1.AM70 UD42.D11
DDR_A_DQS#1: UCPU1.AT69 UD42.P11
DDR_A_DQS#2: UCPU1.AH66 UD42.L11
DDR_A_DQS#3: UCPU1.AG69 UD42.G11
DDR_A_DQS#4: UCPU1.BA64 UD41.D11
DDR_A_DQS#5: UCPU1.AY60 UD41.P11
DDR_A_DQS#6: UCPU1.AR66 UD41.G11
DDR_A_DQS#7: UCPU1.AR61 UD41.L11
DDR_A_ODT0: RD73.1 UCPU1.AT45 UD41.J8 UD42.J8
DDR_B0_ZQ0: RD5.1 UD44.B3
DDR_B0_ZQ1: RD7.1 UD44.B4
DDR_B1_ZQ0: RD6.1 UD43.B3
DDR_B1_ZQ1: RD8.1 UD43.B4
DDR_B_CA1_0: RD22.1 UCPU1.AY48 UD44.R2
DDR_B_CA1_1: RD24.1 UCPU1.AP50 UD44.P2
DDR_B_CA1_2: RD26.1 UCPU1.BA48 UD44.N2
DDR_B_CA1_3: RD28.1 UCPU1.BB48 UD44.N3
DDR_B_CA1_4: RD30.1 UCPU1.AP48 UD44.M3
DDR_B_CA1_5: RD32.1 UCPU1.AP52 UD44.F3
DDR_B_CA1_6: RD34.1 UCPU1.AN50 UD44.E3
DDR_B_CA1_7: RD36.1 UCPU1.AN48 UD44.E2
DDR_B_CA1_8: RD38.1 UCPU1.AN53 UD44.D2
DDR_B_CA1_9: RD40.1 UCPU1.AN52 UD44.C2
DDR_B_CA2_0: RD42.1 UCPU1.BA43 UD43.R2
DDR_B_CA2_1: RD44.1 UCPU1.AY43 UD43.P2
DDR_B_CA2_2: RD46.1 UCPU1.AY44 UD43.N2
DDR_B_CA2_3: RD48.1 UCPU1.AW44 UD43.N3
DDR_B_CA2_4: RD50.1 UCPU1.BB44 UD43.M3
DDR_B_CA2_5: RD52.1 UCPU1.AY47 UD43.F3
DDR_B_CA2_6: RD54.1 UCPU1.BA44 UD43.E3
DDR_B_CA2_7: RD56.1 UCPU1.AW46 UD43.E2
DDR_B_CA2_8: RD58.1 UCPU1.AY46 UD43.D2
DDR_B_CA2_9: RD60.1 UCPU1.BA46 UD43.C2
DDR_B_CKE0: RD66.1 UCPU1.AN56 UD44.K3
DDR_B_CKE1: RD68.1 UCPU1.AP55 UD44.K4
DDR_B_CKE2: RD70.1 UCPU1.AN55 UD43.K3
DDR_B_CKE3: RD72.1 UCPU1.AP53 UD43.K4
DDR_B_CLK0: RD76.1 UCPU1.AP45 UD44.J3
DDR_B_CLK1: RD80.1 UCPU1.AP46 UD43.J3
DDR_B_CLK#0: RD78.1 UCPU1.AN45 UD44.J2
DDR_B_CLK#1: RD82.1 UCPU1.AN46 UD43.J2
DDR_B_CS#0: RD62.1 UCPU1.BB42 UD43.L3 UD44.L3
DDR_B_CS#1: RD64.1 UCPU1.AY42 UD43.L4 UD44.L4
DDR_B_D0: UCPU1.AY39 UD44.E11
DDR_B_D1: UCPU1.AW39 UD44.F10
DDR_B_D2: UCPU1.AY37 UD44.F11
DDR_B_D3: UCPU1.AW37 UD44.D9
DDR_B_D4: UCPU1.BB39 UD44.F9
DDR_B_D5: UCPU1.BA39 UD44.E10
DDR_B_D6: UCPU1.BA37 UD44.F8
DDR_B_D7: UCPU1.BB37 UD44.E9
DDR_B_D8: UCPU1.AY35 UD44.T11
DDR_B_D9: UCPU1.AW35 UD44.T10
DDR_B_D10: UCPU1.AY33 UD44.T9
DDR_B_D11: UCPU1.AW33 UD44.R9
DDR_B_D12: UCPU1.BB35 UD44.R11
DDR_B_D13: UCPU1.BA35 UD44.R10
DDR_B_D14: UCPU1.BA33 UD44.T8
DDR_B_D15: UCPU1.BB33 UD44.R8
DDR_B_D16: UCPU1.AU40 UD44.B10
DDR_B_D17: UCPU1.AT40 UD44.B9
DDR_B_D18: UCPU1.AT37 UD44.C11
DDR_B_D19: UCPU1.AU37 UD44.B11
DDR_B_D20: UCPU1.AR40 UD44.B8
DDR_B_D21: UCPU1.AP40 UD44.C8
DDR_B_D22: UCPU1.AP37 UD44.C9
DDR_B_D23: UCPU1.AR37 UD44.C10
DDR_B_D24: UCPU1.AT33 UD44.N11
DDR_B_D25: UCPU1.AU33 UD44.M10
DDR_B_D26: UCPU1.AU30 UD44.N9
DDR_B_D27: UCPU1.AT30 UD44.P9
DDR_B_D28: UCPU1.AR33 UD44.M11
DDR_B_D29: UCPU1.AP33 UD44.N10
DDR_B_D30: UCPU1.AR30 UD44.M8
DDR_B_D31: UCPU1.AP30 UD44.M9
DDR_B_D32: UCPU1.AY31 UD43.E11
DDR_B_D33: UCPU1.AW31 UD43.F8
DDR_B_D34: UCPU1.AY29 UD43.F9
DDR_B_D35: UCPU1.AW29 UD43.E9
DDR_B_D36: UCPU1.BB31 UD43.D9
DDR_B_D37: UCPU1.BA31 UD43.E10
DDR_B_D38: UCPU1.BA29 UD43.F10
DDR_B_D39: UCPU1.BB29 UD43.F11
DDR_B_D40: UCPU1.AY27 UD43.B8
DDR_B_D41: UCPU1.AW27 UD43.C8
DDR_B_D42: UCPU1.AY25 UD43.B9
DDR_B_D43: UCPU1.AW25 UD43.B10
DDR_B_D44: UCPU1.BB27 UD43.C10
DDR_B_D45: UCPU1.BA27 UD43.C9
DDR_B_D46: UCPU1.BA25 UD43.C11
DDR_B_D47: UCPU1.BB25 UD43.B11
DDR_B_D48: UCPU1.AU27 UD43.T10
DDR_B_D49: UCPU1.AT27 UD43.T11
DDR_B_D50: UCPU1.AT25 UD43.T9
DDR_B_D51: UCPU1.AU25 UD43.R9
DDR_B_D52: UCPU1.AP27 UD43.R11
DDR_B_D53: UCPU1.AN27 UD43.R10
DDR_B_D54: UCPU1.AN25 UD43.R8
DDR_B_D55: UCPU1.AP25 UD43.T8
DDR_B_D56: UCPU1.AT22 UD43.M9
DDR_B_D57: UCPU1.AU22 UD43.N9
DDR_B_D58: UCPU1.AU21 UD43.M11
DDR_B_D59: UCPU1.AT21 UD43.N11
DDR_B_D60: UCPU1.AN22 UD43.M8
DDR_B_D61: UCPU1.AP22 UD43.P9
DDR_B_D62: UCPU1.AP21 UD43.M10
DDR_B_D63: UCPU1.AN21 UD43.N10
DDR_B_DQS0: UCPU1.AY38 UD44.G10
DDR_B_DQS1: UCPU1.BA34 UD44.P10
DDR_B_DQS2: UCPU1.AR38 UD44.D10
DDR_B_DQS3: UCPU1.AR32 UD44.L10
DDR_B_DQS4: UCPU1.AY30 UD43.G10
DDR_B_DQS5: UCPU1.BA26 UD43.D10
DDR_B_DQS6: UCPU1.AR27 UD43.P10
DDR_B_DQS7: UCPU1.AR21 UD43.L10
DDR_B_DQS#0: UCPU1.BA38 UD44.G11
DDR_B_DQS#1: UCPU1.AY34 UD44.P11
DDR_B_DQS#2: UCPU1.AT38 UD44.D11
DDR_B_DQS#3: UCPU1.AT32 UD44.L11
DDR_B_DQS#4: UCPU1.BA30 UD43.G11
DDR_B_DQS#5: UCPU1.AY26 UD43.D11
DDR_B_DQS#6: UCPU1.AR25 UD43.P11
DDR_B_DQS#7: UCPU1.AR22 UD43.L11
DDR_B_ODT0: RD74.1 UCPU1.BA42 UD43.J8 UD44.J8
DDR_CHA_EN: RH66.1 RH68.1 UCPU1.U2
DDR_CHB_EN: RH67.1 RH69.1 UCPU1.U1
DDR_VTT_CNTL: RC383.1 UC9.2 UCPU1.AW67
DDR_XDP_SMBCLK: JXDP1.53 QC1.1 RC388.2 RN2.2
DDR_XDP_SMBDAT: JXDP1.51 QC1.4 RC387.2 RN1.2
DEBUG_TX: JDEG1.9 RE203.2 RE209.2
DISPOFF#: D5.1 JCAM1.10 R13.1
DMIC_CLK_CODEC: CA28.1 D10.2 JKB1.11 RA6.1
DMIC_CLK_CODEC_R: RA6.2 U5.5
DMIC_DAT12_CODEC: CA29.1 D10.3 JKB1.10 RA5.1
DMIC_DAT12_CODEC_R: RA5.2 U5.4
DMIC_DAT34_CODEC: CA83.1 D73.3 JKB1.12 RA61.1
DMIC_DAT34_CODEC_R: RA61.2 U5.1
DPEQ0: R51.1 R5800.1 R5801.2 U30.14
DPEQ1: R54.2 R5797.1 U30.2
DPSNK_RBIAS: RT23.1 UT2.Y18
DPSRC_RBIAS: RT9.2 UT2.N6
EC_I2C_CLK: RA26.2 RE243.1 UE3.F7
EC_I2C_DAT: RA25.2 RE242.1 UE3.B6
EDP_1: JEDP1.1 RR17.2
EDP_2: JEDP1.2 RR16.2
EDP_3: JEDP1.3 RR15.2
EDP_AUXN: C1060.1 UCPU1.E45
EDP_AUXN_C: C1060.2 R257.1
EDP_AUXN_CONN: JEDP1.22 R257.2
EDP_AUXP: C1057.1 UCPU1.F45
EDP_AUXP_C: C1057.2 R258.1
EDP_AUXP_CONN: JEDP1.23 R258.2
EDP_BIA_PWM: D6.2 UCPU1.R11
EDP_COMP: RC8.2 UCPU1.E52
EDP_HPD: RC2.2 RR22.1 UCPU1.L10
EDP_HPD_R: JEDP1.37 RR23.2
EDP_TXN_P0: C1055.1 UCPU1.C47
EDP_TXN_P0_C: C1055.2 R14.1
EDP_TXN_P0_CONN: JEDP1.26 R14.2
EDP_TXN_P1: C1064.1 UCPU1.D46
EDP_TXN_P1_C: C1064.2 R256.1
EDP_TXN_P1_CONN: JEDP1.29 R256.2
EDP_TXN_P2: C1056.1 UCPU1.A45
EDP_TXN_P2_C: C1056.2 R260.1
EDP_TXN_P2_CONN: JEDP1.32 R260.2
EDP_TXN_P3: C1062.1 UCPU1.A47
EDP_TXN_P3_C: C1062.2 R262.1
EDP_TXN_P3_CONN: JEDP1.35 R262.2
EDP_TXP_P0: C1058.1 UCPU1.C46
EDP_TXP_P0_C: C1058.2 R15.1
EDP_TXP_P0_CONN: JEDP1.25 R15.2
EDP_TXP_P1: C1063.1 UCPU1.C45
EDP_TXP_P1_C: C1063.2 R259.1
EDP_TXP_P1_CONN: JEDP1.28 R259.2
EDP_TXP_P2: C1061.1 UCPU1.B45
EDP_TXP_P2_C: C1061.2 R261.1
EDP_TXP_P2_CONN: JEDP1.31 R261.2
EDP_TXP_P3: C1059.1 UCPU1.B47
EDP_TXP_P3_C: C1059.2 R255.1
EDP_TXP_P3_CONN: JEDP1.34 R255.2
EDRAM_OPIO_RCOMP: RC108.1 UCPU1.H66
EMMC_RCOMP: RC10.1 UCPU1.AT1
EN_0.6V: PC618.1 PR609.2 PR610.1 PR611.2 PU600.2
EN_1.0V: PC712.1 PR703.2 PR704.1 PU700.11
EN_1.0V_PRIM_COREP: PC1512.1 PR1512.2 PR1513.1 PU1501.13
EN_1.2V: PC617.1 PR607.2 PR608.1 PU600.1
EN_1.8VA: PC800.1 PR800.2 PR801.2 PU800.13
EN_1.8VU: PC900.1 PR900.2 PR901.2 PU900.13
EN_INVPWR: RE161.1 U22.2 UE3.B2
EN_PD_HV1: PR217.1 R173.2
EN_PD_HV2: PR224.1 R201.2
EN_PD_HV3: PR259.1 R229.2
EN_PRIM_CORE: PC1412.1 PR1412.2 PR1413.1 PU1401.13
EN_VCC_EDRAM: PC1500.1 PR1501.2 PR1502.1 PU1500.13
EN_VCCIO: PC1400.1 PR1401.2 PR1402.1 PU1400.13
ENLDO_3V5V: PR508.2 PR509.1 PU500.11 PU501.11
ENVDD: D13.1 R99.2 UZ2.4
ENVDD_PCH: D13.3 UCPU1.U13 UE3.L12
EOPIO_RCOMP: RC109.1 UCPU1.H65
ESPI_ALERT#: RC24.2 UCPU1.AY11 UE3.H7
ESPI_CLK_5105: CC2.2 JESPI1.10 RC19.2 RC22.2 RE172.1 UE3.G7
ESPI_CS#: JESPI1.7 UCPU1.BA12 UE3.H6
ESPI_IO0: JESPI1.3 RC366.2 UE3.K5
ESPI_IO0_R: RC366.1 UCPU1.AY13
ESPI_IO1: JESPI1.4 RC367.2 UE3.L4
ESPI_IO1_R: RC367.1 UCPU1.BA13
ESPI_IO2: JESPI1.5 RC368.2 UE3.G6
ESPI_IO2_R: RC368.1 UCPU1.BB13
ESPI_IO3: JESPI1.6 RC369.2 UE3.L5
ESPI_IO3_R: RC369.1 UCPU1.AY12
ESPI_RESET#: UCPU1.BA11 UE3.K6
FAN1_PWM: JFAN1.3 R36.1 UE3.L10
FAN1_TACH: D11.2 R37.1 UE3.E3
FAN2_PWM: JFAN2.3 R39.1 UE3.L11
FAN2_TACH: D12.2 R40.1 UE3.D1
FB_1.0V: PC706.2 PR702.2 PR705.1 PU700.14
FB_1.8VA: PC801.2 PR802.2 PR804.1 PU800.5
FB_1.8VU: PC901.2 PR902.2 PR904.1 PU900.5
FCCM_GT: PR1108.1 PU1000.11 PU1150.2
FCCM_SA: PU1000.34 PU1151.2
FCCM_VCORE: PR1111.1 PU1000.24 PU1100.2
FGND: JFP2.4 RE255.2
FPR_DET#: RE274.1 RE280.1 RE281.1
FPR_GPIO_DET#: JFP2.1 MD3.2 MD3.3 RE274.2
FPR_SCAN#: RE254.1 RE272.1 RE273.1 UE3.E5
GPIO006: RE281.2 UE3.B3
GPIO043: T68.1(TP-1) UE3.J12
GPIO206: T62.1(TP-1) UE3.J3
GPP_B22: RC46.2 UCPU1.AN5
GPP_B23: RC29.1 UCPU1.AM7
GPP_C5: RC27.1 UCPU1.W1
GPP_E1: RC52.1 UCPU1.H3
H_CATERR#: RC219.2 UCPU1.D63
H_CPU_SVIDALRT#: RC155.1 UCPU1.B63
H_CPUPWRGD: CA1.1 RC85.2 UCPU1.A68
H_CPUPWRGD_R: RC85.1 T10.1(TP-1)
H_PROCHOT#: PR315.1 PR1009.1 RC220.1 RC221.2 RE158.2
H_PROCHOT#_R: RC220.2 UCPU1.C65
H_PROCHOT#_R1: RE158.1 UE3.H13
H_THERMTRIP#: QE16.3 RC222.1
H_THERMTRIP#_R: RC218.2 RC222.2 UCPU1.C63
H_VCCST_PWRGD: RE4.2 U16.2 UE3.J6
H_VCCST_PWRGD_P: CA2.1 RC79.2 RC86.1 RC371.1 RE4.1 RE118.1 U16.4 UE7.4
HDA_BIT_CLK: RC112.2 UCPU1.AY22
HDA_BIT_CLK_R: CA21.1 CC13.1 RC112.1 U5.14
HDA_RST#: CR26.2 T15.1(TP-1) UCPU1.AW22
HDA_SDIN0: CR25.2 RA14.1 UCPU1.BA21
HDA_SDIN0_R: RA14.2 U5.16
HDA_SDOUT: CR24.2 RC113.2 RC119.2 RH73.2 UCPU1.BB22
HDA_SDOUT_R: RC113.1 U5.17
HDA_SYNC: RC111.2 UCPU1.BA22
HDA_SYNC_R: RC111.1 U5.15
HOST_DEBUG_TX: JDEG1.8 RE202.2 RE206.2 UE3.G11
HOST_SD_WP#: QR1.2 RC38.2 UCPU1.AB3
HP2_D_L: CA32.1 RA53.1 RA57.2 RA60.1 U5.27
HP2_D_L_C: CA78.1 DA7.1 JAUDIO1.5 LA9.2
HP2_D_L_R1: LA9.1 RA53.2
HP2_D_R: CA31.1 RA54.1 RA58.2 RA59.1 U5.26
HP2_D_R_C: CA77.1 DA8.1 JAUDIO1.7 LA10.2
HP2_D_R_R1: LA10.1 RA54.2
HRESET_PD1: R5753.2 R5757.2 U19.D6
HRESET_PD1_EC: R5753.1 UE3.K4
HRESET_PD2: R5745.2 R5763.2 U20.D6
HRESET_PD2_EC: R5763.1 UE3.L6
HRESET_PD3: RT98.2 RT99.2 U21.D6
HRESET_PD3_EC: RT98.1 UE3.G5
I2C0_SCK_TS: RC184.2 RR16.1 UCPU1.U6
I2C0_SDA_TS: RC183.2 RR15.1 UCPU1.U7
I2C1_SCK: JTP1.3 MD2.3 R114.1 RH80.2
I2C1_SCK_TP: RH80.1 UCPU1.U9
I2C1_SDA: JTP1.2 MD2.2 R113.1 RH79.2
I2C1_SDA_TP: RH79.1 UCPU1.U8
I2C2_IRQ_TS: RH83.2 RR17.1 UCPU1.L6
I2C2_SCK_EDP_PCH: RC373.2 RR19.1 UCPU1.AH10
I2C2_SDA_EDP_PCH: RC372.2 RR18.1 UCPU1.AH9
I2C_DAT1_PD3: R5771.2 U21.D1
I2C_EN: C49.1 R5802.2 R5807.1 R5834.2 U30.17
I2C_IRQ1_PD3: R5773.2 U21.C1
I2C_SCL1_PD3: R5772.2 U21.D2
I_ADP: PR341.2 UE3.B11
I_BATT: PR342.2 RE125.2
I_BATT_R: CE60.1 RE125.1 UE3.J4
I_SYS: PC1000.2 PR329.2 PR333.1 PR1000.2 PU1000.1 RE126.2
I_SYS_R: CE61.1 RE126.1 RE159.1 UE3.J5
ILMT_1.0V: PR706.2 PR707.1 PU700.13
ILMT_DDR: PR604.2 PR606.1 PU600.17
IMVP_VR_ON: PR1020.1 RE10.2 RE188.1 UC8.2 UE6.4 UE7.2
IMVP_VR_ON_EC: RE188.2 RPE6.2 UE3.N7 UE6.1
IMVP_VR_ON_P: PR1501.1 PR1512.1 RE9.1 RE10.1 UC8.4
IMVP_VR_PG: PR1017.1 RC390.1 UC10.1 UC10.2
IMVP_VR_PG_R: RC381.2 RC390.2 UC10.4 UCPU1.BA20
INTRUDER#: RC78.1 UCPU1.AP16
INV_PWM_R: D6.1 JEDP1.10 MC1.1 R16.2
ISEN1_GT: PC1029.2 PR1119.2 PR1153.2 PU1000.9
ISEN1_VCORE: PC1028.1 PR1104.2 PR1116.2 PU1000.21
ISEN2_GT: PC1026.2 PR1048.2 PR1117.2 PR1155.2 PU1000.10
ISEN2_VCORE: PC1027.1 PR1050.1 PR1107.2 PR1113.2 PU1000.22
ISUMN_GT: PC1017.2 PC1018.2 PC1024.1 PC1026.1 PC1029.1 PH1002.2 PR1031.1 PR1034.2 PR1036.1 PR1118.2 PR1154.2
ISUMN_SA: PC1011.1 PC1012.1 PC1013.1 PH1001.1 PR1021.2 PR1024.2 PR1025.1 PR1159.2
ISUMN_VCORE: PC1027.2 PC1028.2 PC1030.1 PC1031.1 PC1032.1 PH1003.1 PR1037.2 PR1038.1 PR1039.2 PR1106.2 PR1115.2
ISUMP_GT: PC1017.1 PC1018.1 PR1030.1 PR1034.1 PR1112.2 PR1152.2 PU1000.7
ISUMP_SA: PC1012.2 PC1013.2 PR1025.2 PR1026.2 PR1158.2 PU1000.32
ISUMP_VCORE: PC1031.2 PC1032.2 PR1038.2 PR1040.2 PR1105.2 PR1114.2 PU1000.19
JACK_PLUG: CA22.1 DA9.1 JAUDIO1.1 RA13.1
JTAG_CLK: JDEG1.4 RPE7.3 UE3.C8
JTAG_RST#: CE63.1 JTAG2.1 RE156.1 RE164.1 UE3.G13
JTAG_TDI: JDEG1.2 RPE7.1 UE3.E9
JTAG_TDO: JDEG1.5 RPE7.4 UE3.F6
JTAG_TMS: JDEG1.3 RPE7.2 UE3.C5
K52: R280.1 UCPU1.K52
KB_DET#: JKB1.4 RC41.2 UCPU1.C8
LAN_WAKE#: RC74.2 UCPU1.AM15 UE3.L3
LCD_GPIO1: JCAM1.7 JEDP1.7
LCD_GPIO2: JCAM1.8 JEDP1.8
LCD_TST: JEDP1.38 RE160.1 UE3.M2
LCD_VCC_TEST_EN: D13.2 UE3.E1
LDO_1.0V: PC711.1 PU700.16 PU700.17
LDO_IN: PC128.1 PD103.1 PD106.1 PD107.1 PD111.1 PR149.1 PU101.1
LID_CL_SIO#: RE237.1 UE3.N11
LINE1_L: CA80.1 U5.36
LINE1_L_C: CA80.2 RA57.1
LINE1_R: CA81.1 U5.35
LINE1_R_C: CA81.2 RA58.1
LPM_ZVM_N: PR1500.1 PR1511.1 UCPU1.AR56
LX_1.0V: PC703.2 PL701.1 PR700.1 PU700.6 PU700.19 PU700.20
LX_1V_PRIM: PL1503.1 PR1516.1 PU1501.2 PU1501.3
LX_3V: PC504.2 PL501.1 PR501.1 PU500.6 PU500.19 PU500.20
LX_5V: PC512.2 PL504.1 PR507.1 PU501.6 PU501.19 PU501.20
LX_DDR: PL601.1 PR602.1 PR612.2 PU600.11
LX_PRIM: PL1403.1 PR1416.1 PU1401.2 PU1401.3
LX_VCC_EDRAM: PL1501.1 PR1505.1 PU1500.2 PU1500.3
LX_VCCIO: PL1401.1 PR1403.1 PU1400.2 PU1400.3
ME_EN: R1.1 RH73.1 SW1.2
ME_FWP_EC: R1.2 SW1.3 UE3.G12
ME_SUS_PWR_ACK: RC83.2 UCPU1.AR13 UE3.B13
MEC_XTAL1: CE66.1 UE3.A1 YE2.1
MEC_XTAL2: CE67.1 RE178.2 YE2.2
MEC_XTAL2_R: RE178.1 UE3.A3
MEDIACARD_IRQ#: RC17.2 RR1.1 UCPU1.M1 UR1.32
MEM_CONFIG0: RH51.1 RH52.2 UCPU1.AP2
MEM_CONFIG1: RH53.1 RH54.2 UCPU1.AP1
MEM_CONFIG2: RH55.1 RH56.2 UCPU1.AP3
MEM_CONFIG3: RH57.1 RH58.2 UCPU1.AN3
MEM_CONFIG4: RH59.1 RH60.2 UCPU1.AN1
MEM_SMBCLK: QC1.6 RC18.1 RC388.1 UCPU1.R7
MEM_SMBDATA: QC1.3 RC20.1 RC387.1 UCPU1.R8
MIC2_VREFO_L: RA51.1 U5.28
MIC2_VREFO_R: RA56.1 U5.29
MON_PDN#: RE239.1 U24.B3
MON_SLOW: RE240.1 U24.C3
MONO_IN: CA16.2 U5.34
MPHYP_PWR_EN: RH77.1 UCPU1.AM10
MSCLK: JDEG1.6 RE201.2 RE209.1 UE3.H10
MSDATA: JDEG1.7 RE204.2 RE205.1 UE3.G9
MSM_N: PR1524.2 UCPU1.AP56
MUX_C_AUX_N: C1118.2 R5814.2 U21.J2
MUX_C_AUX_P: C1117.2 R5815.2 U21.J1
MUX_C_CC1: C175.1 D60.1 JUSBC3.A5 U21.K9 U21.L9
MUX_C_CC2: C176.1 D63.1 JUSBC3.B5 U21.K10 U21.L10
MUX_C_PD_SBU1: R227.1 U21.K8
MUX_C_PD_SBU2: R228.1 U21.L8
MUX_C_RESET_N: RT12.1 U21.F11
MUX_C_SBU1: D62.1 JUSBC3.A8 R46.2 R227.2
MUX_C_SBU2: D61.1 JUSBC3.B8 R47.2 R228.2
MUX_C_USB_OC2#: R232.2 RC55.1 UCPU1.D9
MUX_C_VBUS_L: C174.1 LT5.1 U21.A10 U21.B10 U21.H11 U21.J10 U21.J11 U21.K11
MUX_FLIP_SEL: R5811.2 R5818.2 R5819.1
MUX_I2C_CLK_R: QC2.1 R55.1 R57.1 R5811.1 U30.21
MUX_I2C_DATA_R: QC2.4 R56.1 R58.1 R5809.1 U30.22
MUX_PD_SBU1: R46.1 R62.1 U30.27
MUX_PD_SBU2: R47.1 R63.1 U30.26
MUX_USB3_RX0_N: D59.1 JUSBC3.B10 U30.31
MUX_USB3_RX0_P: D57.1 JUSBC3.B11 U30.30
MUX_USB3_RX1_N: D64.1 JUSBC3.A10 U30.39
MUX_USB3_RX1_P: D66.1 JUSBC3.A11 U30.40
MUX_USB3_TX0_N: C57.2 D58.1 JUSBC3.A3
MUX_USB3_TX0_N_C: C57.1 U30.34
MUX_USB3_TX0_P: C55.2 D56.1 JUSBC3.A2
MUX_USB3_TX0_P_C: C55.1 U30.33
MUX_USB3_TX1_N: C63.2 D65.1 JUSBC3.B3
MUX_USB3_TX1_N_C: C63.1 U30.36
MUX_USB3_TX1_P: C62.2 D67.1 JUSBC3.B2
MUX_USB3_TX1_P_C: C62.1 U30.37
MUX_USB_SEL: R5788.1 R5809.2 R5817.1
NB_LID#: R274.2 RE237.2 U26.3
NB_MUTE#: D7.1 UE3.A4
NRB_BIT: RC45.2 UCPU1.AR7
PA_USB2_RBIAS: RT42.1 UT2.H19
PANEL_BKEN_EC: D5.3 UE3.J9
PANEL_BKLEN: D5.2 UCPU1.R12
PANEL_ID: CE76.1 RE195.2 UE3.J10
PB_USB2_RBIAS: RT43.2 UT2.F19
PBAT_CHARGER_SMBCLK: PD104.2 PR152.2 PR314.1 RE112.1 UE3.N2
PBAT_CHARGER_SMBDAT: PD104.3 PR154.2 PR313.1 RE111.1 UE3.M3
PBAT_PRES#: PD105.2 PD105.3 PR157.2 PR158.1 PR325.1 UE3.F9
PBTN_SW#: CE68.1 RE187.2 SW3.1 SW3.3
PCH_ALW_ON: R90.1 RPE6.3 UE3.M8
PCH_BATLOW#: RC80.1 UCPU1.AU13
PCH_DPWROK_EC: RE248.1 UE3.F8
PCH_DPWROK_R: CC12.1 RC90.1 RC92.1 RE248.2 UCPU1.BB20
PCH_JTAG_TCK: RC238.1 RC258.1 UCPU1.B56
PCH_JTAG_TDI: RC234.1 RC254.1 UCPU1.D59
PCH_JTAG_TDO: RC233.1 RC255.2 UCPU1.A56
PCH_JTAG_TMS: RC235.1 RC252.1 UCPU1.C59
PCH_JTAG_TRST#: RC236.1 UCPU1.C61
PCH_JTAGX: RC237.1 RC257.1 UCPU1.A59
PCH_MUTE#: D8.1 UCPU1.AC3
PCH_PCIE_WAKE#: RC73.2 RC396.2 RE186.2 RT429.2 RT432.1 UCPU1.BB15 UE3.L1
PCH_PLTRST#: RC77.2 UC2.1 UC2.2 UCPU1.AN10
PCH_PLTRST#_5105: RE183.1 UE3.K1 UE5.4
PCH_PLTRST#_EC: JNGFF1.50 R164.1 RC76.1 RE193.2 U7.17 UC2.4 UE5.2 UR1.1 WL1.31
PCH_POPIRCOMP: RC107.1 UCPU1.AU16
PCH_PWR_EN: R85.2 R90.2 R91.2 U11.3
PCH_RSMRST#: RC90.2 RC250.1 RE155.1 RE177.2 UCPU1.AY17
PCH_RTCRST#: CC11.1 CMOS1.1 JAPS1.9 RC71.1 RE171.2 UCPU1.AM16
PCH_RTCX1: CC8.1 RC66.2 UCPU1.AM18 YC2.1
PCH_RTCX2: RC66.1 RC69.1 UCPU1.AM20
PCH_RTCX2_R: CC10.1 RC69.2 YC2.2
PCH_RTD3_CIO_PWR_EN: RC115.1 UCPU1.H5
PCH_SMB_ALERT#: RC26.1 UCPU1.R10
PCH_SPI_CLK: JSPI1.8 RC32.1 UCPU1.AV2
PCH_SPI_CLK_R: JSPI1.7 RC32.2 RP1.6 RP1.7
PCH_SPI_CLK_TPM: RE263.1 RP1.3
PCH_SPI_CLK_TPM_R: C32.1 RE263.2 U7.19
PCH_SPI_CS0#: JSPI1.10 RC33.1 UCPU1.AU3
PCH_SPI_CS0#_R: JSPI1.9 RC33.2 U1.1
PCH_SPI_CS2#: RE262.1 UCPU1.AU1
PCH_SPI_CS2#_R: RE262.2 U7.20
PCH_SPI_IO2: JSPI1.12 RC34.1 RC243.1 RH61.2 UCPU1.AW2
PCH_SPI_IO2_R: JSPI1.11 RC34.2 RP2.6
PCH_SPI_IO3: JSPI1.14 RC35.1 RH62.2 RH63.2 UCPU1.AU4
PCH_SPI_IO3_R: JSPI1.13 RC35.2 RP2.5
PCH_SPI_SI: JSPI1.4 RC30.1 RC241.1 UCPU1.AV3
PCH_SPI_SI_R: JSPI1.3 RC30.2 RP1.5 RP1.8
PCH_SPI_SI_TPM: RP1.4 U7.21
PCH_SPI_SO: JSPI1.6 RC31.1 UCPU1.AW3
PCH_SPI_SO_R: JSPI1.5 RC31.2 RP2.7 RP2.8
PCH_SPI_SO_TPM: RP2.1 U7.24
PCH_TBT_FORCE_PWR: RC117.1 UCPU1.D7
PCH_TBT_PERST#: RC395.2 RH90.1 RT428.1 UCPU1.U4
PCI_CLK_LPC0: RC19.1 UCPU1.AW9
PCI_CLK_LPC1: RC22.1 UCPU1.AY9
PCIE_PRX_CARDTX_N1: CR11.1 UCPU1.H13
PCIE_PRX_CARDTX_N1_C: CR11.2 UR1.8
PCIE_PRX_CARDTX_P1: CR10.1 UCPU1.G13
PCIE_PRX_CARDTX_P1_C: CR10.2 UR1.7
PCIE_PRX_SSDTX_N9: JNGFF1.5 UCPU1.E22
PCIE_PRX_SSDTX_N10: JNGFF1.17 UCPU1.F25
PCIE_PRX_SSDTX_N11: JNGFF1.29 UCPU1.E28
PCIE_PRX_SSDTX_P9: JNGFF1.7 UCPU1.E23
PCIE_PRX_SSDTX_P10: JNGFF1.19 UCPU1.E25
PCIE_PRX_SSDTX_P11: JNGFF1.31 UCPU1.E27
PCIE_PRX_TBTX_N5: CT4.1 UCPU1.F16
PCIE_PRX_TBTX_N5_C: CT4.2 UT2.V22
PCIE_PRX_TBTX_N6: CT21.1 UCPU1.G18
PCIE_PRX_TBTX_N6_C: CT21.2 UT2.P22
PCIE_PRX_TBTX_N7: CT8.1 UCPU1.F20
PCIE_PRX_TBTX_N7_C: CT8.2 UT2.K22
PCIE_PRX_TBTX_N8: CT12.1 UCPU1.G21
PCIE_PRX_TBTX_N8_C: CT12.2 UT2.F22
PCIE_PRX_TBTX_P5: CT2.1 UCPU1.E16
PCIE_PRX_TBTX_P5_C: CT2.2 UT2.V23
PCIE_PRX_TBTX_P6: CT19.1 UCPU1.F18
PCIE_PRX_TBTX_P6_C: CT19.2 UT2.P23
PCIE_PRX_TBTX_P7: CT6.1 UCPU1.E20
PCIE_PRX_TBTX_P7_C: CT6.2 UT2.K23
PCIE_PRX_TBTX_P8: CT10.1 UCPU1.F21
PCIE_PRX_TBTX_P8_C: CT10.2 UT2.F23
PCIE_PRX_WLANTX_N3: CH1.1 UCPU1.H16
PCIE_PRX_WLANTX_N3_C: CH1.2 WL1.36
PCIE_PRX_WLANTX_P3: CH2.1 UCPU1.G16
PCIE_PRX_WLANTX_P3_C: CH2.2 WL1.37
PCIE_PTX_CARDRX_N1: CR22.1 UCPU1.B17
PCIE_PTX_CARDRX_N1_C: CR22.2 UR1.4
PCIE_PTX_CARDRX_P1: CR23.1 UCPU1.A17
PCIE_PTX_CARDRX_P1_C: CR23.2 UR1.3
PCIE_PTX_SSDRX_N9: CD92.1 UCPU1.B23
PCIE_PTX_SSDRX_N9_C: CD92.2 JNGFF1.11
PCIE_PTX_SSDRX_N10: CD94.1 UCPU1.D23
PCIE_PTX_SSDRX_N10_C: CD94.2 JNGFF1.23
PCIE_PTX_SSDRX_N11: CD96.1 UCPU1.D24
PCIE_PTX_SSDRX_N11_C: CD96.2 JNGFF1.35
PCIE_PTX_SSDRX_P9: CD93.1 UCPU1.A23
PCIE_PTX_SSDRX_P9_C: CD93.2 JNGFF1.13
PCIE_PTX_SSDRX_P10: CD95.1 UCPU1.C23
PCIE_PTX_SSDRX_P10_C: CD95.2 JNGFF1.25
PCIE_PTX_SSDRX_P11: CD97.1 UCPU1.C24
PCIE_PTX_SSDRX_P11_C: CD97.2 JNGFF1.37
PCIE_PTX_TBRX_N5: CT3.2 UCPU1.C19
PCIE_PTX_TBRX_N5_C: CT3.1 UT2.Y22
PCIE_PTX_TBRX_N6: CT20.2 UCPU1.D20
PCIE_PTX_TBRX_N6_C: CT20.1 UT2.T22
PCIE_PTX_TBRX_N7: CT7.2 UCPU1.B21
PCIE_PTX_TBRX_N7_C: CT7.1 UT2.M22
PCIE_PTX_TBRX_N8: CT11.2 UCPU1.D21
PCIE_PTX_TBRX_N8_C: CT11.1 UT2.H22
PCIE_PTX_TBRX_P5: CT1.2 UCPU1.D19
PCIE_PTX_TBRX_P5_C: CT1.1 UT2.Y23
PCIE_PTX_TBRX_P6: CT5.2 UCPU1.C20
PCIE_PTX_TBRX_P6_C: CT5.1 UT2.T23
PCIE_PTX_TBRX_P7: CT22.2 UCPU1.A21
PCIE_PTX_TBRX_P7_C: CT22.1 UT2.M23
PCIE_PTX_TBRX_P8: CT9.2 UCPU1.C21
PCIE_PTX_TBRX_P8_C: CT9.1 UT2.H23
PCIE_PTX_WLANRX_N3: CH4.1 UCPU1.D17
PCIE_PTX_WLANRX_N3_C: CH4.2 WL1.39
PCIE_PTX_WLANRX_P3: CH5.1 UCPU1.C17
PCIE_PTX_WLANRX_P3_C: CH5.2 WL1.40
PCIE_RBIAS: RT7.2 UT2.N16
PCIE_RCOMPN: RC50.1 UCPU1.F5
PCIE_RCOMPP: RC50.2 UCPU1.E5
PCIE_WAKE#: RE185.1 RE186.1 WL1.29
PCIE_WAKE#_AR: RT430.2 RT431.2 RT432.2 RT433.2 UT2.W1
PCIE_WAKE#_R: R264.2 RE127.1 RE185.2 RT27.2 RT431.1 UE3.N13
PD1_EE_CLK: R5777.1 R5778.1 UT4.6
PD1_EE_CLK_F: R5777.2 U19.A3
PD1_EE_CS#: R167.2 R5776.1 R5781.1 UT4.1
PD1_EE_CS#_F: R5776.2 U19.B3
PD1_EE_DI: R5774.1 R5779.1 UT4.5
PD1_EE_DI_F: R5774.2 U19.B4
PD1_EE_DO: R168.2 R5775.1 R5780.1 UT4.2
PD1_EE_DO_F: R5775.2 U19.A4
PD1_EE_WP#: R169.2 UT4.3
PD1_GPIO0: TC3.1(TP-1) U19.B2
PD1_GPIO1: R173.1 R5751.1 U19.C2
PD1_GPIO2: R5749.1 TC48.1(TP-1) U19.D10
PD1_GPIO4: R175.1 U19.C10
PD1_GPIO5: TC5.1(TP-1) U19.E10
PD1_GPIO6: TC49.1(TP-1) U19.G10
PD1_GPIO7: R176.1 U19.D7
PD1_GPIO8: R178.1 U19.H6
PD1_GPIO8_EXT: R178.2 R5752.2 R5756.1
PD1_HOLD#: R170.2 UT4.7
PD1_LPS1: PQ133.2 PR213.2 PR214.1
PD1_LPS2: PD108.2 PQ100.5 PQ101.5
PD2_EE_CLK: R5778.2 R5783.2 U20.A3
PD2_EE_CS#: R5781.2 R5782.2 U20.B3
PD2_EE_DI: R5779.2 R5784.2 U20.B4
PD2_EE_DO: R5780.2 R5785.2 U20.A4
PD2_GPIO0: TC8.1(TP-1) U20.B2
PD2_GPIO1: R201.1 R5761.1 U20.C2
PD2_GPIO2: R5760.1 TC46.1(TP-1) U20.D10
PD2_GPIO4: R203.1 U20.C10
PD2_GPIO5: TC10.1(TP-1) U20.E10
PD2_GPIO6: TC47.1(TP-1) U20.G10
PD2_GPIO7: R204.1 U20.D7
PD2_GPIO8: R206.1 U20.H6
PD2_GPIO8_EXT: R206.2 R5744.1 R5762.2
PD2_LPS1: PQ135.2 PR220.2 PR221.1
PD2_LPS2: PD109.2 PQ113.5 PQ114.5
PD3_EE_CLK: U21.A3 UT6.6
PD3_EE_CS#: R223.2 U21.B3 UT6.1
PD3_EE_DI: U21.B4 UT6.5
PD3_EE_DO: R224.2 U21.A4 UT6.2
PD3_EE_WP#: R225.2 UT6.3
PD3_GPIO0: R5786.1 R5818.1 U21.B2
PD3_GPIO1: R229.1 R5769.1 U21.C2
PD3_GPIO2: R5768.1 U21.D10
PD3_GPIO4: R5770.1 U21.C10
PD3_GPIO5: R5791.1 U21.E10
PD3_GPIO6: TC45.1(TP-1) U21.G10
PD3_GPIO7: R232.1 U21.D7
PD3_GPIO8: R234.1 U21.H6
PD3_GPIO8_EXT: R234.2 R5792.2 R5793.1
PD3_HOLD#: R226.2 UT6.7
PD3_LPS1: PQ158.2 PR262.1 PR264.2
PD3_LPS2: PD110.2 PQ153.5 PQ155.5
PD3_USBC_AMSEL: R5787.1 R5835.2
PD3_USBC_AMSEL_R: R5833.1 R5835.1 U30.23
PD3_USBC_EN: R5803.1 R5804.2 U30.35
PD3_USBC_POL: R5786.2 R5805.1 R5806.2 R5816.1 U30.38
PD_MRESET_A: R181.1 R183.1 U19.E11
PD_MRESET_B: R209.1 R211.1 U20.E11
PD_MRESET_C: R237.1 R239.1 U21.E11
PECI_EC: RE153.2 UCPU1.A54
PECI_EC_R: RE153.1 UE3.K13
PM_SYS_RESET#: RC87.1 RC248.1
PME#: T12.1(TP-1) UCPU1.AU11
POWER_SW_IN#: CE69.1 RE184.2 RE187.1 UE3.D5
PRIM_PWRGD_GPIO024: RE247.1 UE3.C1
PRODUCT_ID_EC: RE249.1 RE250.2 UE3.J2
PTP_DIS#: JTP1.6 UE3.F4
PTP_INT#_EC: RE251.1 UE3.G2
PWM1_GT: PU1000.12 PU1150.1
PWM1_VCORE: PU1000.25 PU1100.1
PWM2_GT: PR1102.1 PU1000.13
PWM2_PH: PL1103.1 PL1107.1 PR1110.1 PR1112.1 PR1113.1 PR1114.1 PR1117.1 PU1101.8
PWM2_VCORE: PR1103.1 PU1000.26
PWM_SA: PU1000.35 PU1151.1
PWR_MONITOR_EC_SMBCLK: R285.2 UE3.A12
PWR_MONITOR_EC_SMBDAT: R286.2 UE3.N10
PWR_MONITOR_I2CCLK: R5820.2 UCPU1.AH12
PWR_MONITOR_I2CSDA: R5821.2 UCPU1.AH11
PWR_MONITOR_SMBCLK: R283.2 UCPU1.R9
PWR_MONITOR_SMBDAT: R284.2 UCPU1.W2
PWRGD_XDP: JXDP1.39 RC250.2 RC371.2
PWRM_SCL: R283.1 R285.1 R5820.1 RE232.1 U24.C4
PWRM_SDA: R284.1 R286.1 R5821.1 RE233.1 U24.D4
REM_DIODE1_N: CE58.1 CE83.1 CE93.2 QE12.3 QE20.1 QE20.2 UE3.A8
REM_DIODE1_P: CE58.2 CE83.2 CE93.1 QE12.1 QE12.2 QE20.3 UE3.A7
REM_DIODE2_N: CE59.1 CE87.2 CE94.2 QE14.3 QE21.1 QE21.2 UE3.A10
REM_DIODE2_P: CE59.2 CE87.1 CE94.1 QE14.1 QE14.2 QE21.3 UE3.A9
REM_DIODE3_N: CE90.1 CE91.2 CE95.2 QE15.1 QE15.2 QE22.3 UE3.B9
REM_DIODE3_P: CE90.2 CE91.1 CE95.1 QE15.3 QE22.1 QE22.2 UE3.B8
REM_DIODE4_N: CE62.1 CE89.1 QE19.3 UE3.A11
REM_DIODE4_P: CE62.2 CE89.2 QE19.1 QE19.2 UE3.B10
RESET_OUT#_R: CC89.1 JXDP1.47 RC241.2 RC370.2
RING2: RA51.2 RA52.1 U5.30
RING2_R: CA79.1 DA5.1 JAUDIO1.2 JAUDIO1.4 JAUDIO1.6 RA52.2
RREF: RR8.2 UR1.9
RTCRST_ON: QE10.2 RE176.1 UE3.F11
RTD3_CIO_PWR_EN: RC115.2 RT19.2 RT34.2 UT2.F1
RTD3_USB_PWR_EN: RT20.2 RT35.2 UCPU1.J5 UT2.D4
RUN_ON: QE11.5 RE191.2 RE192.1 UE8.4
RUN_ON#: QE11.2 QE11.3 RE174.1
RUN_ON_EC: RE6.2 RE192.2 RPE6.4 UC5.2 UE3.E8 UE8.2
RUN_ON_P: PR611.1 PR901.1 R82.1 R88.2 RE5.1 RE6.1 U12.3 U13.5 UC4.2 UC5.4
RUNPWROK: QE11.6 RE168.1 UE3.G3
SA_B+: PC1159.1 PC1160.1 PC1161.1 PC1162.1 PC1163.1 PL1108.2 PU1151.6 PU1151.12
SATA_PRX_SSDTX_N2: R31.1 UCPU1.E30
SATA_PRX_SSDTX_N2_C: JNGFF1.43 R31.2
SATA_PRX_SSDTX_P2: R30.1 UCPU1.F30
SATA_PRX_SSDTX_P2_C: JNGFF1.41 R30.2
SATA_PTX_SSDRX_N2: CD98.1 UCPU1.A25
SATA_PTX_SSDRX_N2_C: CD98.2 JNGFF1.47
SATA_PTX_SSDRX_P2: CD99.1 UCPU1.B25
SATA_PTX_SSDRX_P2_C: CD99.2 JNGFF1.49
SBIOS_TX: RE206.1 UCPU1.AB2
SD_CD#: JCR1.9 UR1.30
SD_CLK: CR17.1 JCR1.5 RR4.2
SD_CLK_L: RR4.1 UR1.17
SD_CMD: JCR1.3 UR1.19
SD_D2: JCR1.1 UR1.21
SD_D3: JCR1.2 UR1.20
SD_LN0_M: JCR1.19 UR1.25
SD_LN0_P: JCR1.18 UR1.26
SD_LN1_M: JCR1.21 UR1.23
SD_LN1_P: JCR1.22 UR1.22
SD_RCLK_M: JCR1.8 UR1.15
SD_RCLK_P: JCR1.7 UR1.16
SD_RCOMP: RC116.1 UCPU1.AB7
SD_REG2: CR20.2 UR1.24
SHD_CLK: T57.1(TP-1) UE3.J8
SHD_CS#: RE177.1 UE3.M5
SHD_IO2: RE245.1 UE3.L7
SHD_IO3: T56.1(TP-1) UE3.M6
SIO_EXT_SCI#: RC39.2 UCPU1.AN7
SIO_EXT_SMI#: RH81.2 UCPU1.A6
SIO_EXT_WAKE#: RC40.2 UCPU1.AD3 UE3.M12
SIO_PWRBTN#: JAPS1.11 RC247.1 UCPU1.BA15 UE3.K11
SIO_RCIN#: RC21.2 UCPU1.AW13
SIO_SLP_A#: JAPS1.6 UCPU1.AN16 UE3.M11
SIO_SLP_S0#: JAPS1.15 PR1400.1 PR1411.1 RE2.1 RE104.1 UC4.1 UCPU1.AT11
SIO_SLP_S3#: JAPS1.2 QE13.2 RE191.1 RT16.2 U16.1 UC5.1 UC8.1 UCPU1.AP15 UE3.K9 UE6.2 UE8.1
SIO_SLP_S4#: JAPS1.5 UC7.1 UCPU1.BA16 UE3.N12
SIO_SLP_S5#: JAPS1.4 UCPU1.AY16 UE3.N8
SIO_SLP_SUS#: PR703.1 PR801.1 PR1412.1 QE2.2 R91.1 RE115.1 UC6.1 UCPU1.AN15
SIO_SLP_WLAN#: QE23.1 UCPU1.BB17 UE3.D9
SKTOCC#: RC223.1 UCPU1.A65
SLEEVE: RA55.1 RA56.2 U5.31
SLEEVE_R: CA76.1 DA6.1 JAUDIO1.8 JAUDIO1.9 JAUDIO1.10 RA55.2
SLP_WLAN#_GATE: QE23.2 R5837.1 RE118.2 UE3.K10
SM_PG_CTRL: PR609.1 RC383.2 RE241.2 UC9.4
SM_RCOMP0: RC11.1 UCPU1.AR18
SM_RCOMP1: RC12.1 UCPU1.AT18
SM_RCOMP2: RC13.1 UCPU1.AU18
SML1_SMBCLK: RC23.1 UCPU1.W3 UE3.D8
SML1_SMBDAT: RC25.1 UCPU1.V3 UE3.E11
SNUB_1.0V: PC700.1 PR700.2
SNUB_1V_PRIM: PC1519.1 PR1516.2
SNUB_CHG1: PC342.1 PR316.2
SNUB_CHG2: PC343.1 PR317.2
SNUB_PRIM: PC1419.1 PR1416.2
SNUB_VCC_EDRAM: PC1510.1 PR1505.2
SNUB_VCCIO: PC1410.1 PR1403.2
SP7_SDWP: QR1.1 RR10.2 UR1.29
SPI_CLK_VROM: RC28.2 RP1.2 U1.6
SPI_IO2_VROM: RP2.3 U1.3
SPI_IO3_VROM: RP2.4 U1.7
SPI_SI_VROM: RP1.1 U1.5
SPI_SO_VROM: RP2.2 U1.2
SPK_CLK: JSPK1.6 RA64.2
SPK_DAT: JSPK1.7 RA63.2
SPK_DET#: RA62.1 UCPU1.W7
SPK_OUT_L+: CA73.1 DA2.1 JSPK1.1 LA6.2 RA39.1
SPK_OUT_L+_R: RA31.2 RA39.2 U6.27
SPK_OUT_L-: DA1.1 JSPK1.2 RA37.1 RA44.2
SPK_OUT_L-_R: RA29.2 RA37.2 U6.26
SPK_OUT_R+: CA75.1 DA4.1 JSPK1.3 LA8.2 RA43.1
SPK_OUT_R+_R: RA36.2 RA43.2 U6.30
SPK_OUT_R-: DA3.1 JSPK1.4 RA42.1 RA45.2
SPK_OUT_R-_R: RA34.2 RA42.2 U6.29
SPK_VDD: JSPK1.8 RA50.2 RA62.2
SPKR: RA4.1 RC118.2 UCPU1.AW5
SRTCRST#: CC9.1 RC68.1 UCPU1.AN18
SS_1.8VA: PC806.1 PU800.9
SS_1.8VU: PC906.1 PU900.9
SS_1V_PRIM: PC1520.1 PU1501.7
SS_PRIM: PC1420.1 PU1401.7
SS_VCC_EDRAM: PC1511.1 PU1500.7
SS_VCCIO: PC1411.1 PU1400.7
SSD_DEVSLP: JNGFF1.38 R29.2 UCPU1.J3
SSD_IFDET: R35.1 RC52.2 UCPU1.G4
SSD_PCIE_WAKE#: JNGFF1.54 R32.1 R264.1
SSD_PWR_EN: R81.1 R87.2 UCPU1.W12
SSD_SCP: R5827.2 RE288.1 RE289.1 UE3.H5
SSEQ0: R5798.2 R5836.1 R5839.1 U30.11
SUPPLIER_ID0: RH86.1 RH89.2 UCPU1.BB7
SUPPLIER_ID1: RH87.1 RH88.2 UCPU1.BA7
SUS_ON_EC: RE11.2 RE282.1 UC7.2 UE3.D2
SUS_ON_P: PR607.1 PR800.1 PR900.1 RE8.1 RE11.1 UC6.2 UC7.4
SUSACK#: UCPU1.AP11 UE3.K12
SUSCLK: CC93.2 R23.1 R33.2 RC57.1 UCPU1.BA17
SW_1.8VA: PL801.1 PR803.1 PU800.1 PU800.2 PU800.3
SW_1.8VU: PL901.1 PR903.1 PU900.1 PU900.2 PU900.3
SYS_PWROK: RC370.1 RE157.1 UCPU1.B6 UE3.G4
SYS_RESET#: JAPS1.13 RC88.2 RC89.2 UCPU1.B5
SYS_RESET#_R: RC87.2 RC89.1
TBT_A_AUX_N: CT49.2 R185.2 U19.J2
TBT_A_AUX_N_C: CT49.1 UT2.W15
TBT_A_AUX_P: CT47.2 R186.2 U19.J1
TBT_A_AUX_P_C: CT47.1 UT2.Y15
TBT_A_CC1: C150.1 D28.1 JUSBC1.B5 U19.K9 U19.L9
TBT_A_CC2: C149.1 D31.1 JUSBC1.A5 U19.K10 U19.L10
TBT_A_DBG_CTL1: R177.2 U19.E4
TBT_A_DBG_CTL2: R179.2 U19.D5
TBT_A_DEBUG3: R191.2 RT53.1 U19.L3
TBT_A_DEBUG4: R192.2 RT54.1 U19.K3
TBT_A_HPD: R175.2 RT36.2 UT2.M4
TBT_A_I2C_B_N: ML2.1 U19.L7
TBT_A_I2C_B_N_R: D37.1 JUSBC1.A7 ML2.2
TBT_A_I2C_B_P: ML2.4 U19.K7
TBT_A_I2C_B_P_R: D39.1 JUSBC1.A6 ML2.3
TBT_A_I2C_INT#: RT31.2 U19.C1 UT2.J4
TBT_A_LSRX: R189.1 R192.1 R5755.1 RT38.2 UT2.A4
TBT_A_LSRX_R: R189.2 U19.K4
TBT_A_LSTX: R187.1 R191.1 R5754.1 RT37.2 UT2.A5
TBT_A_LSTX_R: R187.2 U19.L4
TBT_A_RESET_N: RT17.1 U19.F11
TBT_A_SBU1: D30.1 JUSBC1.B8 R5755.2 U19.K8
TBT_A_SBU2: D29.1 JUSBC1.A8 R5754.2 U19.L8
TBT_A_USB2_D_N: U19.K5 UT2.D20
TBT_A_USB2_D_P: U19.L5 UT2.E20
TBT_A_USB2_T_N: ML3.4 U19.L6
TBT_A_USB2_T_N_R: D38.1 JUSBC1.B7 ML3.3
TBT_A_USB2_T_P: ML3.1 U19.K6
TBT_A_USB2_T_P_R: D36.1 JUSBC1.B6 ML3.2
TBT_A_USB_OC0#: R176.2 RC53.1 UCPU1.A9
TBT_A_VBUS_L: C148.1 LT3.1 U19.A10 U19.B10 U19.H11 U19.J10 U19.J11 U19.K11
TBT_B_AUX_N: CT50.2 R212.2 U20.J2
TBT_B_AUX_N_C: CT50.1 UT2.W16
TBT_B_AUX_P: CT48.2 R214.2 U20.J1
TBT_B_AUX_P_C: CT48.1 UT2.Y16
TBT_B_CC1: C163.1 D44.1 JUSBC2.B5 U20.K9 U20.L9
TBT_B_CC2: C162.1 D47.1 JUSBC2.A5 U20.K10 U20.L10
TBT_B_DBG_CTL1: R205.2 U20.E4
TBT_B_DBG_CTL2: R207.2 U20.D5
TBT_B_DEBUG3: R218.2 RT59.1 U20.L3
TBT_B_DEBUG4: R220.2 RT60.1 U20.K3
TBT_B_HPD: R203.2 RT39.2 UT2.G2
TBT_B_I2C_B_N: ML4.1 U20.L7
TBT_B_I2C_B_N_R: D53.1 JUSBC2.A7 ML4.2
TBT_B_I2C_B_P: ML4.4 U20.K7
TBT_B_I2C_B_P_R: D55.1 JUSBC2.A6 ML4.3
TBT_B_I2C_INT#: RT100.2 U20.C1 UT2.E2
TBT_B_LSRX: R216.1 R220.1 R5765.1 RT41.2 UT2.B5
TBT_B_LSRX_R: R216.2 U20.K4
TBT_B_LSTX: R215.1 R218.1 R5764.1 RT40.2 UT2.B4
TBT_B_LSTX_R: R215.2 U20.L4
TBT_B_RESET_N: RT15.1 U20.F11
TBT_B_SBU1: D46.1 JUSBC2.B8 R5764.2 U20.K8
TBT_B_SBU2: D45.1 JUSBC2.A8 R5765.2 U20.L8
TBT_B_USB2_D_N: U20.K5 UT2.D19
TBT_B_USB2_D_P: U20.L5 UT2.E19
TBT_B_USB2_T_N: ML5.4 U20.L6
TBT_B_USB2_T_N_R: D54.1 JUSBC2.B7 ML5.3
TBT_B_USB2_T_P: ML5.1 U20.K6
TBT_B_USB2_T_P_R: D52.1 JUSBC2.B6 ML5.2
TBT_B_USB_OC1#: R204.2 RC54.1 UCPU1.C9
TBT_B_VBUS_L: C161.1 LT4.1 U20.A10 U20.B10 U20.H11 U20.J10 U20.J11 U20.K11
TBT_BATLOW#: RT30.2 UCPU1.D8 UT2.F2
TBT_C_DBG_CTL1: R233.2 U21.E4
TBT_C_DBG_CTL2: R235.2 U21.D5
TBT_C_DEBUG1: R236.2 U21.L2
TBT_C_DEBUG2: R238.2 U21.K2
TBT_C_DEBUG3: R5787.2 U21.L3
TBT_C_DEBUG4: R5788.2 U21.K3
TBT_C_LSRX_R: TC50.1(TP-1) U21.K4
TBT_C_LSTX_R: R5790.2 U21.L4
TBT_CIO_PLUG_EVENT#: RT29.2 UCPU1.AB12 UT2.W2
TBT_DDC_CLK: RT11.2 UT2.Y2
TBT_DDC_DATA: RT13.2 UT2.Y1
TBT_DP_AUX_N: C65.1 C1118.1 UT2.Y19
TBT_DP_AUX_N_C: C65.2 R44.2 U30.25
TBT_DP_AUX_P: C64.1 C1117.1 UT2.W19
TBT_DP_AUX_P_C: C64.2 R45.2 U30.24
TBT_DP_HPD: R50.1 R5770.2 R5833.2 RT8.2
TBT_DP_HPD_R: R50.2 RC393.2 U30.32
TBT_DP_ML0_N: C53.1 UT2.R1
TBT_DP_ML0_N_C: C53.2 U30.10
TBT_DP_ML0_P: C52.1 UT2.R2
TBT_DP_ML0_P_C: C52.2 U30.9
TBT_DP_ML1_N: C56.1 UT2.N1
TBT_DP_ML1_N_C: C56.2 U30.13
TBT_DP_ML1_P: C54.1 UT2.N2
TBT_DP_ML1_P_C: C54.2 U30.12
TBT_DP_ML2_N: C59.1 UT2.L1
TBT_DP_ML2_N_C: C59.2 U30.16
TBT_DP_ML2_P: C58.1 UT2.L2
TBT_DP_ML2_P_C: C58.2 U30.15
TBT_DP_ML3_N: C61.1 UT2.J1
TBT_DP_ML3_N_C: C61.2 U30.19
TBT_DP_ML3_P: C60.1 UT2.J2
TBT_DP_ML3_P_C: C60.2 U30.18
TBT_FORCE_PWR: RC117.2 RT33.2 UT2.H4
TBT_I2C_CLK: RT26.2 U19.D2 U20.D2 UT2.U2
TBT_I2C_DATA: RT25.2 U19.D1 U20.D1 UT2.U1
TBT_JTAG_TCK: RT4.2 UT2.T4
TBT_JTAG_TDI: RT6.2 UT2.Y4
TBT_JTAG_TDO: RT3.2 UT2.W4
TBT_JTAG_TMS: RT5.2 UT2.V4
TBT_LDO_BMC_A: CT96.1 U19.E1
TBT_LDO_BMC_B: CT99.1 U20.E1
TBT_LDO_BMC_C: CT102.1 U21.E1
TBT_PERST_N: R164.2 RT428.2 UT2.L4
TBT_PWR_EN: RH70.1 UCPU1.AW7
TBT_RBIAS: RT28.1 UT2.H6
TBT_RESET_N_EC: RE132.1 RT69.1
TBT_RESET_N_EC_R: RE132.2 RE162.1 UE3.L8
TBT_RESET_N_R: RT12.2 RT14.2 RT15.2 RT17.2 RT22.2 RT69.2 UT2.F4
TBT_ROM_CLK: UT2.AB4 UT3.6
TBT_ROM_CS#: RT45.2 UT2.AC3 UT3.1
TBT_ROM_DI: UT2.AB3 UT3.5
TBT_ROM_DO: RT46.2 UT2.AC4 UT3.2
TBT_ROM_HOLD#: RT44.2 UT3.7
TBT_ROM_WP#: RT47.2 UT2.V1 UT3.3
TBT_RSENSE: RT28.2 UT2.J6
TBT_SLP_S3_N: RT16.1 RT84.2 UT2.D2
TBT_SNK0_DDC_CLK: RT80.2 RT91.1 UT2.Y5
TBT_SNK0_DDC_DATA: RT81.2 RT92.1 UT2.R4
TBT_SNK1_DDC_CLK: RT82.2 RT93.1 UT2.Y8
TBT_SNK1_DDC_DATA: RT83.2 RT94.1 UT2.N4
TBT_SRC_CFG1: R165.1 UT2.AA1
TBT_SRC_HPD: R166.1 RT8.1 UT2.G1
TBT_SVR_IND: C1115.1 C1116.1 LT1.1 UT2.C1 UT2.C2 UT2.D1
TBT_TEST_EN: RT18.2 UT2.E1
TBT_TEST_PWRG: RT21.2 UT2.AB5
TBT_TMU_CLK_OUT: C1083.1 RT32.2 UT2.V2
TBT_USB3_RX0_N: D27.1 JUSBC1.A10 UT2.A21
TBT_USB3_RX0_P: D25.1 JUSBC1.A11 UT2.B21
TBT_USB3_RX1_N: D32.1 JUSBC1.B10 UT2.B15
TBT_USB3_RX1_P: D34.1 JUSBC1.B11 UT2.A15
TBT_USB3_RX2_N: D43.1 JUSBC2.A10 UT2.B13
TBT_USB3_RX2_P: D41.1 JUSBC2.A11 UT2.A13
TBT_USB3_RX3_N: D48.1 JUSBC2.B10 UT2.A7
TBT_USB3_RX3_P: D50.1 JUSBC2.B11 UT2.B7
TBT_USB3_TX0_N: CT45.2 D26.1 JUSBC1.B3
TBT_USB3_TX0_N_C: CT45.1 UT2.B19
TBT_USB3_TX0_P: CT43.2 D24.1 JUSBC1.B2
TBT_USB3_TX0_P_C: CT43.1 UT2.A19
TBT_USB3_TX1_N: CT41.2 D33.1 JUSBC1.A3
TBT_USB3_TX1_N_C: CT41.1 UT2.B17
TBT_USB3_TX1_P: CT39.2 D35.1 JUSBC1.A2
TBT_USB3_TX1_P_C: CT39.1 UT2.A17
TBT_USB3_TX2_N: CT46.2 D42.1 JUSBC2.B3
TBT_USB3_TX2_N_C: CT46.1 UT2.B11
TBT_USB3_TX2_P: CT44.2 D40.1 JUSBC2.B2
TBT_USB3_TX2_P_C: CT44.1 UT2.A11
TBT_USB3_TX3_N: CT42.2 D49.1 JUSBC2.A3
TBT_USB3_TX3_N_C: CT42.1 UT2.B9
TBT_USB3_TX3_P: CT40.2 D51.1 JUSBC2.A2
TBT_USB3_TX3_P_C: CT40.1 UT2.A9
THERMATRIP1#: RE124.1 UE3.B12
THERMATRIP2#: CE86.1 QE16.1 RE215.2 UE3.H3
TOP_MUX_N: ML6.1 U21.L6
TOP_MUX_N_R: D70.1 JUSBC3.A7 ML6.2
TOP_MUX_P: ML6.4 U21.K6
TOP_MUX_P_R: D68.1 JUSBC3.A6 ML6.3
TOUCH_SCREEN_PD#: JEDP1.5 RH82.2 UCPU1.A7
TOUCHPAD_INTR#: RC379.1 UCPU1.BA5
TP_INTR#: JTP1.5 R117.2 RC379.2 RE251.2
TP_PW_EN: R270.2 U10.2 UE3.H9
TPM_DET: RH71.2 RH72.1 UCPU1.AM5
TPM_PIRQ#: RH75.2 U7.18 UCPU1.M3
TS_I2C_RST#: RR20.1 UCPU1.AN8
TYPE_ID: CE78.1 RE196.1 UE3.F2
UART1_RXD: JUART1.3 RH65.2 UCPU1.AC1
UART1_TXD: JUART1.2 RH64.2 UCPU1.AC2
UART_MISO: R5748.2 U19.F2 U20.E2
UART_MOSI: R5750.2 U19.E2 U20.F2
UPD1_ALERT#: RE108.1 U19.B6 UE3.F10
UPD1_SMBCLK: R180.1 RE107.1 U19.B5 UE3.C3
UPD1_SMBDAT: R182.1 RE105.1 U19.A5 UE3.B4
UPD2_ALERT#: RE109.1 U20.B6 UE3.F5
UPD2_SMBCLK: R208.1 RPE4.3 U20.B5 UE3.D7
UPD2_SMBDAT: R210.1 RPE4.4 U20.A5 UE3.E7
UPD3_ALERT#: RE231.1 U21.B6 UE3.H2
UPD3_SMBCLK: QC2.6 R55.2 R236.1 R5816.2 R5819.2 RPE4.2 U21.B5 UE3.M4
UPD3_SMBDAT: QC2.3 R56.2 R238.1 R5817.2 RPE4.1 U21.A5 UE3.M7
UPD_MRESET: R181.2 R209.2 R237.2 RT22.1
USB2_ID: RC48.1 UCPU1.AG3
USB3RN1: C67.1 UCPU1.H8
USB3RN1_C: C67.2 U30.4
USB3RP1: C66.1 UCPU1.G8
USB3RP1_C: C66.2 U30.5
USB3TN1: C69.1 UCPU1.C13
USB3TN1_C: C69.2 U30.7
USB3TP1: C68.1 UCPU1.D13
USB3TP1_C: C68.2 U30.8
USB20_N1: U21.K5 UCPU1.AB9
USB20_N5: L1.4 UCPU1.AJ1
USB20_N5_CONN: D2.2 D3.1 JCAM1.14 L1.3
USB20_N7: L2.1 UCPU1.AH1
USB20_N7_CONN: D74.3 L2.2 WL1.69
USB20_N10: ML1.4 UCPU1.AH7
USB20_N10_CONN: D20.2 JFP2.6 ML1.3
USB20_P1: U21.L5 UCPU1.AB10
USB20_P5: L1.1 UCPU1.AJ2
USB20_P5_CONN: D2.3 D4.1 JCAM1.13 L1.2
USB20_P7: L2.4 UCPU1.AH2
USB20_P7_CONN: D74.2 L2.3 WL1.70
USB20_P10: ML1.1 UCPU1.AH8
USB20_P10_CONN: D20.3 JFP2.5 ML1.2
USB_OC3#: RC56.1 UCPU1.B9
USBC_MCP23017_SMBCLK_R_A: R180.2 U19.L2
USBC_MCP23017_SMBCLK_R_B: R208.2 U20.L2
USBC_MCP23017_SMBDAT_R_A: R182.2 U19.K2
USBC_MCP23017_SMBDAT_R_B: R210.2 U20.K2
USBCOMP: RC47.1 UCPU1.AB6
VCI_IN2#: RE142.1 UE3.D4
VCI_IN3#: RE244.1 UE3.E4
VCORE_B+: PC1102.1 PC1103.1 PC1104.1 PC1105.1 PC1106.1 PC1107.1 PC1108.1 PC1112.1 PC1113.1 PC1114.1 PC1115.1 PC1117.1 PC1118.1 PC1119.1 PC1120.1 PC1121.1 PC1152.1 PC1153.1 PC1154.1 PC1155.1 PC1157.1 PC1158.1 PL1101.2 PL1102.2 PL1106.2 PR1002.1 PU1100.6 PU1100.12 PU1101.6 PU1101.12 PU1150.6 PU1150.12
VID0_EDRAM_VR: PR1504.2 PR1508.1 PU1500.9
VID0_EOPIO_VR: PR1515.2 PR1518.1 PU1501.9
VID0_PRIM_CORE: PR1415.2 PR1418.1 PR1419.2 PU1401.9
VID0_VCCIO: PR1405.2 PR1407.1 PU1400.9
VID1_EDRAM_VR: PR1503.2 PR1507.1 PU1500.8
VID1_EOPIO_VR: PR1514.2 PR1517.1 PU1501.8
VID1_PRIM_CORE: PR1414.2 PR1417.1 PR1420.2 PU1401.8
VID1_VCCIO: PR1404.2 PR1406.1 PU1400.8
VIDSCLK_R: RC159.1 UCPU1.A63
VIDSOUT_R: RC157.1 UCPU1.D64
VL: PC523.1 PU501.15
VR_SVID_ALERT#: PR1007.1 RC154.2 RC155.2
VR_SVID_ALERT#_C: PR1007.2 PU1000.44
VR_SVID_CLK: PR1003.2 PR1008.1 RC158.2 RC159.2
VR_SVID_CLK_C: PR1008.2 PU1000.45
VR_SVID_DATA: PR1004.2 PR1005.1 RC156.2 RC157.2
VR_SVID_DATA_C: PR1005.2 PU1000.43
VRALERT#: RC81.1 UCPU1.AM11
VSET_5105: CE79.1 RE199.1 UE3.C9
WLAN_WIGIG60GHZ_DIS#: DZ2.1 RE119.1 UE3.L13
WLAN_WIGIG60GHZ_DIS#_R: DZ2.2 RC181.1 WL1.28
XCLK_BIASREF: RC64.1 UCPU1.E42
XDP_BPM#0: RC245.1 UCPU1.C55
XDP_BPM#1: RC246.1 UCPU1.D55
XDP_BPM#2_R: T50.1(TP-1) UCPU1.B54
XDP_BPM#3_R: T51.1(TP-1) UCPU1.C56
XDP_DBRESET#: CC87.1 JXDP1.48 RC248.2
XDP_ITP_PMODE: RC125.1 RC249.2 UCPU1.E8
XDP_OBS0_1: JXDP1.21 T116.1(TP-1)
XDP_OBS1_1: JXDP1.23 T115.1(TP-1)
XDP_PIN1: JXDP1.1 RC253.2
XDP_PRSENT#: JXDP1.60 RC225.2 RC243.2
XDP_PWRBTN#: CC88.1 JXDP1.41 RC247.2
XDP_RST#: JXDP1.46 RC226.2 RC249.1
XDP_TCK0: JXDP1.57 RC228.2 RC237.2
XDP_TCK1: JXDP1.55 RC238.2
XDP_TDI: JXDP1.56 RC229.2 RC234.2
XDP_TDO: JXDP1.52 RC227.2 RC233.2
XDP_TMS: JXDP1.58 RC231.2 RC235.2
XDP_TRST#: JXDP1.54 RC232.2 RC236.2
XTAL24_IN: RC375.2 UCPU1.E37
XTAL24_IN_RU: RC377.2 UCPU1.E3
XTAL24_OUT: RC376.2 UCPU1.E35
XTAL24_OUT_RU: RC378.2 UCPU1.C7
XTAL_25_IN: RT72.2 UT2.D22
XTAL_25_IN_R: CT38.1 RT72.1 YT1.1
XTAL_25_OUT: RT24.2 UT2.D23
XTAL_25_OUT_R: CT37.1 RT24.1 YT1.3
N16374913: RC245.2 T70.1(TP-1)
N16374925: RC246.2 T73.1(TP-1)
N16378567: JXDP1.9 RC256.2
N16812268: R252.1 U22.7
N16812288: C312.1 U22.1
N17750417: RR9.2 UR1.28
N17806340: C1071.2 R268.1 R269.2 U10.9
N17806379: R271.1 U10.7
N17806392: R269.1 U10.8
N17806402: C1071.1 U10.1
N17907875: RE234.2 U24.C2
N18201138: CC91.1 RC374.2 RC377.1 YC3.3
N18201153: CC90.1 RC374.1 RC378.1 YC3.1
N18408062: T58.1(TP-1) UE3.D6
N18424924: PC350.1 PR328.2 PR341.1 PR342.1
N18537697: PL1150.1 PR1151.1 PR1152.1 PR1153.1 PU1150.8
N18676843: PC131.1 PQ126.1 PR149.2 PR153.1 PU101.4
N18676867: PC109.2 PQ100.4 PQ133.1 PR100.2 PR106.1
N18676872: PC111.2 PQ101.4 PQ104.1 PR103.2 PR109.1
N18676880: PQ109.6 PR107.2
N18676884: PQ109.5 PR123.2 PR176.1
N18676885: PQ109.2 PQ109.3 PR115.2
N18676889: PQ104.2 PR101.2 PR107.1
N18676894: PC123.2 PQ113.4 PQ135.1 PR128.2 PR133.1
N18676898: PQ200.1 PR121.1 PR132.1
N18676900: PC124.2 PQ114.4 PQ115.1 PR130.2 PR134.1
N18676906: PQ115.2 PR118.1 PR129.2
N18676911: PQ121.2 PQ121.3 PR139.2
N18676915: PQ121.6 PR118.2
N18676918: PQ121.5 PR136.2 PR177.1
N18676946: PQ119.2 PR135.1 PR179.2
N18676960: PQ108.2 PR114.1 PR178.2
N18677037: PQ134.2 PQ134.3 PR215.2
N18677040: PQ134.6 PR214.2
N18677045: PQ134.5 PR217.2 PR228.1
N18677050: PQ136.2 PQ136.3 PR222.2
N18677052: PQ136.6 PR221.2
N18677057: PQ136.5 PR224.2 PR229.1
N18677160: PC130.1 PQ125.2 PR151.2
N18677163: PQ124.2 PQ125.5 PR155.1 PR156.1
N18677164: PQ125.6 PR156.2
N18677165: PC125.1 PQ123.2 PR148.1 PR150.1
N18677185: PQ125.3 PR150.2
N18677212: PC136.1 PQ106.2 PR122.2 PR166.1
N18677217: PC137.1 PQ118.2 PR132.2 PR172.1
N18677243: PQ127.5 PQ127.6 PR124.2
N18677245: PQ122.1 PQ127.3 PR142.2 PR203.2
N18677247: PQ122.6 PR192.1
N18677249: PQ127.2 PR201.2 PR203.1
N18677256: PQ120.5 PQ120.6 PR127.2
N18677258: PQ120.3 PQ128.1 PR143.2 PR204.2
N18677261: PQ120.2 PR144.2 PR204.1
N18677267: PQ128.6 PR200.1
N18677269: PQ117.5 PQ117.6 PR171.2
N18677271: PQ117.2 PR196.2 PR205.1
N18677274: PQ117.3 PQ128.4 PR173.2 PR205.2
N18677277: PQ128.3 PR170.1
N18677285: PQ129.5 PR206.2 PR207.2
N18677287: PQ129.6 PR175.2 PR207.1 PR208.1
N18677294: PQ129.3 PR209.1
N18677306: PQ128.2 PR145.2
N18677309: PQ128.5 PR195.2
N18677312: PQ122.2 PR138.2
N18677317: PQ122.5 PR206.1
N18677319: PQ129.2 PR202.2
N18677336: PQ150.2 PR268.2 PR273.1
N18677339: PQ151.5 PR259.2 PR266.1
N18677341: PC287.1 PQ156.2 PR271.2 PR275.1
N18677367: PC286.2 PQ153.4 PQ158.1 PR260.1 PR263.2
N18677371: PQ201.1 PR141.1 PR271.1
N18677375: PC291.2 PQ150.1 PQ155.4 PR261.2 PR274.1
N18677393: PQ149.5 PR272.1 PR278.2
N18677420: PQ157.1 PR274.2
N18677423: PQ157.2 PR267.1 PR277.2
N18677424: PQ149.2 PQ149.3 PR270.2
N18677428: PQ149.6 PR273.2
N18677440: PQ151.2 PQ151.3 PR276.2
N18677470: PQ151.6 PR262.2
N18681292: PC349.1 PR327.2
N18681306: PR300.3 PR301.1
N18681307: PR300.2 PR302.1
N18681310: PD300.1 PD301.1 PR309.1
N18681327: PC330.1 PR306.1
N18681333: PC341.1 PR318.1 PU300.3
N18681352: PC336.2 PR311.2
N18681512: PR332.2 PU300.26
N18681547: PR322.1 PU300.27
N18681577: PL302.1 PR300.4
N18683466: PC504.1 PR500.2
N18683478: PR506.2 PU501.9
N18683485: PR503.2 PU500.12
N18683537: PR510.2 PU501.12
N18683542: PC517.1 PU501.17
N18683563: PC512.1 PR505.2
N18683566: PC511.2 PR504.1
N18683579: PC525.2 PR511.1
N18683583: PR512.1 PU501.14
N18684722: PC609.2 PR603.2 PR605.1 PU600.16
N18684725: PC605.1 PU600.12
N18684739: PC600.1 PC601.1 PC602.1 PC603.1 PL600.2 PU600.10
N18684756: PC607.1 PU600.14
N18684795: PC614.1 PU600.3
N18684816: PC604.1 PR602.2
N18686200: PC803.1 PC804.1 PC805.1 PC808.1 PL800.2 PU800.10 PU800.11 PU800.12
N18686203: PC807.1 PR803.2
N18686225: PR806.1 PU800.7
N18686705: PC903.1 PC904.1 PC905.1 PL900.2 PU900.10 PU900.11 PU900.12
N18686709: PC907.1 PR903.2
N18686770: PR906.1 PU900.7
N18687217: PC1004.2 PR1006.2 PU1000.2
N18687233: PC1006.2 PR1018.2 PU1000.4
N18687239: PC1007.2 PR1018.1
N18687245: PC1020.1 PR1035.1 PU1000.28
N18687260: PC1023.1 PR1032.2
N18687261: PC1021.1 PR1032.1 PU1000.29
N18687263: PC1022.1 PR1033.2
N18687264: PR1028.1 PR1029.1 PR1033.1 PU1000.30
N18687267: PC1019.2 PR1036.2 PU1000.8
N18687270: PC1019.1 PR1031.2
N18687277: PC1005.2 PR1011.2 PU1000.3
N18687285: PC1010.2 PR1024.1
N18687287: PC1010.1 PR1021.1 PU1000.33
N18687304: PR1009.2 PU1000.46
N18687317: PR1023.1 PU1000.36
N18687330: PC1002.1 PR1001.2 PU1000.42
N18687344: PC1035.1 PR1043.1 PU1000.14
N18687348: PH1004.1 PR1041.1 PR1044.1
N18687349: PR1041.2 PU1000.15
N18687351: PR1016.1 PU1000.40
N18687354: PR1015.1 PU1000.39
N18687357: PR1014.1 PU1000.38
N18687362: PR1013.1 PU1000.37
N18687368: PC1039.1 PR1047.2
N18687369: PC1037.1 PR1047.1 PU1000.16
N18687371: PC1038.1 PR1045.2
N18687373: PR1042.1 PR1045.1 PR1046.1 PU1000.17
N18687382: PC1033.1 PR1037.1 PU1000.20
N18687384: PC1033.2 PR1039.1
N18687414: PR1012.2 PR1017.2 PU1000.47
N18687427: PR1049.1 PU1000.23
N18687435: PC1003.1 PR1002.2 PU1000.41
N18687438: PR1020.2 PU1000.48
N18687442: PR1019.2 PR1022.2 PR1027.2 PU1000.5
N18687451: PH1000.2 PR1010.2 PR1011.1
N18687453: PH1002.1 PR1030.2
N18687460: PH1001.2 PR1026.1
N18687461: PH1003.2 PR1040.1
N18687486: PC1009.2 PR1022.1
N18687490: PC1034.1 PR1042.2
N18687497: PC1015.1 PR1028.2
N18687570: PC1008.2 PR1019.1
N18689541: PC1109.1 PR1101.2
N18689543: PC1116.1 PR1110.2
N18689566: PL1100.1 PR1101.1 PR1104.1 PR1105.1 PU1100.8
N18689603: PC1101.1 PU1100.5
N18689605: PC1101.2 PR1100.1
N18689606: PR1100.2 PU1100.3
N18689649: PC1111.1 PU1101.5
N18689651: PC1111.2 PR1109.1
N18689652: PR1109.2 PU1101.3
N18689661: PR1102.2 PR1103.2 PU1101.1
N18689690: PR1108.2 PR1111.2 PU1101.2
N18690739: PC1156.1 PR1151.2
N18690750: PC1151.1 PU1150.5
N18690752: PC1151.2 PR1150.1
N18690753: PR1150.2 PU1150.3
N18695182: PR1421.1 PR1422.1 PU1401.5
N18695231: PR1408.2 PR1409.1 PU1400.5
N18695251: PR1400.2 PR1423.2 PU1400.14
N18695252: PR1411.2 PR1424.2 PU1401.14
N18696495: PR1530.1 PR1531.2 PU1501.5
N18696540: PR1506.2 PR1509.1 PU1500.5
N18696541: PR1510.1 PR1526.1 PU1500.6
N18696557: PR1500.2 PR1522.2 PU1500.14
N18696559: PR1511.2 PR1523.2 PU1501.14
N18696560: PR1514.1 PR1515.1 PR1524.1 PR1525.2
N18696573: PR1519.2 PR1520.1 PR1531.1
N18696576: PR1521.1 PR1527.1 PR1530.2 PU1501.6
N18758153: CC6.1 RC59.2 RC375.1 YC1.3
N18758183: CC7.1 RC59.1 RC376.1 YC1.1
N18759595: PL1151.1 PR1157.1 PR1158.1 PU1151.8
N18759629: PC1166.1 PR1157.2
N18759898: PC1165.1 PR1156.1
N18759902: PR1156.2 PU1151.5
N18759906: PC1165.2 PU1151.3
N18776555: PC352.1 PR325.2 PR326.1 PU300.25
N18960099: PC605.2 PR612.1
N19171666: LED6.2 R288.2
N19330817: JNGFF1.68 R33.1
N19331723: JNGFF1.69 R34.2 R35.2
N19584540: RT51.1 RT52.1 RT56.1 U19.F10
N19588651: RT96.1 U20.L11
N19588867: RT57.1 RT58.1 RT62.1 U20.F10
N20205431: RT95.1 U19.L11
N20206948: RT97.1 U21.L11
N20448862: RTCD1.1 RTCR2.1
N20737286: R230.1 R5789.1 U21.E2
N20877664: R5794.2 U19.A6 U19.A7 U19.A8 U19.B7
N20877810: R5795.1 U20.A6 U20.A7 U20.A8 U20.B7
N20878169: R5796.2 U21.A6 U21.A7 U21.A8 U21.B7
N20949883: JEDP1.15 RR20.2
N21092755: CE43.1 CE44.1 CE45.1 RE252.1 UE3.B7 UE3.K2
N21131251: JEDP1.13 RR18.2
N21131254: JEDP1.12 RR19.2
N21271671: RA66.1 U6.4
N21352667: T69.1(TP-1) UE3.H8
N21352765: T124.1(TP-1) UE3.H11
N22221959: RR21.2 RR22.2 RR23.1
N22930798: PQ199.1 PR112.1 PR122.1
N22930931: PQ199.3 PR108.2 PR110.1
N22932645: PQ200.3 PR117.2 PR119.1
N22934326: PQ201.3 PR126.2 PR140.1
N23434155: PD305.1 PD306.1 PR335.1 PR336.2 PU301.1
N23434758: PR345.1 PU301.4
N23434902: PD305.2 PR321.2
N23434905: PD305.3 PR343.2
N23434908: PD306.2 PR344.2
N23437101: PR346.2 PU301.2
N23538625: R5823.2 UZ1.3
N23545560: R5825.1 U31.7
N23545577: C1121.1 U31.1
N23849155: RE261.2 UE3.K7
N23886095: RC389.1 UCPU1.J1
N24109146: JFAN1.4 LT6.2
N24110025: JFAN2.4 LT7.2
N24419592: JFP2.2 RE273.2
N24419725: LED6.1 RE275.2
N25181277: PQ106.1 PR106.2
N25182593: PQ108.1 PR109.2
N25183368: PQ118.1 PR133.2
N25184290: PQ119.1 PR134.2
N25185028: PQ156.1 PR260.2
N25186288: PQ199.2 PR111.1
N25186457: PQ200.2 PR120.1
N25186576: PQ201.2 PR137.1
N25190486: PR336.1 PT104.1(TP-1)
N25234876: JNGFF1.8 R5827.1
N25447747: RE27.2 RE29.1 U7.4
N25689392: D75.2 QE23.3 RE290.1
N28314143: T4.1(TP-1) UCPU1.AT52
N28323796: T6.1(TP-1) UCPU1.AP43
N28323807: T5.1(TP-1) UCPU1.AN43
N28344853: T7.1(TP-1) UCPU1.AT13
N28375965: T1.1(TP-1) UCPU1.G46
N28375966: T2.1(TP-1) UCPU1.F46
N28424999: T27.1(TP-1) UCPU1.AW71
N28425002: T28.1(TP-1) UCPU1.AW70
N28842863: CC65.1 UCPU1.AL1
N28843886: CC76.1 UCPU1.BB10
N28856399: T23.1(TP-1) UCPU1.BA70
N28856402: T25.1(TP-1) UCPU1.BA68
N28857231: T16.1(TP-1) UCPU1.BB68
N28857234: T17.1(TP-1) UCPU1.BB69
N28857237: T18.1(TP-1) UCPU1.AK13
N28857240: T19.1(TP-1) UCPU1.AK12
N28861827: RC126.1 UCPU1.C64
N28938912: CC5.2 RC28.1
N29708559: T24.1(TP-1) UCPU1.AY4
N29708561: T26.1(TP-1) UCPU1.BB3
N29708599: T20.1(TP-1) UCPU1.AU5
N29708601: T21.1(TP-1) UCPU1.AT5
N29708639: T22.1(TP-1) UCPU1.BB5
N30340494: RC152.2 UCPU1.G61
N31739843: T9.1(TP-1) UCPU1.AY8
N34458680: RA7.1 U5.2
N34458868: CA19.1 U5.24
N34458871: CA19.2 U5.23
N34458958: CA23.1 U5.32
N34459429: CA26.1 RA16.1 U5.39
N34459663: CA24.1 U5.38
N34459862: CA30.1 U5.25
N34711424: RA3.1 U5.33
N34711571: CA16.1 CA18.1 R17.1 RA2.2 RA4.2
N34711769: CA25.2 U5.21
N34741776: CA62.2 U6.2
N34741906: CA57.1 RA23.1 RA24.2 U6.3
N34741924: CA54.1 U6.40
N34768323: CA63.2 U6.50
N34768417: CA65.2 U6.41
N34768420: CA64.2 U6.49
N34769506: CA68.2 RA46.1
N34769927: CA69.2 RA47.1
N34769983: CA70.2 RA48.1
N34770039: CA71.2 RA49.1
N34828335: RA24.1 U6.6
N34828474: CA66.2 U6.22
N34828656: RA40.2 U6.5
N34866610: CA67.1 U6.23
N34949443: CA47.1 CA48.1 RA22.1 U6.21
N36038235: CA20.2 RA11.2 RA13.2 U5.48
N39070459: QE13.3 RE219.1 RE222.2
N39070470: QE16.2 RE219.2
N39388747: CA27.2 U5.19
N40373163: CD80.2 RD19.1
N40373501: CD81.2 RD20.1
N40376778: CD79.2 RD12.1
N44109348: QE10.1 RE171.1
N44325406: RE152.1 RE154.1 UE3.B1
N44325565: RE115.2 UE3.N4
N44325691: CE65.1 RE172.2
N44759345: JESPI1.8 RE193.1
N50638473: QH1.3 R67.1
N52708219: D11.1 JFAN1.2 R38.1
N52922958: R79.1 U11.13 U11.14
N52922960: C87.1 U11.10
N52923110: C83.1 U11.12
N52925836: R84.1 U12.8 U12.9
N52925896: R80.1 U12.13 U12.14
N52925901: C86.1 U12.10
N52926051: C84.1 U12.12
N52930519: R94.1 U13.8 U13.9
N52930580: C98.1 U13.10
N52930730: C94.1 U13.12
N52934489: R95.1 U14.8 U14.9
N52934545: R93.1 U14.13 U14.14
N52934547: C99.1 U14.10
N52934693: C97.1 U14.12
N56242723: T3.1(TP-1) UCPU1.AW50
N56822254: C151.1 U19.H7
N56822270: R184.1 U19.G2
N56822627: TC1.1(TP-1) U19.G4
N56822629: TC2.1(TP-1) U19.F4
N56856077: RT55.1 U19.F1
N56977728: R22.1 U7.27
N57177583: R101.1 UZ3.6
N57177874: RZ2.2 UZ5.4
N57177931: R103.1 UZ5.6
N57178338: R102.1 UZ4.6
N57313034: RC63.2 UCPU1.AT8
N57317696: RC110.2 SW1.1
N57319429: T31.1(TP-1) UCPU1.AK62
N57319432: T32.1(TP-1) UCPU1.AL61
N57670088: T11.1(TP-1) UCPU1.AW15
N58842401: T8.1(TP-1) UCPU1.AD4
N58864976: R81.2 R82.2 U11.5
N59153523: RE104.2 U7.3
N59894012: RE2.2 U7.29
N61547946: QZ1.1 R98.1
N61553916: R73.1 UZ1.6
N63216045: QH1.6 R68.1
N63216077: QH2.3 R69.1
N63216109: QH2.6 R70.1
N63239426: Q4.1 R71.1
N64008725: QE2.5 QE2.6 R116.2
N64008885: QE2.3 R115.2
N64926554: CE84.1 R4.2
N65482285: CC77.1 R3.2
N66491485: JSPI1.16 RC36.2 RC37.2
N67506216: R23.2 WL1.27
N67571980: C164.1 U20.H7
N67571982: R213.1 U20.G2
N67572033: TC6.1(TP-1) U20.G4
N67572034: TC7.1(TP-1) U20.F4
N67572050: RT61.1 U20.F1
N67581669: C177.1 U21.H7
N67581671: R240.1 U21.G2
N67581722: TC11.1(TP-1) U21.G4
N67581723: TC12.1(TP-1) U21.F4
N67581739: RT67.1 U21.F1
N67581740: R230.2 U21.F2
N67581787: RT63.1 RT64.1 RT68.1 U21.F10
N67727375: D12.1 JFAN2.2 R41.1
N168123855: R251.1 U22.8
N235456705: R5824.1 U31.8

Pads without a net: D73 2; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JCR1 16; JEDP1 20; JNGFF1 6 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JSPI1 1 2 17; JUSBC3 7 8; JXDP1 45; PD306 3; PU101 3; PU300 13; PU500 10 15; PU501 10 16; PU700 9 10 12; PU1000 27; PU1100 4 9 10 13; PU1101 4 9 10 13; PU1150 4 9 10 13; PU1151 4 9 10 13; PU1400 4; PU1401 4; PU1500 4; PU1501 4; R5771 1; R5772 1; R5773 1; R5791 2; RC253 1; RPE6 1; U1 9; U5 42 43 44 45 47; U6 13 31 32 35 36 38; U7 2 5 6 7 10 11 12 13 15 25 26 28 30 31; U19 A9 B9; U20 A9 B9; U21 A9 B9; UC9 1; UCPU1 A3 A4 A11 A13 A15 A19 A26 A27 A29 A31 A33 A36 A38 A40 A52 A69 AB1 AB4 AB13 AD1 AD2 AD6 AD7 AD9 AD10 AD11 AD12 AF6 AF7 AF8 AF9 AF11 AF12 AF13 AG1 AG2 AH3 AJ3 AK6 AK7 AK9 AK10 AL25 AL27 AM1 AM2 AM3 AM4 AN2 AP4 AP8 AP13 AT43 AU2 AU56 AW1 AW17 AW20 AW42 AW48 AW68 AW69 AY1 AY2 AY7 AY20 AY21 B2 B3 B7 B11 B13 B15 B19 B26 B27 B29 B31 B33 B36 B38 B40 B52 B69 B70 BA3 BA4 BA8 BA9 BA47 BA50 BB2 BB4 BB9 BB11 BB46 BB52 C2 C4 C11 C12 C15 C16 C27 C28 C29 C31 C32 C33 C36 C37 C38 C41 C54 C70 C71 D1 D3 D4 D5 D12 D15 D16 D27 D28 D29 D31 D32 D33 D36 D37 D38 D41 D54 D71 E1 E2 E10 E61 F6 F10 F11 F15 F52 F60 F61 G11 G15 H1 H2 H6 H10 H11 J2 J4 J6 J10 J68 J71 K45 K46 M2 M4 N1 N2 N3 N9 N11 N12 P2 P3 U11 U12 V1 V2 W4 W8 W10 W11; UD41 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD42 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD43 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD44 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UE3 L2 M1 N3; UE5 1; UE7 1; UR1 31; UT2 A23 AB23 AC23 B23 E18 V18; UZ2 3; WL1 1 2 3 7 8 9 10 11 12 13 14 15 16 18 19 21 22 24 25 45 46 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 64 65 66 67

## Via types
v1: diameter 0.254, hole 0.102, TOP to GND1, 1797 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 752 vias
v3: diameter 0.406, hole 0.203, GND1 to GND3, 1971 vias
v4: diameter 0.254, hole 0.102, GND3 to BOTTOM, 2592 vias
v5: diameter 0.254, hole 0.102, IN4 to BOTTOM, 407 vias
v6: diameter 0.254, hole 0.102, GND3 to IN4, 366 vias
v7: diameter 0.254, hole 0.102, TOP to IN1, 512 vias
v8: diameter 0.457, hole 0.203, TOP to BOTTOM, 3596 vias
v9: diameter 0.254, hole 0.102, IN1 to GND1, 292 vias
v10: diameter 0.508, hole 0.254, TOP to BOTTOM, 44 vias
v11: diameter 0.406, hole 0.203, TOP to BOTTOM, 126 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V_DDR_OT: length 3.6
  BOTTOM w0.254: PR600.1 113.92,4.21 115.21,4.21 115.6,4.6 116.32,4.6 116.57,4.86 PU600.19
1.2V_DDR_PG: length 4.8
  BOTTOM w0.254: PU600.18 117.02,4.48 116.77,4.22 115.76,4.22 115.34,3.8 v2(114.86,3.8) 114.41,3.8 113.45,2.84 PR601.1
1.8VA_PWROK: length 221.6
  TOP w0.095: v7(159.3,5.63) 160.56,6.9 v2(160.56,13.34) 160.56,14.07 v1(160.89,14.4)
  IN1 w0.076: v9(67.87,1.87) 67.88,1.88 74.34,1.88 74.63,2.17 77.55,2.17 81.33,5.95 114.68,5.95 115.95,7.23 116.26,7.23 118.6,9.56 138.38,9.56 139.01,10.2 144.32,10.2 144.71,9.81 149.25,9.81 154.14,4.92 158.58,4.92 v7(159.3,5.63)
  GND1 w0.095: v3(161.05,14.7) 161.05,14.56 v1(160.89,14.4) ; v3(29.35,13.85) 29.68,14.18 v1(29.96,14.18) ; v9(67.87,1.87) 67.88,1.88 68.06,1.88 v3(68.24,1.7)
  IN3 w0.064: v3(68.24,1.7) 67.65,1.12 44.88,1.12 43.77,2.24 34.05,2.24 32.44,3.85 30.34,3.85 29.45,4.75 29.45,6.59 29.69,6.83 29.69,9.94 29.1,10.53 29.1,11.45 29.39,11.74 29.39,13.81 v3(29.35,13.85)
  GND3 w0.095: v3(161.05,14.7) 160.98,14.7 v6(160.45,15.22)
  IN4 w0.076: v6(160.45,15.22) 160.43,15.25 159.98,15.25 158.52,16.71 158.52,25.79 156.7,27.6 156.7,32.45 155.58,33.57 155.58,34.74 153.87,36.46 153.87,37.58 154.52,38.23 154.52,40.68 155,41.15 155,47.73 155.63,48.36 155.63,50.53 154.14,52.02 154.14,54.76 151.79,57.11 151.79,58.3 151,59.09 v5(151,59.44)
  BOTTOM w0.095: v5(151,59.44) 151.29,59.73 RE253.1 151.29,60.38 150.69,60.98 150.69,61.63 152.26,63.2 152.91,63.2 153.8,64.09 PR805.1 153.91,63.65 153.81,63.55 153.81,63 154,62.81 157.35,62.81 157.39,62.85 PU800.4
