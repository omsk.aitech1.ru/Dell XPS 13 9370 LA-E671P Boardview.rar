# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N20205431: length 4.4
  TOP w0.095: v2(13.95,25.91) 13.76,26.11 RT95.1
  TOP w0.254: RT95.1 14.44,26.88 15.2,27.64 15.81,27.64 U19.L11
N20206948: length 1.6
  BOTTOM w0.095: RT97.1 290.13,20.12 290.13,18.94 U21.L11
N20448862: length 2.5
  BOTTOM w0.508: RTCD1.1 251.56,10.29 252.26,9.58 RTCR2.1
N20737286: length 6.2
  IN4 w0.076: v5(285.83,15.56) 285.76,15.63 285.23,15.63 285.19,15.59 283.57,15.59 283.09,15.11 281.85,15.11 281.64,15.32 v5(281.47,15.32)
  BOTTOM w0.095: R230.1 280.66,15.36 R5789.1 ; v5(285.83,15.56) 285.55,15.83 U21.E2
N20878169: length 3.8
  TOP w0.508: R5796.2 288.37,15.81 288.66,15.51 v8(288.66,13.37)
  BOTTOM w0.095: 287.82,13.43 v2(287.82,12.45)
N20949883: length 3.6
  BOTTOM w0.095: RR20.2 44.73,58.71 44.02,59.42 44.02,60.13 v2(44.04,60.15) 44.08,60.19 JEDP1.15
N21092755: length 13.1
  TOP w0.095: RE252.1 v2(19.78,5.2)
  TOP w0.254: UE3.K2 23.9,17.27 v8(23.56,17.61)
  GND1 w0.254: v3(20.02,10.45) 19.9,10.57 v1(19.9,10.81)
  GND3 w0.254: v3(20.02,10.45) 20.23,10.45 20.65,10.87 v6(20.65,10.95)
  IN4 w0.254: v6(20.65,10.95) 21.16,11.46 21.16,11.77 21.41,12.03 v5(21.87,12.03)
  BOTTOM w0.254: v5(21.87,12.03) 21.32,12.58 21.32,14.4 21.93,15.01 21.93,15.82 22.54,16.44 23.8,16.44 24.3,16.94 CE43.1 23.85,17.32 v8(23.56,17.61)
  vias: v7(19.84,8.81) v7(20.15,8.82)
N21131251: length 4.2
  BOTTOM w0.095: RR18.2 45.4,58.57 45.4,58.79 45.18,59.02 v2(45.18,59.57) 44.99,59.75 44.99,60.82 45.08,60.91 JEDP1.13
N21131254: length 3.5
  BOTTOM w0.095: JEDP1.12 45.58,60.6 45.51,60.52 45.51,59 45.88,58.63 RR19.2
N21271671: length 3.2
  TOP w0.095: RA66.1 274.87,14.06 274.2,13.39 273.89,13.39 273.54,13.04 U6.4
N21352667: length 20.4
  IN1 w0.076: v7(19.1,15.62) 19.1,15.03 19.31,14.82 20.73,14.82 21.15,14.4 22.39,14.4 22.77,14.01 22.77,13.89 22.95,13.71 23.56,13.71 23.92,14.07 24.51,14.07 24.7,13.88 26.2,13.88 28.06,12.02 28.06,11.72 28.53,11.25 29.93,11.25 30.59,10.59 30.63,10.59 31.12,10.09 31.77,10.09 31.88,10.19 34.12,10.19 34.26,10.05 v7(36.25,10.05)
N21352765: length 10.7
  IN1 w0.076: v7(16.7,15.62) 15.95,15.62 14.02,13.69 6.92,13.69 v7(6.85,13.76)
N22221959: length 3
  TOP w0.095: v2(33.06,63.28) RR23.1 RR21.2 RR22.2
N22930798: length 7.9
  TOP w0.095: v1(27.59,24.05) 27.76,24.21 28.35,24.21 28.7,23.86 28.7,23.26 28.97,22.99 29.93,22.99 v2(30.48,22.45) 30.92,22.01 30.92,21.91 31.21,21.62 PR122.1
  GND1 w0.095: v3(27.21,24.04) 27.21,24.05 v1(27.59,24.05)
  GND3 w0.095: v4(27.21,24.6) v3(27.21,24.04)
  BOTTOM w0.095: PQ199.1 27,24.81 v4(27.21,24.6)
N22930931: length 4.3
  BOTTOM w0.095: PQ199.3 24.1,25.33 PR110.1 23.17,26.07 PR108.2 23.18,26.3 22.71,26.77 22.71,27.4 v2(23.36,28.05)
N22932645: length 3.1
  BOTTOM w0.095: PQ200.3 31.22,32.38 31.22,32.03 PR117.2 31.4,30.82 PR119.1
N22934326: length 2
  BOTTOM w0.254: PQ201.3 214.71,13.46 PR126.2 215.77,13.63 215.99,13.84 PR140.1
N23434155: length 7
  BOTTOM w0.095: PU301.1 65.86,4.38 PD306.1 PD305.1 61.34,3.74 PR335.1 61.71,2.75 PR336.2
N23434758: length 1.1
  BOTTOM w0.095: PU301.4 67.56,2.08 PR345.1
N23434902: length 1.9
  BOTTOM w0.254: PD305.2 59.44,3.6 58.66,2.82 58.66,2.67 58.37,2.38 PR321.2
N23434905: length 2.5
  BOTTOM w0.095: PR343.2 58.22,5.4 58.59,5.77 v2(58.59,6.14)
  BOTTOM w0.254: PD305.3 58.24,5.03 PR343.2
N23434908: length 4.6
  BOTTOM w0.095: PR344.2 68.12,5.37 66.63,5.37 66.26,5.74 65.1,5.74 64.83,5.48 PD306.2
N23437101: length 2.8
  BOTTOM w0.095: PU301.2 66.72,3.47 67.11,3.08 67.63,3.08 PR346.2
N23538625: length 2.3
  TOP w0.095: UZ1.3 51.72,62.09 R5823.2 v2(52.92,61.94)
N23545560: length 2.3
  BOTTOM w0.095: v2(282.79,36.19) 282.35,36.19 R5825.1 281.75,36.79 U31.7
N23545577: length 2.4
  BOTTOM w0.095: U31.1 278.23,36.29 278.04,36.1 v2(278.04,35.35) 278.04,34.69 277.95,34.6 C1121.1
N23849155: length 17.1
  TOP w0.095: v2(11.91,8) 12.44,8.52 v7(12.44,8.99)
  IN1 w0.076: v9(10.86,11.78) 11.91,10.73 11.91,9.51 v7(12.44,8.99)
  GND1 w0.095: v3(10.86,12.11) v9(10.86,11.78) ; v1(19.9,17.22) v3(19.9,17.6)
  IN2 w0.064: v3(19.9,17.6) 19.79,17.6 19.42,17.23 16.12,17.23 15.17,16.28 15.17,15.7 13.61,14.14 12.7,14.14 10.86,12.31 v3(10.86,12.11)
N23886095: length 20.1
  IN4 w0.076: v5(149.86,51.18) 149.86,52.91 147.22,55.55 147.22,56.71 146.33,57.6 146.33,57.86 145.05,59.14 143.49,59.14 142.43,60.19 142.35,60.19 141.71,60.82 141,60.82 140.25,60.08 138.91,60.08 137.61,61.38 v5(137.56,61.38)
  BOTTOM w0.095: v5(149.86,51.18) v2(149.86,50.1)
N24109146:
  vias: v2(261.79,4.73)
N24110025:
  vias: v2(209.02,1.39)
N24419592: length 9.1
  IN4 w0.076: v5(271.01,6.46) 271.13,6.33 271.78,6.33 272.73,7.28 274.47,7.28 274.73,7.03 v5(276.58,7.03)
  BOTTOM w0.095: v2(272.02,9.01) 272.02,8.92 271.11,8.01 RE273.2 270.99,7.93 270.99,6.47 v5(271.01,6.46)
N24419725: length 24.6
  IN1 w0.076: v7(290.9,70.69) 294.18,70.69 295.06,69.81 295.06,66.78 295.61,66.24 295.61,62.46 295.05,61.9 293.93,61.9 291.64,59.61 291.64,59.05 288.83,56.24 288.38,56.24 v8(287.63,55.49)
  BOTTOM w0.095: v2(287.63,54.95) v8(287.63,55.49) 287.95,55.81 RE275.2
N25181277: length 3.1
  TOP w0.095: v2(34.13,20) 34.13,19.86 v1(33.77,19.5) 33.53,19.5 PR106.2
  GND1 w0.095: v3(33.15,19.5) v1(33.77,19.5)
  GND3 w0.095: v3(33.15,19.5) 33.15,19.55 33.18,19.58 v4(33.18,19.85)
  BOTTOM w0.095: PQ106.1 33.43,19.64 33.21,19.85 v4(33.18,19.85)
N25182593: length 1.7
  BOTTOM w0.095: PQ108.1 34.14,9.29 34.24,9.19 PR109.2
N25183368: length 7.6
  TOP w0.254: PR133.2 45.16,16.79 46.64,16.79 v2(46.67,16.82) 46.68,16.83 v1(47.61,16.83)
  GND1 w0.254: v1(47.61,16.83) 48.21,16.83 v3(48.34,16.69)
  GND3 w0.254: v3(48.34,16.69) v4(48.77,16.69)
  BOTTOM w0.254: v4(48.77,16.69) 49.93,16.69 50.21,16.41 50.21,15.71 50.59,15.34 PQ118.1
N25184290: length 6.5
  TOP w0.254: PR134.2 45.62,5.52 45.47,5.67 45.12,5.67 v2(44.83,5.96) 44.83,6.09 43.6,7.32 42.13,7.32 41.39,8.06 v1(41.39,8.22)
  GND1 w0.254: v3(41.77,8.24) 41.41,8.24 v1(41.39,8.22)
  GND3 w0.254: v3(41.77,8.24) 42.08,8.24 v4(42.2,8.11)
N25185028: length 2
  BOTTOM w0.305: PR260.2 192.29,4.46 PQ156.1
N25186288: length 2.7
  BOTTOM w0.095: PR111.1 23.6,24.16 PQ199.2 24.23,23.67 v2(23.53,22.97)
N25186457: length 3.1
  BOTTOM w0.095: PQ200.2 32.7,31.77 33.06,31.41 PR120.1 v2(33.06,29.64)
N25186576: length 3.3
  BOTTOM w0.095: v2(212.13,15.91) PR137.1
  BOTTOM w0.254: PR137.1 213.11,15.34 213.62,14.82 PQ201.2
N25190486: length 0.6
  BOTTOM w0.095: PT104.1 59.88,2.45 PR336.1
N25234876: length 151
  TOP w0.095: v1(143.88,8.09) 143.76,7.98 143.76,4.52 145.56,2.72 151.09,2.72 152.02,3.65 152.02,8 153.8,9.78 v2(153.8,13.71) v1(153.8,14.79)
  GND1 w0.095: v3(143.73,7.6) 143.88,7.74 v1(143.88,8.09) ; v3(153.31,15.09) 153.31,15.05 153.57,14.79 v1(153.8,14.79)
  IN3 w0.064: v3(143.73,7.6) 143.73,8.46 143.14,9.06 137.01,9.06 136.77,8.82 136.08,8.82 135.96,8.95 113.89,8.95 109.83,4.89 79.9,4.89 77.68,2.68 58.37,2.68 58.11,2.94 36.47,2.94 34.89,4.52 30.98,4.52 v8(30.22,5.28)
  GND3 w0.095: v3(153.31,15.09) 153.23,15.17 v6(153.23,15.49)
  IN4 w0.076: v5(153.86,19.45) 153.86,16.33 153.23,15.69 v6(153.23,15.49)
  BOTTOM w0.095: JNGFF1.8 v5(153.86,19.45) ; R5827.1 30.39,5.46 v8(30.22,5.28)
N25447747: length 5.5
  BOTTOM w0.095: RE27.2 165.18,15.59 RE29.1 165.6,14.41 167.71,14.41 v2(168.06,14.05) 168.48,13.64 U7.4
N25689392: length 7.7
  TOP w0.095: QE23.3 267.45,57.59 267.72,57.32 268.37,57.32 D75.2 269.05,55.85 269.37,55.53 v2(269.37,54.36) 269.37,53.56 RE290.1
N28314143: length 3.2
  TOP w0.095: T4.1 109.63,45.87 109.26,46.23 109.26,47.27 v8(108.84,47.69)
  BOTTOM w0.095: v8(108.84,47.69) 108.71,47.69 UCPU1.AT52
N28323796: length 1.2
  TOP w0.127: T6.1 112.64,48.28 v8(112.5,48.28)
  BOTTOM w0.112: v8(112.5,48.28) 112.88,48.66 UCPU1.AP43
N28323807: length 1.2
  TOP w0.127: T5.1 112.82,49.24 v8(112.5,48.92)
  BOTTOM w0.112: v8(112.5,48.92) 112.89,49.31 UCPU1.AN43
N28344853: length 2.5
  TOP w0.095: v8(129.83,47.04) 129.46,46.66 129.46,46.12 129.85,45.73 T7.1
  BOTTOM w0.112: v8(129.83,47.04) 129.88,47.04 130.2,47.36 UCPU1.AT13
N28375965: length 1.3
  TOP w0.095: T1.1 110.53,62.49 v8(110.7,62.49)
  BOTTOM w0.112: v8(110.7,62.49) 110.72,62.51 110.91,62.51 111.13,62.29 UCPU1.G46
N28375966: length 1.5
  TOP w0.095: v8(110.69,63.13) 110.86,63.3 T2.1
  BOTTOM w0.112: UCPU1.F46 110.87,63.11 110.71,63.11 v8(110.69,63.13)
N28424999: length 6.8
  BOTTOM w0.089: UCPU1.AW71 96.72,45.36 95.96,44.6 95.96,41.78 94.6,40.42
  BOTTOM w0.095: T27.1 94.15,39.96 94.6,40.42
N28425002: length 8.6
  BOTTOM w0.112: T28.1 93.92,39.35 96.15,41.59 96.15,44.52 96.19,44.55 96.69,45.06 97.38,45.06 UCPU1.AW70
N28842863: length 3.2
  TOP w0.095: v8(137.73,49.95) 137.73,50.37 v2(138.17,50.81)
  TOP w0.381: v8(137.73,49.95) 137.71,49.93 137.71,49.26 137.24,48.78 CC65.1
  BOTTOM w0.112: UCPU1.AL1 137.62,50.11 137.73,50 v8(137.73,49.95)
N28843886: length 3.5
  TOP w0.381: v8(132.86,43.13) 132.86,44.14 CC76.1
  BOTTOM w0.254: UCPU1.BB10 132,43.71 132.53,43.18 132.8,43.18 v8(132.86,43.13)
N28856399: length 5.2
  BOTTOM w0.089: UCPU1.BA70 97.72,44.07 97.72,43.25
  BOTTOM w0.127: T23.1 95.54,40.6 96.94,42 96.94,42.48 97.72,43.25
N28856402: length 7.2
  BOTTOM w0.076: UCPU1.BA68 98.36,44.07 98.36,42.8 97.41,41.84 97.41,40.04 97.33,39.96 96.69,39.96 95.87,39.15
  BOTTOM w0.095: 95.87,39.15 95.57,38.84 T25.1
N28857231: length 5.5
  BOTTOM w0.076: T16.1 97.65,39.14 97.65,41.79 98.7,42.84 UCPU1.BB68
N28857234: length 3.7
  BOTTOM w0.112: T17.1 97.15,40.55 97.15,42.11 98.05,43.01 UCPU1.BB69
N28857237: length 1.5
  TOP w0.095: T18.1 130.32,50.29 v8(130.19,50.42)
  BOTTOM w0.127: UCPU1.AK13 130.19,50.81 v8(130.19,50.42)
N28857240: length 1.2
  TOP w0.095: v8(130.6,51.38) 130.49,51.28 T19.1
  BOTTOM w0.076: v8(130.6,51.38) 130.93,51.05 UCPU1.AK12
N28861827: length 6.7
  BOTTOM w0.076: UCPU1.C64 101.26,65.54 101.18,65.62 101.18,67.14 99.83,68.49 98.63,68.49 98.2,68.92 RC126.1
N28938912: length 2.2
  BOTTOM w0.095: v2(167.44,39.81) 168.06,39.19 CC5.2 RC28.1
N29708559: length 7.6
  BOTTOM w0.095: UCPU1.AY4 135.62,44.86 135.98,44.51 135.98,44.01 136.12,43.88 136.12,43.37 136.48,43.01 141.05,43.01 T24.1
N29708561: length 4.6
  BOTTOM w0.095: T26.1 139.5,43.24 136.93,43.24 136.58,43.59 UCPU1.BB3
N29708599: length 5.1
  BOTTOM w0.095: T20.1 139.24,46.97 138.85,46.97 138.75,46.87 137.99,46.87 137.76,47.1 135.48,47.1 135.1,46.71 UCPU1.AU5
N29708601: length 5.5
  BOTTOM w0.076: T21.1 139.23,47.68 137.54,47.68 137.35,47.74 137.3,47.77 137.29,47.76 135.36,47.76 134.96,47.36 UCPU1.AT5
N29708639: length 6.2
  BOTTOM w0.095: UCPU1.BB5 135.03,43.55 135.52,43.06 135.81,43.06 136.37,42.5 139.27,42.5 140.1,41.68 T22.1
N30340494: length 1
  GND1 w0.508: v1(102.42,62.95) v3(102.42,62.54)
  GND3 w0.508: v4(102.9,62.2) 102.77,62.2 v3(102.42,62.54)
N31739843: length 7.2
  BOTTOM w0.076: T9.1 137.5,40.91 137.24,40.91 135.62,42.54 135.02,42.54 134.26,43.29 133.75,43.29 133.58,43.45 133.58,44.67 133.23,45.02 UCPU1.AY8
N34458680: length 3.4
  TOP w0.203: RA7.1 273.6,60.71 273.6,60.48 v1(273.34,60.23)
  GND1 w0.203: v3(273.24,59.9) 273.24,60.13 v1(273.34,60.23)
  GND3 w0.203: v4(272.89,59.9) v3(273.24,59.9)
  BOTTOM w0.095: v2(272.53,59.25) 272.53,59.54 v4(272.89,59.9)
  BOTTOM w0.203: U5.2 273.06,60.08 v4(272.89,59.9)
N34458868: length 3.2
  BOTTOM w0.095: CA19.1 v2(280.04,67.58)
  BOTTOM w0.203: 279.15,65.57 278.86,65.27 U5.24
  BOTTOM w0.254: 279.15,65.57 279.99,66.4 CA19.1
N34458871: length 1.6
  BOTTOM w0.203: U5.23 278.46,65.64 278.64,65.82
  BOTTOM w0.254: 278.64,65.82 CA19.2
N34458958: length 3.1
  BOTTOM w0.203: CA23.1 281.83,60.05 280.61,61.28 U5.32
N34459429:
  vias: v2(278.68,57.58)
N34459663: length 5.2
  BOTTOM w0.203: 278.64,58.18 278.46,58.36 U5.38
  BOTTOM w0.254: CA24.1 282.42,56.62 281,58.05 280.1,58.05 280.02,57.97 278.85,57.97 278.64,58.18
N34459862: length 3.5
  BOTTOM w0.203: U5.25 280,64.08 280.25,64.33
  BOTTOM w0.254: CA30.1 281.85,66.39 280.25,64.79 280.25,64.33
N34711424: length 3.9
  TOP w0.095: RA3.1 v2(279.49,63.56)
  TOP w0.203: RA3.1 280.27,61.78 v1(280.42,61.78)
  GND1 w0.203: v3(280.4,61.31) 280.42,61.34 v1(280.42,61.78)
  GND3 w0.203: v4(280.41,60.87) 280.41,61.31 v3(280.4,61.31)
  BOTTOM w0.203: U5.33 280.39,60.88 v4(280.41,60.87)
N34711571: length 5.5
  TOP w0.095: RA2.2 276.85,62.54 R17.1 CA18.1 ; RA4.2 CA18.1 ; CA18.1 278.45,61.02 CA16.1 279.58,60.19 v2(279.58,60.17)
N34711769: length 2.4
  TOP w0.095: CA25.2 v1(278.46,65.39) 278.46,64.46 v2(278.39,64.38)
  GND3 w0.305: v4(277.66,65.59) 277.7,65.63 v3(278.1,65.63)
  BOTTOM w0.203: U5.21 v4(277.66,65.59)
  vias: v1(278.46,65.7)
N34741776:
  vias: v2(276.6,13.42)
N34741906: length 6.6
  TOP w0.095: RA24.2 273.97,16.69 v2(275.02,16.69) 275.74,15.98 RA23.1 275.78,15.61 CA57.1 275.74,14.61 274.29,13.17 274.07,13.17 273.94,13.04 U6.3
N34741924: length 1.5
  TOP w0.203: U6.40 273.94,3.95 CA54.1
N34768323:
  vias: v2(277.18,9.38)
N34768417:
  vias: v2(276.46,4.06)
N34769506: length 2.6
  TOP w0.095: RA46.1 279.33,13.67 278.55,14.45 v2(278.23,14.45)
  TOP w0.254: RA46.1 279.3,13.44 279.04,13.18 CA68.2
N34769927: length 0.8
  TOP w0.254: CA69.2 279.73,8.97 RA47.1
N34769983: length 1.7
  TOP w0.095: CA70.2 v2(279.97,6.25)
  TOP w0.203: CA70.2 278.85,6.25 278.45,6.65 RA48.1
N34770039: length 0.8
  TOP w0.254: CA71.2 278.95,4.45 RA49.1
N34828335: length 3.9
  TOP w0.119: RA24.1 273.3,15.11 273.3,13.58 272.74,13.02 U6.6
N34828474: length 7.4
  TOP w0.095: U6.22 267.5,8.65 266.99,8.13 v2(266.99,4.32) 266.99,2.72 CA66.2
N34828656: length 1.9
  TOP w0.095: U6.5 273.14,13.06 273.97,13.9 RA40.2
N34866610: length 7.2
  TOP w0.095: CA67.1 267.32,3.28 v2(267.32,5.61) 267.32,7.98 267.73,8.39 268.04,8.39 268.18,8.25 U6.23
N34949443: length 1.6
  TOP w0.095: v8(267.65,9.46) v2(267.11,9.46)
  TOP w0.203: v8(267.65,9.46) 268.06,9.05 U6.21
N36038235: length 5.1
  BOTTOM w0.095: U5.48 274.46,57.28 CA20.2 RA11.2 274.39,56.24 RA13.2 272.96,54.82 v2(272.51,54.82)
N39070459: length 8.9
  TOP w0.095: RE219.1 RE222.2 5.71,28.87 v8(5.09,29.49)
  BOTTOM w0.095: v8(5.09,29.49) 5.09,29.05 5.65,28.5 9.01,28.5 v2(9.51,28) 10.11,27.4 QE13.3
N39070470: length 8.8
  TOP w0.095: v8(7.33,27.95) 7.32,27.96 RE219.2
  BOTTOM w0.095: v8(7.33,27.95) 7.56,28.17 v2(7.96,28.17) 8.88,28.17 10.31,26.74 11.56,26.74 12.42,25.88 13.92,25.88 QE16.2
N39388747: length 3
  TOP w0.095: v2(277.09,64.65) 276.76,64.98 CA27.2
  GND3 w0.305: v3(276.26,65.13) 276.39,65.13 v4(276.87,65.61)
  BOTTOM w0.203: U5.19 276.86,65.6 v4(276.87,65.61)
  vias: v1(275.76,65.11) v1(275.76,64.85)
N40373163: length 3.1
  TOP w0.102: RD19.1 87.1,33.51 v2(87.1,31.96)
  TOP w0.508: RD19.1 CD80.2
N40373501: length 0.9
  TOP w0.508: CD81.2 91.15,33.96 RD20.1
N40376778: length 2.3
  TOP w0.102: v2(97.07,36.34) 98.01,37.28 RD12.1
  TOP w0.508: CD79.2 98.13,37.26 RD12.1
N44109348: length 3.1
  TOP w0.095: QE10.1 8.93,9 v2(9.27,8.66) 9.44,8.49 9.44,7.68 9.08,7.32 RE171.1
N44325406: length 3.4
  TOP w0.095: UE3.B1 25.17,10.81 25.43,10.55 26.66,10.55 RE154.1 RE152.1
N44325565: length 6.6
  TOP w0.095: UE3.N4 22.86,20.17 23.53,20.17 25.48,22.13 25.84,22.13 RE115.2 27.18,23.46 v2(27.18,23.64)
N44325691: length 0.9
  TOP w0.095: RE172.2 31.04,12.31 CE65.1
N44759345: length 5.1
  TOP w0.095: RE193.1 7.63,7.61 v2(7.63,8.21) 7.89,8.47 v8(8.6,8.47)
  BOTTOM w0.095: JESPI1.8 8.79,9.12 8.6,8.92 v8(8.6,8.47)
N50638473: length 19.9
  TOP w0.095: R67.1 5.63,13.48 v2(4.84,14.27) 3.58,14.27 v7(3.41,14.09)
  IN1 w0.076: v7(3.41,14.09) 3.41,17.85 2.94,18.32 2.94,20.17 6,23.23 6,24.24 8.27,26.51 v8(8.27,26.57)
  BOTTOM w0.095: v8(8.27,26.57) 8.02,26.32 8.02,24.95 8.11,24.86 QH1.3
N52708219: length 13.4
  BOTTOM w0.095: D11.1 254.22,9.49 255.3,10.57 256.76,10.57 258.15,9.18 JFAN1.2 258.15,4.55 257.9,4.3 v2(256.14,4.3) 255.07,4.3 R38.1
N52922958:
  vias: v2(148.43,31.91)
N52922960: length 4.4
  TOP w0.203: C87.1 146.04,33.41 v2(147.33,33.41) 148.32,33.41 149.05,34.13 U11.10
N52923110: length 4.3
  TOP w0.203: C83.1 146.13,33.01 148.49,33.01 v2(148.76,33.28) 148.81,33.33 U11.12
N52925836: length 0.9
  TOP w0.095: v2(223.67,7.31) 223.86,7.5 224.51,7.5
N52925896: length 0.9
  TOP w0.095: v2(223.51,11.94) 223.88,11.58 223.88,11.18
N52925901: length 1.6
  TOP w0.203: U12.10 224.93,9.12 C86.1
N52926051: length 4
  TOP w0.095: v2(227.12,9.76) 226.58,10.29 225.68,10.29 225.17,9.79 C84.1
  TOP w0.203: C84.1 225.01,9.91 U12.12
N52930519:
  vias: v2(265.97,45.98)
N52930580: length 1.7
  TOP w0.119: U13.10 267.77,45.37 267.54,45.14 C98.1
N52930730: length 1.7
  TOP w0.119: U13.12 268.57,45.58 268.62,45.53 268.62,44.71 C94.1
N52934489: length 0.8
  TOP w0.095: 255.26,5.85 255.01,5.6 v2(255.01,5.19)
N52934545: length 1.2
  TOP w0.095: 255.51,9.1 v2(255.51,10.32)
N52934547: length 1.6
  TOP w0.203: C99.1 254.44,7.07 U14.10
N52934693: length 1.6
  TOP w0.203: U14.12 255.42,7.86 255.52,7.96 C97.1
N56242723: length 4.5
  BOTTOM w0.112: T3.1 109.7,41.7 109.7,44.31 109.58,44.43 109.58,44.72 109.62,44.76 109.62,45.06 109.26,45.42 UCPU1.AW50
N56822254: length 6.1
  TOP w0.076: v2(14.4,29.09) v7(13.99,28.69)
  TOP w0.095: C151.1 13.84,28.53 v7(13.99,28.69)
  IN1 w0.076: v7(13.99,28.69) 13.99,29.07 14.37,29.45 16.39,29.45 17.36,30.42 17.87,30.42 v7(17.98,30.31)
N56822270: length 6.1
  TOP w0.095: v7(21.97,36.44) 21.97,36.57 21.76,36.79 R184.1
  IN1 w0.076: v7(18.48,32.81) 19.09,33.42 19.09,33.56 20.03,34.5 20.44,34.5 21.97,36.03 v7(21.97,36.44)
N56822627: length 5.3
  TOP w0.076: U19.G4 18.42,31.86 18.42,32.48 18.23,32.67 18.23,33.49 17.96,33.75 17.96,34.21 18.18,34.42 18.18,36.14 18.12,36.2
  TOP w0.095: 18.12,36.2 18.07,36.25 TC1.1
N56822629: length 6.4
  TOP w0.076: U19.F4 18.84,31.81 18.61,32.04 18.61,32.58 18.73,32.7 18.73,33.41 18.73,33.42 18.91,33.6 18.91,34.09 19.1,34.28 19.1,34.46
  TOP w0.095: TC2.1 19.09,37.65 19.09,36.16 19.1,36.15 19.1,34.46
N56856077: length 1.8
  TOP w0.076: U19.F1 19.07,33.4 19.07,33.99 19.55,34.46 RT55.1
N56977728: length 4.5
  BOTTOM w0.095: v2(175.44,10.97) 175.17,10.97 174.23,10.03 174.23,9.85 R22.1 173.26,10.59 172.68,10.59 172.55,10.73 U7.27
N57177583: length 1.6
  TOP w0.095: R101.1 136.33,70 v2(135.89,70.44)
N57177874: length 3
  TOP w0.095: UZ5.4 124.01,36.84 v2(124.93,35.92)
  TOP w0.254: UZ5.4 124.35,37.12 125.01,37.78 RZ2.2
N57177931: length 2.7
  TOP w0.095: v2(121.51,41.13) R103.1
  TOP w0.508: R103.1 122.85,39.95 UZ5.6
N57178338: length 1.5
  BOTTOM w0.095: R102.1 151.04,13.5 151.41,13.88 v2(151.75,13.88)
N57313034: length 11.6
  TOP w0.095: v8(132.65,47.02) 132.27,46.64 132.27,45.78 136.72,41.33 v2(136.87,41.33) 137.52,41.33 137.66,41.48 139.68,41.48 RC63.2
  BOTTOM w0.112: UCPU1.AT8 132.99,47.36 v8(132.65,47.02)
N57317696: length 3.3
  TOP w0.095: RC110.2 v2(154.79,40.51) SW1.1
N57319429: length 1.2
  GND1 w0.095: v1(102.34,50.89) 102.37,50.86 103.07,50.86 v3(103.12,50.91)
  GND3 w0.095: v4(102.79,50.76) 102.98,50.76 v3(103.12,50.91)
N57319432: length 1
  GND1 w0.095: v3(103.69,50.89) 103.69,50.6 103.59,50.5 v1(103.57,50.5)
  GND3 w0.095: v4(103.36,50.43) 103.36,50.56 v3(103.69,50.89)
N57670088: length 2.7
  TOP w0.095: T11.1 128.47,47.5 v8(128.97,47.01)
  BOTTOM w0.112: UCPU1.AW15 128.86,45.66 128.86,46.62 128.97,46.73 v8(128.97,47.01)
N58842401: length 1.7
  TOP w0.095: v8(135.15,52.46) 135.52,52.08 T8.1
  BOTTOM w0.112: UCPU1.AD4 135.61,53.36 135.17,52.92 135.17,52.49 v8(135.15,52.46)
N58864976: length 13.9
  TOP w0.095: v7(153.07,24.84) 152.58,24.84 R81.2 151.38,23.63 R82.2 151.17,23.63 150.23,22.69 v2(150.23,22.65) ; U11.5 v7(152.58,34.13)
  IN1 w0.076: v7(152.58,34.13) 152.96,33.75 152.96,24.94 v7(153.07,24.84)
N59153523: length 2.5
  BOTTOM w0.095: U7.3 167.86,13.14 RE104.2
N59894012: length 4.3
  BOTTOM w0.095: U7.29 171.55,10.75 172.06,10.24 173.01,10.24 173.09,10.16 RE2.2 173.09,8.38 v2(173,8.29)
N61547946: length 2.2
  BOTTOM w0.095: QZ1.1 285.98,26.53 v2(285.15,25.71)
N61553916: length 3.5
  TOP w0.095: v2(46.32,59.44) R73.1
  TOP w0.508: UZ1.6 47.95,60.65 47.77,60.46 R73.1
N63216045: length 12
  IN1 w0.076: v7(5.83,15.25) 6.34,15.25 7.88,16.78 9.59,16.78 10.06,17.25 10.06,17.84 11.01,18.79 11.01,20.99 10.79,21.21 v9(10.79,22.94)
  GND1 w0.095: v9(10.79,22.94) 10.79,23.04 v3(10.62,23.22)
  GND3 w0.095: v3(10.62,23.22) 10.39,23.45 v4(10.39,23.56)
N63216077: length 9.9
  TOP w0.095: R69.1 v2(5.84,19.02) 5.84,19.55 v8(6.81,20.52)
  BOTTOM w0.095: v8(6.81,20.52) 7.01,20.72 8.83,20.72 9.08,20.97 9.08,21.52 9.46,21.9 11.26,21.9 11.58,21.58 QH2.3
N63216109: length 9.2
  TOP w0.095: R70.1 v1(7.23,24.07)
  IN1 w0.076: v9(12.79,23.16) 12.38,23.16 12,23.55 12,24.3 11.8,24.49 11.38,24.49 11.15,24.26 10.8,24.26 v7(10.68,24.38) 10.68,24.98 10.48,25.18 8.24,25.18 7.23,24.17 v1(7.23,24.07)
  GND1 w0.095: v3(13.25,23.26) 12.89,23.26 v9(12.79,23.16)
  GND3 w0.095: v4(12.88,23.26) v3(13.25,23.26)
N63239426: length 16.5
  TOP w0.095: v7(2.69,17.64) 3.47,17.64 v2(3.86,17.24) 5.38,15.72 6.23,15.72 6.4,15.55 Q4.1 ; R71.1 v7(6.75,26.78)
  IN1 w0.076: v7(6.75,26.78) 6.75,26.73 5.34,25.32 5.34,23.5 2.28,20.45 2.28,18.05 v7(2.69,17.64)
N64008885: length 3.2
  TOP w0.095: R115.2 32.94,25.06 v2(32.94,25.48) 32.94,25.88 32.99,25.94 v1(32.99,25.98)
  GND1 w0.095: v1(32.99,25.98) 33.02,26.01 v3(33.02,26.37)
  GND3 w0.095: v3(33.02,26.37) 32.91,26.48 v4(32.7,26.48)
  BOTTOM w0.095: QE2.3 v4(32.7,26.48)
N64926554: length 2.6
  TOP w0.095: v2(143.43,53.61) 143.43,53.53 143.04,53.14 142.13,53.14 CE84.1
  TOP w0.254: CE84.1 R4.2
N65482285: length 0.6
  TOP w0.381: CC77.1 126.46,50.88 R3.2
N66491485: length 6.3
  BOTTOM w0.095: RC37.2 162.6,39.37 162.6,39.13 162.7,39.03 162.92,39.03 RC36.2 162.77,38.7 162.77,35.07 163.05,34.78 JSPI1.16
N67506216: length 4
  BOTTOM w0.095: R23.2 284.86,55.04 283.31,55.04 v2(283.04,54.76) 282.77,54.49 WL1.27
N67571980: length 4.8
  IN1 w0.076: v7(30.52,32.54) 30.17,32.54 29.87,32.24 29.87,31.97 28.39,30.49 26.82,30.49 v7(26.75,30.56)
N67571982: length 5.7
  TOP w0.095: v7(27.6,35.39) 27.22,35.77 R213.1 ; U20.G2 31.02,35.01 30.82,34.8 v7(30.82,34.76)
  IN1 w0.076: v7(30.82,34.76) 30.8,34.77 29.12,34.77 28.87,35.02 28.54,35.02 28.17,35.39 v7(27.6,35.39)
N67572033: length 6
  TOP w0.095: TC6.1 31.51,38.85 v7(31.51,38.85)
  IN1 w0.076: v7(31.51,38.85) 31.47,38.81 31.47,38.4 31.59,38.28 31.59,37.14 30.82,36.38 30.82,35.14 31.09,34.88 31.09,34.64 31.05,34.61 31.05,34.07 v7(31.02,34.04)
N67572034: length 6.1
  TOP w0.095: TC7.1 32.08,38.56 31.79,38.56 31.79,38.54 v7(31.78,38.54)
  IN1 w0.076: v7(31.78,38.54) 31.79,38.53 31.79,37.01 31.13,36.35 31.13,35.09 31.27,34.95 31.27,34.57 31.24,34.54 31.24,34.29 31.49,34.04 v7(31.52,34.04)
N67572050: length 1.8
  TOP w0.095: U20.F1 31.52,36.29 32.09,36.86 RT61.1
N67581669: length 5.2
  IN4 w0.076: v5(288.02,17.33) 287.84,17.51 287.84,18.93 287.65,19.12 287.56,19.12 287.45,19.22 287.45,19.57 287.16,19.86 287.16,20.3 287.42,20.55 287.42,20.98 287.03,21.36 286.55,21.36 v5(286.52,21.39)
N67581671: length 5.6
  IN4 w0.076: v5(281.42,17.12) 281.6,17.12 281.71,17.01 283.63,17.01 283.97,16.67 284.74,16.67 284.86,16.8 286.03,16.8 v5(286.12,16.89)
  BOTTOM w0.095: v5(286.12,16.89) 285.59,16.89 U21.G2
N67581722: length 7.7
  IN4 w0.076: v5(286.52,16.83) 286.29,16.59 284.94,16.59 284.6,16.25 282.13,16.25 281.56,16.81 281.32,16.81 280.01,18.12 v5(279.8,18.12)
N67581723: length 7.2
  IN4 w0.076: v5(279.82,16.83) 281.01,16.83 281.25,16.59 281.49,16.59 282.04,16.05 285.36,16.05 285.71,16.39 286.46,16.39 v5(286.52,16.33)
N67581739: length 2.1
  BOTTOM w0.119: U21.F1 283.8,16.33 283.3,15.82 RT67.1
N67581740: length 6.4
  IN4 w0.076: v5(280.44,16.12) 280.68,16.12 281.15,15.65 281.77,15.65 282.11,15.32 283.01,15.32 283.53,15.84 285.57,15.84 v5(285.83,16.1)
  BOTTOM w0.095: U21.F2 v5(285.83,16.1)
N67581787: length 17.6
  IN4 w0.305: v4(289.52,16.33) 289.44,16.33 289.13,16.64 289.13,18.05 289.23,18.16 289.23,19.49 289.82,20.07 289.82,20.71 289.14,21.38 287.5,21.38 286.68,22.21 v5(286.58,22.21) 286.32,22.21 285.91,21.8 281.99,21.8 281.47,21.28 v5(281.47,20.98) 281.47,18.7 v5(281.57,18.6)
  BOTTOM w0.254: RT63.1 281.6,18.57 v5(281.57,18.6)
N67727375: length 17.2
  IN4 w0.076: v5(205.83,4.55) 205.92,4.46 209.88,4.46 210.2,4.78 211.24,4.78 211.73,4.29 v5(212.47,4.29)
  BOTTOM w0.095: JFAN2.2 v5(205.83,4.55) 205.83,6.4 204.12,8.11 202.99,8.11 v2(202.57,7.7) 202.23,7.35 D12.1
N168123855: length 2
  TOP w0.095: R251.1 281.28,17.87 281.98,17.87 282.16,17.69 U22.8
N235456705: length 2.3
  BOTTOM w0.095: R5824.1 280.56,34.67 v2(280.56,35.27) 280.56,36.07 U31.8

## Copper pours and planes (outline as drawn)
5V_SN on TOP (solid shape): 39.58,32.14 39.58,29.37 39.43,29.22 38.45,29.22 38.43,29.24 38.43,30.19 38.52,30.28 38.52,32.17 38.56,32.21 39.51,32.21
+0.6VS on TOP (solid shape): 88.57,15.39 91.16,15.39 91.16,15.6 98.71,15.6 98.71,15.5 99.58,15.5 99.58,15.49 100.4,15.49 100.4,15.6 108.5,15.6 108.53,15.57 108.53,14.46 108.18,14.11 100.83,14.11 100.83,14.28 100.02,14.28 100.02,14.27 99.11,14.27 99.11,14.11 98.7,14.11 98.67,14.13 98.62,14.14 98.58,14.14 98.54,14.14 98.49,14.13 98.46,14.11 98.04,14.11 98.04,14.27 97.83,14.27 97.79,14.29 97.73,14.3 97.66,14.31 97.63,14.31 96.7,14.31 96.63,14.31 96.62,14.32 96.15,14.32 96.14,14.33 86.82,14.33 86.81,14.32 84.28,14.32 84.12,14.48 91.16,14.48 91.16,14.58 99.58,14.58 99.58,14.57 100.4,14.57 100.4,15.34 99.52,15.34 99.52,15.34 98.71,15.34 98.71,14.58 91.16,14.58 91.16,15.24 88.57,15.24 88.57,14.48 84.12,14.48 83.7,14.9 83.7,15.43 83.87,15.6 88.57,15.6
+0.6VS on TOP (solid shape): 117.63,18.04 117.63,16.3 118.06,15.86 122.03,15.86 122.04,15.86 122.16,15.84 122.28,15.86 122.28,15.86 123.15,15.86 123.23,15.86 123.31,15.86 131.59,15.86 131.81,15.64 131.82,15.62 131.84,15.52 131.88,15.44 131.89,15.42 131.89,15.34 131.98,15.34 132,15.33 132.08,15.29 132.18,15.27 132.2,15.27 132.21,15.26 133.67,15.26 133.67,15.22 134.43,15.22 134.43,15.26 134.58,15.26 134.58,15.22 135.35,15.22 135.35,15.25 135.43,15.34 135.43,15.5 135.49,15.56 136.55,15.56 136.55,15.54 137.37,15.54 137.37,15.91 145.2,15.91 145.22,15.93 145.28,15.95 145.34,15.98 145.43,15.98 145.43,16.02 146.11,16.02 146.19,15.93 146.19,15.43 138.63,15.43 138.45,15.24 138.4,15.24 137.76,14.6 130.73,14.6 130.33,15 122.46,15 121.22,13.76 120.43,13.76 120.23,13.96 120.23,14.46 120.08,14.61 116.08,14.61 115.71,14.99 115.71,17.51 115.72,17.51 115.72,18.04 115.79,18.1 117.57,18.1
+0.6VS on BOTTOM (solid shape): 120.18,13.49 120.18,12.83 120.07,12.72 118.7,12.72 118.62,12.8 118.62,13.44 118.75,13.56 120.11,13.56
+0.6VS on IN1 (solid shape): 101.12,16.03 101.12,15.49 100.68,15.04 100.22,15.04 100.16,14.99 100.11,15.06 100.08,15.09 100.05,15.12 100.01,15.14 99.97,15.16 99.92,15.16 99.88,15.16 99.83,15.16 99.79,15.14 99.75,15.12 99.72,15.09 99.69,15.06 99.67,15.02 99.65,14.98 99.65,14.93 99.65,14.89 99.65,14.84 99.67,14.8 99.69,14.76 99.72,14.73 99.76,14.68 99.77,14.66 99.77,14.63 99.76,14.6 99.74,14.57 99.55,14.38 98.12,14.38 97.92,14.58 97.92,14.96 98.86,14.96 98.87,14.92 98.88,14.87 98.9,14.83 98.93,14.79 98.96,14.76 99,14.74 99.04,14.72 99.08,14.71 99.13,14.71 99.17,14.71 99.22,14.73 99.26,14.75 99.29,14.78 99.32,14.81 99.35,14.85 99.36,14.89 99.37,14.94 99.37,14.99 99.36,15.03 99.35,15.07 99.32,15.11 99.29,15.15 99.26,15.18 99.22,15.2 99.17,15.21 99.13,15.22 99.08,15.22 99.04,15.2 99,15.19 98.96,15.16 98.93,15.13 98.9,15.09 98.88,15.05 98.87,15.01 98.86,14.96 97.92,14.96 97.92,15.6 97.93,15.61 98.95,15.61 99.49,16.15 101,16.15
+0.6VS on IN1 (solid shape): 88.64,14.93 88.71,14.9 88.74,14.82 88.99,14.54 89.24,14.82 89.27,14.9 89.34,14.93 89.52,14.93 89.6,14.9 89.63,14.82 89.88,14.54 90.13,14.82 90.16,14.9 90.23,14.93 90.41,14.93 90.49,14.9 90.51,14.82 90.77,14.54 91.02,14.82 91.05,14.9 91.12,14.93 91.56,14.93 91.71,14.78 91.71,13.83 91.53,13.65 89.31,13.65 89.24,13.68 89.21,13.76 89.03,14.12 88.63,14.08 88.57,14.06 88.5,14.08 88.26,14.16 88.03,14.07 87.91,14.19 87.91,14.8 88.04,14.93
+0.6VS on IN1 (solid shape): outline of 219 points within 106.99,14.85 116.53,17.2
+0.6VS on GND1 (solid shape): 121.21,14.05 121.21,12.81 121.13,12.74 120.08,12.74 119.99,12.83 119.99,13.81 120.05,13.91 120.05,14.03 120.04,14.06 120.1,14.11 121.14,14.11
+0.6VS on GND3 (solid shape): 121.1,13.44 121.1,12.82 120.99,12.71 119.35,12.71 119.34,12.72 118.96,12.72 118.82,12.86 118.82,13.35 118.99,13.52 121.02,13.52
+0.6VSP on BOTTOM (solid shape): 120.19,11.8 120.19,9.8 118.94,8.54 118.94,7.35 118.86,7.27 118.38,7.27 118.25,7.4 118.25,8.62 118.25,8.62 118.25,10.95 118.42,11.11 118.42,11.94 120.05,11.94
+1.0V_APLLEBB on IN1 (solid shape): 133.83,68.93 133.83,67.94 133.68,67.79 133.19,67.79 133,67.98 133,68.88 133.18,69.07 133.7,69.07
+1.0V_APLLEBB on IN1 (solid shape): 127.74,59.1 127.74,58.29 127.54,58.09 127.47,58.06 127.4,58.08 127,58.14 126.8,57.79 126.77,57.71 126.7,57.68 126.33,57.68 126.21,57.8 126.21,58.24 126.25,58.32 126.35,58.33 126.76,58.43 126.79,58.85 127.12,59.19 127.26,59.21 127.38,59.28 127.56,59.28
+1.0V_APLLEBB on IN1 (solid shape): outline of 176 points within 128.17,60.94 131.11,64.08
+1.0V_CLK on TOP (solid shape): outline of 211 points within 126.32,59.35 130.69,67.3
+1.0V_CLK on IN2 (solid shape): 126.67,61.05 127.17,61.05 127.42,60.81 127.42,60.25 127.25,60.08 126.87,60.08 126.76,59.97 126.76,59.41 126.64,59.3 125.86,59.3 125.63,59.53 125.63,60.47 125.87,60.71 126.31,60.71 126.65,61.05
+1.0V_MPHYAON on IN2 (solid shape): outline of 259 points within 127.54,59.81 137.99,61.56
+1.0V_MPHYGT on TOP (solid shape): 129.48,59.75 129.51,59.71 129.51,59.65 129.6,59.31 129.93,59.21 129.94,59.21 130.62,59.21 130.71,59.12 130.71,58.38 130.07,57.75 130.07,57.75 129.85,57.53 128.86,57.53 128.78,57.56 128.75,57.64 128.61,57.9 128.32,57.89 128.29,57.86 128.21,57.94 128.21,59.55 128.58,59.91 129.32,59.91
+1.0V_MPHYGT on TOP (solid shape): outline of 123 points within 126.84,69.35 134.27,72.82
+1.0V_MPHYGT on BOTTOM (solid shape): 132.32,72.98 132.32,71.45 132.06,71.19 130.04,71.19 129.55,71.68 129.55,73.05 129.76,73.27 132.03,73.27
+1.0V_MPHYGT on IN1 (solid shape): outline of 1216 points within 128.21,56.97 138.84,72.26
+1.0V_MPHYGT on VCC: 129.1,57.72 128.21,58.61 128.21,71.28 129.25,72.32 133.28,72.32 133.9,71.71 133.9,59.14 132.47,57.72
+1.0V_PRIM_CORE on BOTTOM (solid shape): 154.72,65.75 154.72,64.84 154.41,64.52 152.38,64.52 152.14,64.76 152.14,65.78 152.29,65.93 154.54,65.93
+1.0V_PRIM_CORE on BOTTOM (solid shape): 149.36,58.79 149.36,57.37 149.13,57.14 147.73,57.14 147.51,57.36 147.51,57.64 147.27,57.89 147.27,58.37 147.39,58.52 147.45,58.71 147.62,58.88 149.27,58.88
+1.0V_PRIM_CORE on IN1 (solid shape): outline of 203 points within 124.98,53.43 127.92,57.22
+1.0V_PRIM_CORE on VCC: 125.59,51.59 125.19,52 125.19,56.71 125.68,57.21 132.68,57.21 134.41,58.93 134.41,71.71 135.02,72.32 139.41,72.32 142,69.73 152.61,69.73 154.34,68 154.34,52.04 153.89,51.59
+1.0V_PRIM_COREP on BOTTOM (solid shape): 156.97,70.41 156.97,69.31 156.76,69.11 156.76,69.09 156.67,68.86 156.76,68.62 156.76,66.47 156.74,66.45 156.74,65.2 156.57,65.03 155.33,65.03 155.32,65.02 155.18,65.02 154.92,65.28 154.92,66.33 154.62,66.63 151.81,66.63 151.48,66.97 150.46,66.97 150.35,67.08 150.35,69.44 151.4,70.49 156.89,70.49
+1.0V_SRAM on BOTTOM (solid shape): 125.18,58.63 125.18,58.19 125.37,58 126.53,58 126.9,57.63 126.93,57.6 126.96,57.57 127.03,57.5 127.03,57.34 126.94,57.25 126.65,57.25 126.64,57.26 126.49,57.3 126.34,57.26 126.33,57.25 126.11,57.25 125.77,57.59 125.73,57.59 125.54,57.69 125.34,57.59 125.04,57.59 124.84,57.38 124.57,57.38 124.57,58.59 124.72,58.74 125.06,58.74
+1.0V_SRAM on IN1 (solid shape): 126,58.91 126,58.55 125.59,58.13 124.9,58.13 124.63,58.4 124.63,58.63 124.77,58.77 125.02,58.77 125.47,59.22 125.69,59.22
+1.0V_SRAM on IN1 (solid shape): outline of 189 points within 125.51,60.54 127.78,63.55
+1.0V_VCCST on TOP (solid shape): 34.04,57.94 34.04,57.03 33.68,56.67 33.15,56.67 33.01,56.81 33.01,58.12 33.04,58.15 33.84,58.15
+1.0V_VCCST on TOP (solid shape): 35.54,60.04 35.54,59.35 35.33,59.14 34.63,59.14 34.51,59.27 34.51,59.85 34.82,60.16 35.41,60.16
+1.0V_VCCST on TOP (solid shape): 99.77,72.42 100.33,72.42 100.33,72.41 100.48,72.41 100.61,72.28 100.61,70.94 100.4,70.73 99.11,70.73 99.06,70.77 99.06,71.32 99.25,71.5 99.25,72.25 99.44,72.44 99.74,72.44
+1.0V_VCCST on BOTTOM (solid shape): 38.98,32.32 38.98,31.94 38.62,31.59 36.98,31.59 36.74,31.83 36.74,32.09 37.18,32.53 38.76,32.53
+1.0V_VCCST on BOTTOM (solid shape): 101.55,72.97 103.44,72.97 104.14,72.28 104.14,70.57 103.96,70.38 103.72,70.38 103.49,70.62 102.97,70.62 102.76,70.75 102.54,70.62 101.59,70.62 101.41,70.8 101.41,71.33 101.21,71.53 101.21,72.27 101,72.47 100.29,72.47 100.09,72.27 100.09,71.58 99.99,71.48 99.51,71.48 99.38,71.36 99.38,70.73 99.3,70.65 97.97,70.65 97.93,70.69 97.93,71.18 98.03,71.28 98.52,71.28 98.77,71.53 98.77,71.58 99.73,72.55 99.73,73.36 99.86,73.49 101.03,73.49
+1.0V_VCCST on IN1 (solid shape): 35,59.65 35,58.33 33.9,57.23 33.05,57.23 32.9,57.37 32.9,58.94 33.92,59.96 34.7,59.96
+1.0V_VCCSTG on TOP (solid shape): 98.33,72.49 98.33,71.96 98.2,71.83 97.6,71.83 97.46,71.97 94.73,71.97 94.48,71.71 94.48,70.34 94.48,70.34 94.48,69.65 94.43,69.6 93.75,69.6 93.67,69.68 93.67,71.02 93.8,71.24 93.67,71.46 93.67,72.32 93.97,72.61 98.2,72.61
+1.0VA on TOP (solid shape): 143.47,55.98 143.47,55.12 143.2,54.84 143.2,54.11 142.99,53.91 142.34,53.91 142.23,54.02 142.23,55.76 142.5,56.02 143.43,56.02
+1.0VA on TOP (solid shape): 140.91,72.55 140.91,70.19 141.01,70.09 141.49,70.09 141.67,69.91 141.67,69.2 141.44,68.97 139.26,68.97 139.18,69.04 139.18,71.53 139.38,71.74 139.61,71.74 139.82,71.94 139.82,72.68 139.89,72.75 140.71,72.75
+1.0VA on TOP (solid shape): 126.37,71.95 126.37,71.84 126.36,71.74 126.37,71.65 126.13,71.41 126.13,70.36 126.03,70.26 126.03,69.31 126.19,69.15 127.88,69.15 128.91,68.12 128.91,66.45 128.88,66.43 128,66.43 127.99,66.44 127.99,67.31 127.92,67.38 127.92,67.65 127.36,68.21 125.39,68.21 124.99,68.61 124.99,70.08 125.06,70.29 124.99,70.5 124.99,71.99 125.1,72.1 126.22,72.1
+1.0VA on BOTTOM (solid shape): 126.28,73.1 126.28,71.63 126.09,71.44 125.15,71.44 124.94,71.65 124.94,73.21 125.06,73.34 126.04,73.34
+1.0VA on BOTTOM (solid shape): 145.42,13.3 149.32,13.3 149.47,13.15 149.47,11.16 149.24,10.93 148.29,10.93 148.14,11.07 148.14,11.45 147.94,11.65 146.9,11.65 146.75,11.5 146.75,11.32 146.39,10.96 143.62,10.96 143.58,11 143.58,11.26 143.6,11.28 144.11,11.28 144.13,11.3 144.13,11.82 144.12,11.83 143.61,11.83 143.57,11.86 143.57,12.05 143.59,12.07 144.12,12.07 144.14,12.09 144.14,12.63 144.12,12.65 143.6,12.65 143.57,12.68 143.57,13.58 143.64,13.65 145.06,13.65
+1.0VA on IN1 (solid shape): 142.45,59.11 142.45,58.59 142.28,58.42 142.28,58.21 142.33,58.16 142.33,57.99 142.51,57.8 142.78,57.8 143.03,58.05 143.48,58.05 143.47,57.71 143.81,57.67 143.81,56.13 143.32,55.64 142.95,55.64 142.81,55.78 142.81,56 142.81,56 142.81,56.15 143.15,56.5 143.15,56.92 142.92,57.16 140.31,57.16 140.3,57.18 139.55,57.18 139.3,57.43 139.3,58.75 139.76,59.21 142.35,59.21
+1.0VA on GND3 (solid shape): 149.28,14.2 149.28,12.73 149.16,12.61 148.69,12.61 148.46,12.84 146.66,12.84 146.53,12.72 145.15,12.72 145.07,12.8 145.07,13.11 145.28,13.33 146.07,13.33 146.38,13.64 146.38,13.94 146.25,14.08 145.7,14.08 145.58,14.2 145.58,14.37 145.69,14.49 148.99,14.49
+1.0VA on IN4 (solid shape): outline of 930 points within 121.4,50.08 128.39,58.05
+1.0VA on VCC: 145.74,14.03 145.58,14.18 145.58,20.48 150.92,25.81 150.92,43.95 151.32,44.36 153.84,44.36 154.85,45.37 154.85,68.21 152.82,70.24 142.21,70.24 139.62,72.83 134.17,72.83 134.08,72.84 134.07,72.83 129.04,72.83 127.7,71.49 127.7,58.4 128.11,57.99 128.11,57.77 128.07,57.81 128,57.74 127.98,57.74 127.96,57.72 125.65,57.72 125.19,58.18 125.19,74.41 125.51,74.73 157.55,74.73 158.08,74.2 158.1,23.07 149.06,14.03
+1.0VAP on TOP (solid shape): 143.28,11.6 143.28,10.29 142.98,9.99 139.99,9.99 139.76,10.21 139.76,11.4 140.17,11.81 143.07,11.81
+1.0VAP on BOTTOM (solid shape): 143.4,12.95 143.4,12.5 143.42,12.48 143.49,12.48 143.5,12.48 143.95,12.48 143.97,12.46 143.97,12.26 143.95,12.23 143.46,12.23 143.42,12.2 143.42,11.69 143.44,11.67 143.92,11.67 143.95,11.64 143.95,11.46 143.93,11.44 143.41,11.44 143.36,11.39 143.36,6.62 142.91,6.17 138.13,6.17 137.96,6.34 137.96,8.78 138.04,8.97 137.96,9.17 137.96,10.4 139.53,11.97 139.53,12.48 142.19,12.48 142.7,12.99 143.35,12.99
+1.0VAP on GND1 (solid shape): 142.35,12.55 142.35,12.12 141.81,11.58 140.17,11.58 140.06,11.68 140.06,12.07 139.81,12.33 139.81,12.62 139.9,12.71 142.19,12.71
+1.0VAP on GND3 (solid shape): 142.5,12.6 142.5,12.09 142.4,11.99 139.91,11.99 139.8,12.09 139.8,12.6 139.9,12.7 142.4,12.7
+1.0VS_VCCIO on TOP (solid shape): 113.22,51.67 114.57,51.67 114.74,51.5 114.74,49.54 114.57,49.37 114.08,49.37 113.89,49.56 113.89,50.38 112.62,51.64 112.62,51.91 112.68,51.97 112.92,51.97
+1.0VS_VCCIO on TOP (solid shape): 122.64,52.66 122.64,51.9 122.65,51.89 122.65,51.73 122.88,51.49 123.05,51.49 123.15,51.39 123.15,50.85 123.03,50.74 122.3,50.74 122.3,50.87 121.91,51.26 121.91,51.27 121.81,51.47 121.62,51.56 121.54,51.62 121.55,51.72 121.1,52.24 121.19,51.56 121.26,51.5 121.23,51.07 121.5,50.86 121.52,50.86 121.53,50.85 121.71,50.67 121.71,50.27 120.78,49.34 119.64,49.34 119.54,49.45 119.54,50.07 119.67,50.2 120.09,50.2 120.17,50.28 120.17,50.99 120.23,51.05 120.23,51.38 120.17,51.44 120.17,51.45 120.17,52.03 120.04,52.16 119.41,52.16 119.28,52.29 119.28,52.79 119.41,52.92 122.39,52.92
+1.0VS_VCCIO on BOTTOM (solid shape): 133.57,74.23 133.57,71.09 133.42,70.95 132.83,70.95 132.65,71.13 132.65,74.27 132.75,74.38 133.42,74.38
+1.0VS_VCCIO on BOTTOM (solid shape): 155.54,53.43 155.54,52.81 155,52.81 155,52.31 155.54,52.31 155.54,52.01 155,52.01 155,51.51 155.54,51.51 155.54,49.2 155.22,48.88 153.18,48.88 151.88,50.18 151.88,52.92 152.55,53.59 155.38,53.59
+1.0VS_VCCIO on BOTTOM (solid shape): 121.2,51.23 121.2,51.21 121.24,51.06 121.34,50.93 121.34,49.85 120.83,49.34 120.53,49.34 120.52,49.38 120.35,49.55 120.11,49.5 119.92,49.34 119.71,49.34 119.58,49.47 119.58,49.84 119.6,49.89 119.61,49.95 119.84,50.18 119.86,50.18 119.99,50.25 120.07,50.39 120.07,50.41 120.12,50.46 120.12,50.94 120.15,51 120.52,51.37 121.06,51.37
+1.0VS_VCCIO on IN3 (solid shape): outline of 1334 points within 112.42,48.99 128.01,53.68
+1.0VS_VCCIO on IN4 (solid shape): 133.57,74.4 133.57,74.05 131.03,74.05 131.01,74.07 131.01,74.45 131.08,74.52 133.45,74.52
+1.0VS_VCCIO on IN4 (solid shape): 133.86,71.7 133.86,71.18 133.6,70.91 132.96,70.91 132.65,71.22 132.65,71.6 132.86,71.82 133.75,71.82
+1.0VS_VCCIO on IN4 (solid shape): 120.91,53.7 120.91,52.05 120.9,52.02 120.92,51.74 121.15,51.56 121.18,51.55 121.18,49.75 120.71,49.27 120.58,49.24 119.98,49.24 119.88,49.27 119.8,49.27 119.73,49.26 119.55,49.44 119.55,50.34 120.17,50.97 120.17,51.71 118.82,53.06 117.91,53.06 117.83,53.07 117.76,53.06 117.08,53.06 117.04,53.07 117,53.06 116.39,53.06 116.39,53.06 116.29,53.08 116.19,53.06 116.18,53.06 115.27,53.06 115.21,53.07 115.15,53.06 114.65,53.06 114.26,52.68 114.26,50.47 114.61,50.12 114.61,49.43 114.48,49.3 114.14,49.3 113.73,49.71 113.72,49.72 113.66,49.8 113.59,49.85 113.58,49.86 112.55,50.89 112.55,51.06 112.71,51.33 112.61,51.62 112.57,51.7 112.6,51.77 112.61,51.77 112.61,53.36 112.91,53.66 119.34,53.66 119.83,54.15 120.46,54.15
+1.0VS_VCCIO on IN4 (solid shape): outline of 173 points within 130.62,60.41 133.86,71.61
+1.0VS_VCCIO on VCC: 127.88,44.86 126.08,46.67 126.02,46.67 123.03,49.66 121.32,49.66 120.74,49.08 114.06,49.08 112.5,50.64 112.5,53.11 112.76,53.38 113.77,53.38 115.65,51.5 115.65,51.05 116.01,50.7 119.76,50.7 120.14,51.09 153.91,51.09 154.34,50.65 154.34,45.58 153.63,44.86
+1.0VS_VCCIOP on BOTTOM (solid shape): 161.66,54.64 161.66,54.23 161.41,53.98 161.15,53.98 160.76,53.59 160.76,51.68 160.22,51.14 155.71,51.14 155.71,53.38 156.03,53.69 156.58,53.69 156.58,53.7 156.69,53.7 157.57,54.57 160.18,54.57 160.32,54.71 161.59,54.71
+1.2V_DDR on TOP (solid shape): 135.41,30.82 135.92,30.82 136.04,30.7 136.04,30.04 134.29,28.28 133.25,28.28 133.12,28.41 133.12,29.43 132.74,29.81 130.2,29.81 129.95,30.06 129.95,30.82 130.1,30.97 135.26,30.97
+1.2V_DDR on TOP (solid shape): outline of 98 points within 130.2,20.66 138.11,25.11
+1.2V_DDR on TOP (solid shape): outline of 287 points within 108.37,36.72 125.31,47.33
+1.2V_DDR on TOP (solid shape): outline of 477 points within 139.13,20.96 145.1,30.9
+1.2V_DDR on BOTTOM (solid shape): outline of 416 points within 126.98,10.37 148.21,19.65
+1.2V_DDR on IN1 (solid shape): outline of 91 points within 140.2,21.54 142.04,25.9
+1.2V_DDR on IN1 (solid shape): 124.04,25.21 124.14,25.18 124.53,24.79 125.55,24.79 125.87,24.47 125.86,24.4 125.88,24.34 125.88,24.03 125.72,23.88 125.51,23.87 125.34,23.75 125.26,23.71 125.18,23.74 124.75,23.83 124.56,23.44 124.54,23.35 124.46,23.32 124.03,23.32 123.94,23.36 123.94,23.46 123.96,23.73 123.79,23.94 123.74,24.03 123.98,24.43 123.74,24.83 123.79,24.91 123.9,25.01 123.97,25.14
+1.2V_DDR on IN1 (solid shape): outline of 198 points within 118.41,21.03 122.85,24.33
+1.2V_DDR on IN1 (solid shape): outline of 219 points within 134.93,18.66 139.41,22.37
+1.2V_DDR on IN1 (solid shape): 137.57,25.01 137.89,24.87 138.22,25.01 138.29,24.98 138.33,24.94 138.37,24.91 138.42,24.83 138.37,24.74 138.26,24.21 138.79,24.18 138.87,24.21 138.94,24.18 138.98,24.14 139.02,24.12 139.07,24.03 139.02,23.94 138.84,23.55 139.16,23.27 139.23,23.24 139.25,23.17 139.25,22.85 139.94,22.17 139.94,21.68 139.91,21.61 139.84,21.58 139.48,21.23 139.84,20.87 139.91,20.84 139.94,20.77 139.94,20.2 140.25,19.89 140.13,19.78 140.13,19.51 139.99,19.51 139.46,20.04 139.43,20.11 139.45,20.18 139.52,20.56 139.21,20.78 139.14,20.81 139.11,20.88 139.11,21.08 139.33,21.3 139.33,22.56 138.72,23.17 137.53,23.17 137.43,23.24 137.47,23.35 137.6,23.66 137.41,23.94 137.36,24.03 137.6,24.43 137.36,24.83 137.41,24.91 137.46,24.94 137.49,24.98
+1.2V_DDR on IN1 (solid shape): 131.48,26.97 131.48,25.53 131.47,25.49 131.43,25.48 131.14,25.32 131.1,24.99 131.23,24.8 131.43,24.73 131.47,24.71 131.48,24.68 131.48,24.63 131.47,24.59 131.43,24.58 131.25,24.52 131.12,24.36 131.06,24.33 131.01,24.3 130.94,24.27 130.87,24.3 130.77,24.4 129.82,24.4 129.82,24.45 129.54,24.8 129.14,24.6 129.13,24.57 127.65,24.57 127.48,24.74 127.48,24.83 127.56,24.88 127.68,24.91 127.78,24.98 127.85,25.01 127.92,24.98 128.47,25.01 128.35,25.54 128.29,25.63 128.35,25.72 128.39,25.75 128.43,25.78 128.5,25.81 128.82,25.67 129.08,25.77 129.15,25.8 129.22,25.77 129.33,25.7 129.46,25.67 129.61,25.7 129.72,25.78 129.8,25.81 129.87,25.78 130.14,25.67 130.4,25.81 130.48,25.84 130.55,25.81 130.96,25.71 131.18,26.07 130.93,26.38 130.55,26.26 130.47,26.22 130.39,26.26 130.35,26.3 130.29,26.34 130.24,26.43 130.48,26.83 130.24,27.23 130.29,27.31 130.46,27.53 130.43,27.8 130.43,27.88 130.48,27.94 130.51,27.94
+1.2V_DDR on IN1 (solid shape): outline of 376 points within 134.03,25.99 139.15,29.44
+1.2V_DDR on IN1 (solid shape): outline of 399 points within 102.71,17.8 107.06,25.56
+1.2V_DDR on IN1 (solid shape): outline of 409 points within 124.79,25.17 130,28.78
+1.2V_DDR on IN1 (solid shape): outline of 688 points within 119.03,24.45 123.78,29.66
+1.2V_DDR on IN1 (solid shape): outline of 1477 points within 81.93,18.35 90.33,29.77
+1.2V_DDR on IN1 (solid shape): outline of 3860 points within 113.28,20.64 149.47,52.02
+1.2V_DDR on IN2 (solid shape): outline of 2807 points within 89.88,14.69 150.11,24.82
+1.2V_DDR on IN4 (solid shape): outline of 16215 points within 82.62,15.83 147.99,30.12
+1.2V_DDRP on TOP (solid shape): 129.66,12.64 129.66,11.7 129.32,11.36 129.32,9.69 128.85,9.23 126.14,9.23 126.14,11.08 126.28,11.23 126.51,11.23 126.55,11.27 126.55,12.56 126.82,12.83 129.47,12.83
+1.2V_DDRP on BOTTOM (solid shape): 129.45,13.97 129.45,13.12 129.47,13.11 129.98,13.11 130.01,13.08 130.01,12.69 129.98,12.66 129.48,12.66 129.46,12.64 129.46,11.95 129.5,11.91 130.01,11.91 130.01,11.46 129.47,11.46 129.45,11.43 129.45,7.56 128.32,6.43 128.32,4.88 128.16,4.73 125.44,4.73 124.83,5.34 124.83,7.55 124.27,8.11 121.88,8.11 121.05,7.27 119.24,7.27 119.14,7.37 119.14,8.11 119.15,8.12 119.15,8.3 120.33,9.48 120.33,9.48 120.46,9.61 125.59,9.61 125.77,9.79 125.77,11.03 125.72,11.08 125.72,13.39 125.73,13.4 125.73,13.92 125.92,14.12 129.3,14.12
+1.2V_DDRP on GND1 (solid shape): 128.92,11.6 129.09,11.6 129.19,11.5 129.19,11.03 129.08,10.93 126.34,10.93 126.18,11.09 126.18,11.43 126.34,11.6 128.91,11.6
+1.2V_DDRP on GND1 (solid shape): 129.05,12.79 129.47,12.79 129.64,12.62 129.64,12.27 129.52,12.15 126.11,12.15 126.04,12.22 126.04,12.62 126.13,12.71 126.15,12.71 126.22,12.79 129.05,12.79
+1.2V_DDRP on GND3 (solid shape): 129.26,11.58 129.26,11.11 129.05,10.89 126.37,10.89 126.18,11.08 126.18,11.61 126.29,11.72 129.12,11.72
+1.2V_DDRP on GND3 (solid shape): 128.79,12.67 129.1,12.67 129.24,12.53 129.24,11.99 129.15,11.9 126.29,11.9 126.29,11.9 126.09,11.9 126,12 126,12.49 126.18,12.67 128.79,12.67
+1.8V_3.3V_ALW_VTR3 on TOP (solid shape): 24.6,22.67 24.6,21.67 23.67,20.74 22.1,20.74 21.71,20.34 21.71,19.51 21.63,19.44 21.2,19.44 21.02,19.62 21.02,20.48 21.73,21.19 21.93,21.19 22.14,21.4 22.14,21.79 22.24,21.89 22.58,21.89 22.72,22.03 22.72,22.68 22.78,22.74 24.52,22.74
+1.8VA on TOP (solid shape): 32.68,23.71 32.68,23.07 32.55,22.94 30.25,22.94 30.01,23.18 29.07,23.18 28.98,23.27 28.98,23.77 29.05,23.83 32.55,23.83
+1.8VA on TOP (solid shape): 103.66,72.47 103.66,71.9 102.92,71.16 102.42,71.16 102.39,71.2 102.39,72.16 102.39,72.16 102.39,72.41 102.57,72.59 103.54,72.59
+1.8VA on TOP (solid shape): 140.5,55.35 140.5,54.11 140.31,53.93 138.55,53.93 137.97,53.35 137.95,53.35 137.72,53.13 137.72,53.11 137.66,53.07 137.63,53.03 136.93,53.03 136.93,54.1 137.45,54.1 138.84,55.49 140.35,55.49
+1.8VA on TOP (solid shape): 252.78,6.7 252.78,6.62 252.71,6.55 252.05,6.55 251.99,6.49 251.99,6.4 252.04,6.35 252.72,6.35 252.78,6.29 252.78,5.89 253.39,5.28 253.39,4.69 253.32,4.62 251.35,4.62 251,4.96 251,6.68 251.14,6.81 252.67,6.81
+1.8VA on TOP (solid shape): 25.64,23.88 25.64,22.97 25.52,22.84 24.7,22.84 24.6,22.94 24.22,22.94 24.18,22.98 24.18,23.47 24.14,23.51 23.66,23.51 23.64,23.49 23.64,22.96 23.59,22.91 22.95,22.91 22.79,23.08 22.79,23.92 23.01,24.14 25.39,24.14
+1.8VA on BOTTOM (solid shape): 150.14,53.06 150.14,51.81 149.97,51.64 147.01,51.64 146.62,52.03 146.62,52.5 147.03,52.92 148.5,52.92 148.84,53.26 149.94,53.26
+1.8VA on BOTTOM (solid shape): 154.97,57.88 154.97,56.1 154.53,55.66 151.1,55.66 150.94,55.82 150.94,56.34 151.7,57.11 153.55,57.11 154.02,57.58 154.02,57.93 154.11,58.03 154.83,58.03
+1.8VA on BOTTOM (solid shape): 201.44,11.31 201.44,11.01 201.3,10.87 200.48,10.87 200.31,10.71 199.72,10.71 199.55,10.88 199.55,10.98 199.69,11.12 200.01,11.18 200.34,11.24 200.63,11.34 200.79,11.38 200.8,11.39 201.36,11.39
+1.8VA on BOTTOM (solid shape): 140.71,55.05 141.3,55.05 141.37,54.98 141.37,54.43 141.33,54.39 140.85,54.39 140.84,54.4 140.54,54.4 140.24,54.7 138.26,54.7 137.74,55.22 137.68,55.28 137.12,55.28 137.06,55.35 137.06,55.5 137.11,55.56 140.19,55.56
+1.8VA on IN1 (solid shape): 27.37,23.93 27.45,23.84 27.57,23.79 27.63,23.76 27.66,23.7 27.94,23.35 28.34,23.56 28.34,23.56 28.57,23.8 29.16,23.8 29.23,23.72 29.23,22.92 29.01,22.7 28.22,22.7 28.22,22.7 27.89,22.7 27.89,22.71 27.51,22.71 27.5,22.74 27.32,22.9 27.09,22.84 27.02,22.82 26.95,22.85 26.38,23.42 26.38,23.43 26.31,23.52 26.22,23.58 26.14,23.59 26.06,23.58 25.52,23.58 25.46,23.51 24.94,23.51 24.84,23.61 24.84,23.87 24.93,23.96 27.35,23.96
+1.8VA on IN1 (solid shape): 142.32,53.66 142.3,53.61 142.28,53.56 142.28,53.51 142.28,53.46 142.3,53.41 142.32,53.37 142.35,53.34 142.38,53.31 142.42,53.28 142.46,53.27 142.51,53.26 142.55,53.26 142.6,53.26 142.64,53.28 142.68,53.3 142.71,53.33 142.74,53.36 142.76,53.4 142.78,53.44 142.79,53.48 142.79,53.52 142.8,53.54 142.82,53.57 142.85,53.58 142.87,53.59 142.89,53.59 147.45,53.59 148.01,53.03 148.01,51.93 147.66,51.58 144.92,51.58 144.42,52.07 142.2,52.07 142.18,52.09 141.29,52.09 140.97,52.42 140.85,52.42 139.84,53.42 141.01,53.42 141.01,53.38 141.02,53.33 141.04,53.29 141.07,53.26 141.1,53.22 141.14,53.2 141.18,53.18 141.23,53.17 141.28,53.17 141.32,53.17 141.36,53.19 141.4,53.21 141.44,53.24 141.47,53.27 141.49,53.31 141.51,53.36 141.52,53.4 141.52,53.45 141.51,53.49 141.49,53.53 141.47,53.57 141.44,53.61 141.4,53.64 141.36,53.66 141.32,53.67 141.28,53.68 141.23,53.68 141.18,53.67 141.14,53.65 141.1,53.62 141.07,53.59 141.04,53.55 141.02,53.51 141.01,53.47 141.01,53.42 139.84,53.42 139.28,53.99 139.28,55.2 139.38,55.3 140.68,55.3
+1.8VAP on BOTTOM (solid shape): 158.37,59.86 158.37,58.83 158.35,58.81 158.35,58.07 158.35,58.06 158.35,57.79 158.34,57.78 158.34,57.01 158.26,56.94 155.65,56.94 155.33,57.26 155.33,58.08 155.17,58.25 154.02,58.25 153.74,57.96 153.74,57.53 153.5,57.28 153.13,57.28 153.13,57.81 152.7,57.81 152.7,57.28 152.35,57.28 152.17,57.47 152.17,59.98 152.26,60.08 158.15,60.08
+1.8VS_AUDIO on BOTTOM (solid shape): 266.44,12.34 267.9,12.34 268.01,12.24 268.01,10.55 267.91,10.45 267.51,10.45 267.35,10.6 267.35,11.39 267.2,11.54 266.44,11.54 266.31,11.54 266.2,11.43 266.2,10.83 266.15,10.78 265.68,10.78 265.49,10.97 265.49,12.73 265.57,12.81 265.97,12.81
+1.8VU on TOP (solid shape): 148.57,25.91 148.57,25.55 148.52,25.5 147.84,25.5 147.51,25.17 146.7,25.17 146.68,25.19 146.68,25.62 147.09,26.02 148.45,26.02
+1.8VU on TOP (solid shape): 132.08,26.17 132.08,26.15 132.1,26.15 132.34,25.92 132.75,25.92 132.8,25.87 132.8,25.42 132.71,25.33 131.96,25.33 131.72,25.58 130.68,25.58 130.53,25.43 130.37,25.43 130.24,25.56 130.24,25.66 130.47,25.89 130.47,25.98 130.55,26.06 130.56,26.09 130.58,26.12 130.75,26.29 131.96,26.29
