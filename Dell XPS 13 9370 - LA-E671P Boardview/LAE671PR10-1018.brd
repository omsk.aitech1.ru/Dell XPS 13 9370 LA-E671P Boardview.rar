# Allegro board LAE671PR10-1018.brd (continued)
## Nets (continued)
+1.2V_DDR: CC32.1 CC33.1 CC34.1 CC35.1 CC36.1 CC37.1 CC38.1 CC43.1 CC44.1 CC45.1 CC46.1 CC47.1 CC48.1 CC49.1 CC50.1 CC92.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD11.1 CD13.1 CD14.1 CD15.1 CD16.1 CD17.1 CD18.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD24.1 CD25.1 CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD32.1 CD33.1 CD34.1 CD39.1 CD43.1 CD46.1 CD49.1 CD50.1 CD51.1 CD52.1 CD53.1 CD54.1 CD55.1 CD56.1 CD57.1 CD58.1 CD59.1 CD60.1 CD61.1 CD62.1 CD63.1 CD64.1 CD65.1 CD66.1 CD67.1 CD68.1 CD69.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CZ7.1 PJP600.2 RC162.1 RD9.1 RD13.1 RD14.1 UC9.5 UCPU1.AU23 UCPU1.AU28 UCPU1.AU35 UCPU1.AU42 UCPU1.BB23 UCPU1.BB32 UCPU1.BB41 UCPU1.BB47 UCPU1.BB51 UD41.A8 UD41.A9 UD41.A11 UD41.C12 UD41.D4 UD41.D5 UD41.D6 UD41.E8 UD41.E12 UD41.F2 UD41.G2 UD41.G5 UD41.G12 UD41.H3 UD41.H5 UD41.H6 UD41.H8 UD41.H9 UD41.H11 UD41.H12 UD41.J5 UD41.J6 UD41.J9 UD41.J10 UD41.K5 UD41.K6 UD41.K8 UD41.K11 UD41.K12 UD41.L2 UD41.L5 UD41.L12 UD41.M2 UD41.N8 UD41.N12 UD41.P4 UD41.P5 UD41.P6 UD41.R12 UD41.U8 UD41.U9 UD41.U11 UD42.A8 UD42.A9 UD42.A11 UD42.C12 UD42.D4 UD42.D5 UD42.D6 UD42.E8 UD42.E12 UD42.F2 UD42.G2 UD42.G5 UD42.G12 UD42.H3 UD42.H5 UD42.H6 UD42.H8 UD42.H9 UD42.H11 UD42.H12 UD42.J5 UD42.J6 UD42.J9 UD42.J10 UD42.K5 UD42.K6 UD42.K8 UD42.K11 UD42.K12 UD42.L2 UD42.L5 UD42.L12 UD42.M2 UD42.N8 UD42.N12 UD42.P4 UD42.P5 UD42.P6 UD42.R12 UD42.U8 UD42.U9 UD42.U11 UD43.A8 UD43.A9 UD43.A11 UD43.C12 UD43.D4 UD43.D5 UD43.D6 UD43.E8 UD43.E12 UD43.F2 UD43.G2 UD43.G5 UD43.G12 UD43.H3 UD43.H5 UD43.H6 UD43.H8 UD43.H9 UD43.H11 UD43.H12 UD43.J5 UD43.J6 UD43.J9 UD43.J10 UD43.K5 UD43.K6 UD43.K8 UD43.K11 UD43.K12 UD43.L2 UD43.L5 UD43.L12 UD43.M2 UD43.N8 UD43.N12 UD43.P4 UD43.P5 UD43.P6 UD43.R12 UD43.U8 UD43.U9 UD43.U11 UD44.A8 UD44.A9 UD44.A11 UD44.C12 UD44.D4 UD44.D5 UD44.D6 UD44.E8 UD44.E12 UD44.F2 UD44.G2 UD44.G5 UD44.G12 UD44.H3 UD44.H5 UD44.H6 UD44.H8 UD44.H9 UD44.H11 UD44.H12 UD44.J5 UD44.J6 UD44.J9 UD44.J10 UD44.K5 UD44.K6 UD44.K8 UD44.K11 UD44.K12 UD44.L2 UD44.L5 UD44.L12 UD44.M2 UD44.N8 UD44.N12 UD44.P4 UD44.P5 UD44.P6 UD44.R12 UD44.U8 UD44.U9 UD44.U11 UZ5.1 UZ5.2 UZ5.7
+1.2V_DDRP: PC608.1 PC609.1 PC610.1 PC611.1 PC612.1 PC613.1 PJP600.1 PL601.2 PR603.1 PU600.7 PU600.8
+1.2V_MEM_CPUCLK: RC162.2 UCPU1.AM40
+1.8V_3.3V_ALW_VTR3: CE55.1 JP3.2 RE183.2 UE3.N5
+1.8V_PGPP: RC176.2 UCPU1.AF16
+1.8VA: C101.1 CC61.1 CC69.1 CE54.1 JP3.1 PJP800.2 R2.1 R115.1 RC176.1 RC384.1 RH51.2 RH53.2 RH55.2 RH57.2 RH59.2 U14.6 U14.7 UCPU1.AA1
+1.8VAP: PC801.1 PC802.1 PC809.1 PJP800.1 PL801.2 PR802.1 PR806.2 PU800.14
+1.8VS_AUDIO: C103.1 CA55.1 CA56.1 R95.2 RA1.2 RA22.2 U6.17
+1.8VU: CD1.1 CD2.1 CD3.1 CD9.1 CD10.1 CD12.1 CD40.1 CD41.1 CD42.1 CD44.1 CD45.1 CD47.1 CD48.1 PJP900.2 UD41.A3 UD41.A4 UD41.A5 UD41.A6 UD41.A10 UD41.U3 UD41.U4 UD41.U5 UD41.U6 UD41.U10 UD42.A3 UD42.A4 UD42.A5 UD42.A6 UD42.A10 UD42.U3 UD42.U4 UD42.U5 UD42.U6 UD42.U10 UD43.A3 UD43.A4 UD43.A5 UD43.A6 UD43.A10 UD43.U3 UD43.U4 UD43.U5 UD43.U6 UD43.U10 UD44.A3 UD44.A4 UD44.A5 UD44.A6 UD44.A10 UD44.U3 UD44.U4 UD44.U5 UD44.U6 UD44.U10
+1.8VUP: PC901.1 PC902.1 PC908.1 PJP900.1 PL901.2 PR902.1 PR906.2 PU900.14
+3.3V_1.8V_ESPI: RC21.1 RC24.1 RC386.2
+3.3V_1.8V_PGPPA: RC384.2 RC386.1 RH86.2 RH87.2 UCPU1.AK15
+3.3V_EC5105: CE49.1 CE50.1 CE51.1 JP2.2 RE105.2 RE107.2 RE108.2 RE109.2 RE111.2 RE112.2 RE113.2 RE119.2 RE124.2 RE127.2 RE130.2 RE133.2 RE231.2 RE242.2 RE243.2 RE252.2 RE272.2 RE280.2 RE289.2 RPE4.5 RPE4.6 RPE4.7 RPE4.8 UE3.G8 UE3.H1 UE3.M9
+3.3V_EC_PLL: CE47.1 CE48.1 RE113.1 UE3.F1
+3.3V_PGPP: CC57.1 CC58.1 CC59.1 RC167.2 UCPU1.AD15 UCPU1.AG15 UCPU1.T16 UCPU1.Y15 UCPU1.Y16
+3.3V_SPI: RC170.2 UCPU1.AJ16
+3.3VDX_SSD: C41.1 C42.1 C43.1 C44.1 C45.1 C90.1 JNGFF1.2 JNGFF1.4 JNGFF1.12 JNGFF1.14 JNGFF1.16 JNGFF1.18 JNGFF1.70 JNGFF1.72 JNGFF1.74 R29.1 R32.2 R83.2 U24.C1
+3.3VDX_SSD_IN+: R83.1 U11.8 U11.9 U24.D1
+3V_LDO: PC125.2 PC337.1 PQ123.3 PQ124.3 PR112.2 PR115.1 PR121.2 PR139.1 PR141.2 PR148.2 PR155.2 PR215.1 PR222.1 PR270.1 PR276.1 PT105.1(TP-1) PU301.5 R272.1 R5746.1 R5758.1 R5766.1
+3V_LDOP: PC129.1 PQ123.1 PU101.5
+3V_PCH: C82.1 CC4.1 CC68.1 CC74.1 CC75.1 CC94.1 JAPS1.1 JAPS1.7 JSPI1.15 R3.1 R19.1 R79.2 R282.1 RA65.1 RC17.1 RC18.2 RC20.2 RC23.2 RC25.2 RC26.2 RC27.2 RC29.2 RC36.1 RC40.1 RC41.1 RC45.1 RC46.1 RC53.2 RC54.2 RC55.2 RC56.2 RC81.2 RC83.1 RC118.1 RC119.1 RC167.1 RC170.1 RC225.1 RC395.1 RE253.2 RH61.1 RH62.1 RH71.1 RH75.1 RH81.1 RH84.2 U1.8 UCPU1.AJ21 UCPU1.AK17 UCPU1.V19
+3V_PCH_DSW: CC81.1 CC82.1 RC73.1 RC74.1 RC80.2 RC82.2 RC174.2 UCPU1.AD17 UCPU1.AD18 UCPU1.AJ17
+3V_TBT: C1095.1 C1096.1 CT61.1 CT62.1 CT63.1 CT64.1 CT65.1 LT2.2 RT50.2 RT88.2 RT90.1 UT2.A2 UT2.A3 UT2.B3 UT2.H9
+3V_TBT_S0: C1089.1 C1090.1 CT91.1 CT92.1 CT93.1 LT2.1 UT2.R13
+3V_VC_A: C139.1 R265.2 R5746.2 R5747.2 U19.B1 U19.H1
+3V_VC_B: C152.1 R266.2 R5758.2 R5759.2 U20.B1 U20.H1
+3V_VC_C: C165.1 R267.2 R5766.2 R5767.2 U21.B1 U21.H1
+3VA_TBT: C1091.1 C1092.1 C1113.1 C1114.1 CT60.1 RC396.1 RT10.1 RT11.1 RT13.1 RT14.1 RT19.1 RT20.1 RT25.1 RT26.1 RT27.1 RT29.1 RT30.1 RT31.1 RT49.2 RT84.1 RT88.1 RT89.2 RT100.1 RT429.1 RT430.1 UT2.F8
+3VA_TBT_LC: C1093.1 C1094.1 CT59.1 RT3.1 RT4.1 RT5.1 RT6.1 UT2.R6
+3VALW: C76.1 C80.1 C88.1 C92.1 C93.1 C100.1 C105.1 C375.1 C1050.1 C1070.1 C1073.1 C1077.1 C1123.1 CC60.1 CE46.1 CE52.1 CE53.1 CE70.1 CE72.1 CE73.1 JAPS1.3 JKB1.2 JP2.1 PC606.1 PC713.1 PJP500.2 PQ124.1 PR110.2 PR111.2 PR119.2 PR120.2 PR124.1 PR127.1 PR137.2 PR140.2 PR142.1 PR143.1 PR158.2 PR171.1 PR173.1 PR174.1 PR175.1 PR604.1 PR706.1 PR1404.1 PR1405.1 PR1414.1 PR1415.1 PR1423.1 PR1424.1 PR1503.1 PR1504.1 PR1522.1 PR1523.1 PU600.13 PU700.15 Q4.2 QH1.2 QH1.5 QH2.2 QH2.5 R252.2 R265.1 R266.1 R267.1 R271.2 R274.1 R5825.2 R5837.2 RC37.1 RC174.1 RC382.1 RE156.2 RE174.2 RE194.1 RE195.1 RE196.2 RE200.1 RE201.1 RE202.1 RE203.1 RE204.1 RE215.1 RE247.2 RE249.2 RE283.2 RE284.2 RE285.2 RE286.2 RE287.2 RPE7.5 RPE7.6 RPE7.7 RPE7.8 RT49.1 RT90.2 U10.3 U10.4 U10.6 U11.1 U11.2 U11.4 U11.6 U11.7 U13.1 U13.2 U13.4 U13.6 U13.7 U14.1 U14.2 U14.4 U16.5 U22.6 U26.2 U31.6 UC4.5 UC5.5 UC6.5 UC7.5 UC8.5 UE5.5 UE6.5 UE7.5 UE8.5 UZ1.1 UZ1.2 UZ1.7 UZ2.5
+3VALWP: PC505.1 PC506.1 PC507.1 PC508.1 PC526.1 PJP500.1 PL501.2 PR502.1 PR504.2 PU500.14
+3VLP: PC509.1 PU500.16 PU500.17 RE152.2 RTCD1.2
+3VS: C102.1 C107.1 C377.1 C1079.1 JESPI1.1 JESPI1.2 JKB1.3 PR600.2 PR601.2 PR805.2 PR905.2 PR1012.1 QC1.2 QC1.5 QZ1.3 R34.1 R36.2 R37.2 R39.2 R40.2 R42.1 R86.2 R94.2 R100.2 R281.2 R5838.1 RC1.2 RC3.2 RC5.2 RC7.2 RC16.1 RC38.1 RC39.1 RC58.1 RC62.1 RC63.1 RC65.1 RC67.1 RC70.1 RC88.1 RC114.2 RC179.1 RE168.2 RE241.1 RH64.1 RH65.1 RH66.2 RH67.2 RH82.1 RH83.1 RN1.1 RN2.1 RT50.1 RT70.1 RT89.1 UC2.5 UC10.5
+3VS_AUDIO: C96.1 LA2.1 LA4.1 R93.2 RA50.1 RC110.1
+3VS_CAM: C18.1 C19.1 C20.1 C21.1 C106.1 JCAM1.11 R98.2
+3VS_CR: C39.1 C40.1 CR5.1 CR6.1 CR7.1 CR8.1 RR1.2 RR9.1 RR10.1 RT70.2 UR1.11 UR1.27
+3VS_FP: C1080.1 JFP2.7 JFP2.8 R281.1
+3VS_MUX: C48.1 C50.1 C51.1 C1126.1 C1127.1 C1128.1 LA11.1 QC2.2 QC2.5 R44.1 R48.1 R49.2 R57.2 R58.2 R5797.2 R5798.1 R5801.1 R5804.1 R5806.1 R5807.2 R5808.1 U30.6 U30.20 U30.28
+3VS_MUX_L: LA11.2 R42.2 R272.2
+3VS_NGFF: C33.1 C34.1 C35.1 C95.1 R92.2 RC181.2 RC182.2 U24.D2 WL1.4 WL1.5 WL1.72 WL1.73
+3VS_NGFF_IN+: R92.1 U13.13 U13.14 U24.D3
+3VS_PWRM: C1075.1 C1076.1 R282.2 RE232.2 RE233.2 RE239.2 RE240.2 U24.A4 U24.B2
+3VS_TP: C121.1 C122.1 C1069.1 C1072.1 JTP1.1 R113.2 R114.2 R117.1 R268.2 RE235.1 RE236.1
+3VS_TPM: C27.1 C28.1 C29.1 C30.1 R19.2 R5838.2 RC178.1 RE27.1 U7.14 U7.22
+3VS_TS: C74.1 C131.1 C132.1 C133.1 D18.1 JEDP1.4 R73.2 RC183.1 RC184.1
+5VALW: C81.1 C89.1 C143.1 C144.1 C145.1 C146.1 C156.1 C157.1 C158.1 C159.1 C169.1 C170.1 C171.1 C172.1 C376.1 CZ4.1 JKB1.1 LED1.2 LED2.2 LED3.2 LED4.2 LED5.2 PJP501.2 R288.1 R5823.1 U12.1 U12.2 U12.4 U12.6 U12.7 U19.A11 U19.B11 U19.C11 U19.D11 U19.H10 U20.A11 U20.B11 U20.C11 U20.D11 U20.H10 U21.A11 U21.B11 U21.C11 U21.D11 U21.H10 UZ3.3 UZ4.3 UZ5.3
+5VALWP: PC518.1 PC519.1 PC520.1 PC521.1 PC522.1 PC527.1 PJP501.1 PL504.2 PR511.2 PR512.2
+5VS: C46.2 C47.2 C85.1 C1124.2 C1125.2 D78.1 D79.1 JUART1.1 LT6.1 LT7.1 PC1100.2 PC1110.2 PC1150.2 PC1164.2 PR1001.1 PR1048.1 PR1049.2 PR1050.2 PU1100.14 PU1101.14 PU1150.14 PU1151.14 R38.2 R41.2 R80.2
+5VS_AUDIO: C91.1 CA3.1 CA5.1 LA1.2 LA3.2 R84.2 U4.1
+8.4V_BATT+: PC322.1 PC323.1 PQ304.1 PQ304.2 PQ304.3 PR304.2 PR324.1
+AVDD1: CA9.1 CA10.2 CA11.1 LA3.1 U5.40
+AVDD2: CA12.1 CA13.2 RA1.1 U5.20
+DVDD: CA4.2 CA7.1 CA17.1 CA49.1 CA53.1 LA2.2 RA8.2 RA9.1 RA10.1 RA11.1 RA15.1 RA30.1 U5.3 U6.16
+DVDDIO: CA14.2 CA15.1 LA4.2 U5.18
+PVDD2: CA6.2 CA8.1 LA1.1 U5.41 U5.46
+V1.8S_EDRAM: R2.2 RC152.1 UCPU1.H63
+VBUS1_20V: PC104.1 PC105.1 PC106.1 PC107.1 PC108.1 PC109.1 PC133.1 PD103.2 PL100.2 PQ100.1 PQ100.2 PQ100.3 PQ133.3 PR100.1 PR213.1 PR218.1
+VBUS1_PD_20V: C140.1 C178.2 C179.2 C180.2 C181.2 C1085.1 CT103.1 D21.1 DI1.2 DI1.3 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 LT3.2 PC100.1 PC101.1 PC102.1 PC103.1 PL100.1 PT101.1(TP-1) PT106.1(TP-1) PT107.1(TP-1)
+VBUS2_20V: PC115.1 PC117.1 PC118.1 PC119.1 PC121.1 PC123.1 PC134.1 PD106.2 PL101.2 PQ113.1 PQ113.2 PQ113.3 PQ135.3 PR128.1 PR219.1 PR220.1
+VBUS2_PD_20V: C153.1 C182.2 C183.2 C184.2 C185.2 C1086.1 CT104.1 D22.1 DI2.2 DI2.3 JUSBC2.A4 JUSBC2.A9 JUSBC2.B4 JUSBC2.B9 LT4.2 PC114.1 PC116.1 PC120.1 PC122.1 PL101.1 PT102.1(TP-1)
+VBUS3_20V: PC283.1 PC285.1 PC286.1 PC288.1 PC290.1 PC293.1 PC295.1 PD107.2 PL104.2 PQ153.1 PQ153.2 PQ153.3 PQ158.3 PR263.1 PR264.1 PR269.1
+VBUS3_PD_20V: C166.1 C186.2 C187.2 C188.2 C189.2 CT105.1 D23.1 DI3.2 DI3.3 JUSBC3.A4 JUSBC3.A9 JUSBC3.B4 JUSBC3.B9 LT5.2 PC284.1 PC289.1 PC292.1 PC294.1 PL104.1 PT103.1(TP-1) PT108.1(TP-1) PT109.1(TP-1)
+VCC0V9_CIO: C1107.1 C1108.1 CT82.1 CT83.1 CT84.1 UT2.R8 UT2.R9 UT2.R11 UT2.R12
+VCC0V9_DP: C1097.1 C1098.1 CT52.1 CT53.1 CT54.1 CT55.1 CT56.1 CT57.1 CT58.1 UT2.L6 UT2.L8 UT2.L11 UT2.L12 UT2.M6 UT2.M8 UT2.T11 UT2.T12 UT2.V11 UT2.V12 UT2.V13
+VCC0V9_PCIE: C1099.1 C1100.1 CT67.1 CT68.1 CT69.1 CT70.1 UT2.L18 UT2.L19 UT2.M13 UT2.M15 UT2.M16 UT2.M18 UT2.N18 UT2.N19
+VCC0V9_USB: C1103.1 C1104.1 CT66.1 CT71.1 UT2.R15 UT2.R16
+VCC_CORE: PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1204.1 PC1205.1 PC1206.1 PC1207.1 PC1208.1 PC1209.1 PC1210.1 PC1211.1 PC1212.1 PC1213.1 PC1214.1 PC1215.1 PC1216.1 PC1226.1 PC1230.1 PC1231.1 PC1232.1 PC1233.1 PC1234.1 PC1235.1 PC1236.1 PC1237.1 PC1238.1 PC1239.1 PC1240.1 PC1241.1 PC1242.1 PC1243.1 PC1244.1 PC1245.1 PC1250.1 PC1255.1 PC1259.1 PC1260.1 PC1261.1 PC1262.1 PC1263.1 PC1264.1 PC1265.1 PC1266.1 PC1267.1 PC1268.1 PC1269.1 PC1270.1 PC1271.1 PC1272.1 PC1273.1 PC1274.1 PC1275.1 PC1288.1 PC1289.1 PC1290.1 PC1291.1 PC1292.1 PC1293.1 PC1294.1 PC1295.1 PC1296.1 PC1297.1 PC1298.1 PC1299.1 PC1300.1 PC1301.1 PC1302.1 PC1303.1 PC1304.1 PC1305.1 PC1306.1 PC1309.1 PC1380.1 PC1381.1 PC1382.1 PC1383.1 PC1384.1 PC1385.1 PC1386.1 PC1387.1 PC1529.1 PL1100.2 PL1103.2 PR1106.1 PR1107.1 PR1115.1 PR1116.1 R275.1 R277.1 RC150.1 UCPU1.A30 UCPU1.A34 UCPU1.A39 UCPU1.A44 UCPU1.AK33 UCPU1.AK35 UCPU1.AK37 UCPU1.AK38 UCPU1.AK40 UCPU1.AL33 UCPU1.AL37 UCPU1.AL40 UCPU1.AM32 UCPU1.AM33 UCPU1.AM35 UCPU1.AM37 UCPU1.AM38 UCPU1.G30 UCPU1.G32 UCPU1.G33 UCPU1.G35 UCPU1.G37 UCPU1.G38 UCPU1.G40 UCPU1.G42 UCPU1.J30 UCPU1.J33 UCPU1.J37 UCPU1.J40 UCPU1.K33 UCPU1.K35 UCPU1.K37 UCPU1.K38 UCPU1.K40 UCPU1.K42 UCPU1.K43
+VCC_CORE_G0: T29.1(TP-1) UCPU1.K32
+VCC_CORE_G1: T30.1(TP-1) UCPU1.AK32
+VCC_EDRAM: CC19.1 CC20.1 CC21.1 CC22.1 CC23.1 CC24.1 CC25.1 PR1528.2 UCPU1.AB62 UCPU1.P62 UCPU1.V62
+VCC_EDRAM_P: PC1503.1 PC1504.1 PC1505.1 PL1501.2 PR1506.1 PR1528.1 PU1500.1
+VCC_EOPIO: CC26.1 CC27.1 PR1529.2 UCPU1.AE62 UCPU1.AG62
+VCC_EOPIO_P: PC1506.1 PC1515.1 PC1516.1 PL1503.2 PR1519.1 PR1529.1 PU1501.1
+VCCGT: PC1217.1 PC1218.1 PC1219.1 PC1220.1 PC1221.1 PC1223.1 PC1224.1 PC1225.1 PC1227.1 PC1228.1 PC1229.1 PC1246.1 PC1247.1 PC1248.1 PC1249.1 PC1253.1 PC1254.1 PC1256.1 PC1257.1 PC1258.1 PC1280.1 PC1281.1 PC1282.1 PC1283.1 PC1284.1 PC1285.1 PC1286.1 PC1307.1 PC1308.1 PC1329.1 PC1330.1 PC1331.1 PC1332.1 PC1333.1 PC1334.1 PC1336.1 PC1337.1 PC1339.1 PC1340.1 PC1344.1 PC1345.1 PC1346.1 PC1349.1 PC1351.1 PC1353.1 PC1355.1 PC1356.1 PC1357.1 PC1358.1 PC1359.1 PC1360.1 PC1361.1 PC1362.1 PC1373.1 PC1374.1 PC1375.1 PC1376.1 PC1377.1 PC1378.1 PC1379.1 PL1107.2 PL1150.2 PR1118.1 PR1119.1 PR1154.1 PR1155.1 R276.2 R278.2 R280.2 RC160.1 UCPU1.A58 UCPU1.A62 UCPU1.A66 UCPU1.AA63 UCPU1.AA64 UCPU1.AA66 UCPU1.AA67 UCPU1.AA69 UCPU1.AA70 UCPU1.AA71 UCPU1.AC64 UCPU1.AC65 UCPU1.AC66 UCPU1.AC67 UCPU1.AC68 UCPU1.AC69 UCPU1.AC70 UCPU1.AC71 UCPU1.AK53 UCPU1.AK55 UCPU1.AK56 UCPU1.AK58 UCPU1.AK60 UCPU1.AK70 UCPU1.AL53 UCPU1.AL56 UCPU1.AL60 UCPU1.AM53 UCPU1.AM56 UCPU1.AM58 UCPU1.AU58 UCPU1.AU63 UCPU1.BB57 UCPU1.BB66 UCPU1.J53 UCPU1.J55 UCPU1.J56 UCPU1.J58 UCPU1.J60 UCPU1.K53 UCPU1.K55 UCPU1.K56 UCPU1.K58 UCPU1.K60 UCPU1.L62 UCPU1.L63 UCPU1.L64 UCPU1.L65 UCPU1.L66 UCPU1.L67 UCPU1.L68 UCPU1.L69 UCPU1.L70 UCPU1.L71 UCPU1.M62 UCPU1.N63 UCPU1.N64 UCPU1.N66 UCPU1.N67 UCPU1.N69 UCPU1.N70 UCPU1.N71 UCPU1.R63 UCPU1.R64 UCPU1.R65 UCPU1.R66 UCPU1.R67 UCPU1.R68 UCPU1.R69 UCPU1.R70 UCPU1.R71 UCPU1.T62 UCPU1.U65 UCPU1.U68 UCPU1.U71 UCPU1.W63 UCPU1.W64 UCPU1.W65 UCPU1.W66 UCPU1.W67 UCPU1.W68 UCPU1.W69 UCPU1.W70 UCPU1.W71 UCPU1.Y62
+VCCIA_GT: PC1222.1 PC1251.1 PC1252.1 PC1276.1 PC1277.1 PC1278.1 PC1279.1 PC1287.1 PC1335.1 PC1338.1 PC1341.1 PC1342.1 PC1343.1 PC1347.1 PC1348.1 PC1350.1 PC1352.1 PC1354.1 PC1363.1 PC1364.1 PC1365.1 PC1366.1 PC1367.1 PC1368.1 PC1369.1 PC1370.1 PC1371.1 PC1372.1 R275.2 R276.1 R277.2 R278.1 R279.2 UCPU1.A48 UCPU1.A53 UCPU1.AK42 UCPU1.AK43 UCPU1.AK45 UCPU1.AK46 UCPU1.AK48 UCPU1.AK50 UCPU1.AL43 UCPU1.AL46 UCPU1.AL50 UCPU1.AM48 UCPU1.AM50 UCPU1.AM52 UCPU1.J43 UCPU1.J45 UCPU1.J46 UCPU1.J48 UCPU1.J50 UCPU1.J52 UCPU1.K48 UCPU1.K50
+VCCPLL_OC: CC30.1 CZ6.1 R103.2 UCPU1.AL23
+VCCSA: PC1310.1 PC1311.1 PC1312.1 PC1313.1 PC1314.1 PC1315.1 PC1316.1 PC1317.1 PC1318.1 PC1319.1 PC1320.1 PC1321.1 PC1322.1 PC1323.1 PC1324.1 PC1325.1 PC1326.1 PC1327.1 PC1328.1 PL1151.2 PR1159.1 RC166.1 UCPU1.AK23 UCPU1.AK25 UCPU1.G23 UCPU1.G25 UCPU1.G27 UCPU1.G28 UCPU1.J22 UCPU1.J23 UCPU1.J27 UCPU1.K23 UCPU1.K25 UCPU1.K27 UCPU1.K28 UCPU1.K30
+VSS_PLL: CE47.2 CE48.2 UE3.G1
AGND: CA9.2 CA10.1 CA11.2 CA12.2 CA13.1 CA23.2 CA24.2 CA25.1 CA26.2 CA30.2 CA76.2 CA77.2 CA78.2 CA79.2 JAUDIO1.3 JPA1.1 JPA2.1 RA16.2 RA59.2 RA60.2 U5.22 U5.37
DV12S: CR18.2 CR19.1 CR21.1 UR1.10 UR1.14
DV33_18: CR9.2 UR1.18
GND: C18.2 C19.2 C20.2 C21.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.1 C47.1 C48.2 C49.2 C50.2 C51.2 C70.1 C71.2 C74.2 C76.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C121.2 C122.2 C123.2 C124.2 C131.2 C132.2 C133.2 C139.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C174.2 C175.2 C176.2 C177.2 C178.1 C179.1 C180.1 C181.1 C182.1 C183.1 C184.1 C185.1 C186.1 C187.1 C188.1 C189.1 C375.2 C376.2 C377.2 C1018.2 C1049.2 C1050.2 C1051.2 C1052.2 C1053.2 C1054.2 C1065.2 C1066.2 C1067.2 C1068.2 C1069.2 C1070.2 C1072.2 C1073.2 C1075.2 C1076.2 C1077.2 C1079.2 C1080.2 C1081.2 C1082.2 C1083.2 C1085.2 C1086.2 C1087.2 C1088.2 C1089.2 C1090.2 C1091.2 C1092.2 C1093.2 C1094.2 C1095.2 C1096.2 C1097.2 C1098.2 C1099.2 C1100.2 C1101.2 C1102.2 C1103.2 C1104.2 C1105.2 C1106.2 C1107.2 C1108.2 C1109.2 C1110.2 C1111.2 C1112.2 C1113.2 C1114.2 C1115.2 C1116.2 C1119.2 C1120.2 C1122.2 C1123.2 C1124.1 C1125.1 C1126.2 C1127.2 C1128.2 CA1.2 CA2.2 CA3.2 CA4.1 CA5.2 CA6.1 CA7.2 CA8.2 CA14.1 CA15.2 CA17.2 CA18.2 CA20.1 CA21.2 CA22.2 CA27.1 CA28.2 CA29.2 CA31.2 CA32.2 CA33.2 CA34.2 CA35.2 CA36.2 CA37.2 CA38.2 CA39.2 CA40.2 CA41.2 CA42.2 CA43.2 CA44.2 CA45.2 CA46.2 CA47.2 CA48.2 CA49.2 CA50.2 CA51.2 CA52.2 CA53.2 CA54.2 CA55.2 CA56.2 CA57.2 CA58.2 CA59.2 CA60.2 CA61.2 CA66.1 CA67.2 CA72.2 CA73.2 CA74.2 CA75.2 CA82.2 CA83.2 CC2.1 CC4.2 CC5.1 CC6.2 CC7.2 CC8.2 CC9.2 CC10.2 CC11.2 CC12.2 CC13.2 CC19.2 CC20.2 CC21.2 CC22.2 CC23.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CC53.2 CC54.2 CC55.2 CC56.2 CC57.2 CC58.2 CC59.2 CC60.2 CC61.2 CC62.2 CC63.2 CC64.2 CC65.2 CC66.2 CC67.2 CC68.2 CC69.2 CC70.2 CC71.2 CC72.2 CC73.2 CC74.2 CC75.2 CC76.2 CC77.2 CC78.2 CC79.2 CC80.2 CC81.2 CC82.2 CC83.2 CC85.2 CC86.2 CC87.2 CC88.2 CC89.2 CC90.2 CC91.2 CC92.2 CC93.1 CC94.2 CC95.1 CC96.2 CC97.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD100.2 CD101.2 CD102.2 CD103.2 CD104.2 CD105.2 CD106.2 CD107.2 CD108.2 CD109.2 CE42.2 CE43.2 CE44.2 CE45.2 CE46.2 CE49.2 CE50.2 CE51.2 CE52.2 CE53.2 CE54.2 CE55.2 CE56.2 CE57.2 CE60.2 CE61.2 CE63.2 CE64.2 CE65.2 CE66.2 CE67.2 CE68.2 CE69.2 CE70.2 CE72.2 CE73.2 CE75.2 CE76.2 CE78.2 CE79.2 CE84.2 CE86.2 CE96.2 CH3.2 CLRP1.2 CMOS1.2 CR1.2 CR2.2 CR3.2 CR4.2 CR5.2 CR6.2 CR7.2 CR8.2 CR9.1 CR17.2 CR18.1 CR19.2 CR20.1 CR21.2 CR24.1 CR25.1 CR26.1 CT37.2 CT38.2 CT51.2 CT52.2 CT53.2 CT54.2 CT55.2 CT56.2 CT57.2 CT58.2 CT59.2 CT60.2 CT61.2 CT62.2 CT63.2 CT64.2 CT65.2 CT66.2 CT67.2 CT68.2 CT69.2 CT70.2 CT71.2 CT72.2 CT73.2 CT74.2 CT75.2 CT76.2 CT77.2 CT78.2 CT79.2 CT80.2 CT81.2 CT82.2 CT83.2 CT84.2 CT85.2 CT86.2 CT87.2 CT88.2 CT89.2 CT90.2 CT91.2 CT92.2 CT93.2 CT94.2 CT95.2 CT96.2 CT97.2 CT98.2 CT99.2 CT100.2 CT101.2 CT102.2 CT103.2 CT104.2 CT105.2 CZ1.2 CZ2.2 CZ3.2 CZ4.2 CZ5.2 CZ6.2 CZ7.2 CZ8.2 CZ9.2 D2.1 D3.2 D4.2 D10.1 D18.2 D20.1 D21.2 D22.2 D23.2 D24.2 D25.2 D26.2 D27.2 D28.2 D29.2 D30.2 D31.2 D32.2 D33.2 D34.2 D35.2 D36.2 D37.2 D38.2 D39.2 D40.2 D41.2 D42.2 D43.2 D44.2 D45.2 D46.2 D47.2 D48.2 D49.2 D50.2 D51.2 D52.2 D53.2 D54.2 D55.2 D56.2 D57.2 D58.2 D59.2 D60.2 D61.2 D62.2 D63.2 D64.2 D65.2 D66.2 D67.2 D68.2 D69.2 D70.2 D71.2 D72.2 D73.1 D74.1 D78.2 D79.2 DA1.2 DA2.2 DA3.2 DA4.2 DA5.2 DA6.2 DA7.2 DA8.2 DA9.2 DI1.1 DI2.1 DI3.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H16.1(TP-1) H17.1(TP-1) H19.1(TP-1) H20.1(TP-1) H21.1(TP-1) H23.1(TP-1) H24.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JAUDIO1.11 JAUDIO1.12 JAUDIO1.13 JAUDIO1.14 JCAM1.15 JCAM1.16 JCAM1.17 JCAM1.18 JCAM1.19 JCAM1.20 JCAM1.21 JCAM1.22 JCAM1.23 JCAM1.24 JCR1.6 JCR1.10 JCR1.11 JCR1.12 JCR1.13 JCR1.14 JCR1.17 JCR1.20 JCR1.23 JDEG1.10 JDEG1.11 JDEG1.12 JEDP1.6 JEDP1.11 JEDP1.14 JEDP1.21 JEDP1.24 JEDP1.27 JEDP1.30 JEDP1.33 JEDP1.36 JEDP1.39 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JESPI1.9 JESPI1.11 JESPI1.12 JFAN1.1 JFAN1.5 JFAN1.6 JFAN2.1 JFAN2.5 JFAN2.6 JFP2.3 JFP2.9 JFP2.10 JKB1.13 JKB1.14 JKB1.15 JKB1.16 JKB1.17 JNGFF1.1 JNGFF1.3 JNGFF1.9 JNGFF1.15 JNGFF1.21 JNGFF1.27 JNGFF1.33 JNGFF1.39 JNGFF1.45 JNGFF1.51 JNGFF1.57 JNGFF1.71 JNGFF1.73 JNGFF1.75 JNGFF1.76 JNGFF1.77 JPA1.2 JPA2.2 JRTC1.2 JRTC1.3 JRTC1.4 JSPI1.18 JSPI1.19 JSPI1.20 JSPI1.21 JSPI1.22 JSPK1.5 JSPK1.9 JSPK1.10 JT101.1 JT101.2 JT101.3 JT101.4 JT101.5 JT101.13 JT101.14 JTAG2.2 JTP1.4 JTP1.9 JTP1.10 JUART1.4 JUART1.5 JUART1.6 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JUSBC2.1 JUSBC2.2 JUSBC2.3 JUSBC2.4 JUSBC2.5 JUSBC2.6 JUSBC2.A1 JUSBC2.A12 JUSBC2.B1 JUSBC2.B12 JUSBC3.1 JUSBC3.2 JUSBC3.3 JUSBC3.4 JUSBC3.A1 JUSBC3.A12 JUSBC3.B1 JUSBC3.B12 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 JXDP1.61 JXDP1.62 JXDP1.63 MC1.2 MD1.1 MD2.1 MD3.1 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC126.2 PC127.2 PC128.2 PC129.2 PC130.2 PC131.2 PC132.1 PC133.2 PC134.2 PC136.2 PC137.2 PC140.2 PC283.2 PC284.2 PC285.2 PC287.2 PC288.2 PC289.2 PC290.2 PC292.2 PC293.2 PC294.2 PC295.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.2 PC308.2 PC309.2 PC310.2 PC313.2 PC314.2 PC315.2 PC316.2 PC317.2 PC318.2 PC319.2 PC320.2 PC321.2 PC322.2 PC323.2 PC324.2 PC325.2 PC326.2 PC329.2 PC331.2 PC332.2 PC333.1 PC334.2 PC335.1 PC337.2 PC339.2 PC340.2 PC341.2 PC342.2 PC343.2 PC345.1 PC347.2 PC348.2 PC349.2 PC350.2 PC351.2 PC352.2 PC500.2 PC501.2 PC502.2 PC503.2 PC505.2 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC513.2 PC514.2 PC515.2 PC516.2 PC517.2 PC518.2 PC519.2 PC520.2 PC521.2 PC522.2 PC523.2 PC524.2 PC526.2 PC527.2 PC528.2 PC529.2 PC600.2 PC601.2 PC602.2 PC603.2 PC604.2 PC606.2 PC607.2 PC608.2 PC610.2 PC611.2 PC612.2 PC613.2 PC614.2 PC615.2 PC616.2 PC617.2 PC618.2 PC700.2 PC701.2 PC702.2 PC704.2 PC705.2 PC707.2 PC708.2 PC709.2 PC710.2 PC711.2 PC712.2 PC713.2 PC800.2 PC802.2 PC803.2 PC804.2 PC805.2 PC806.2 PC807.2 PC808.2 PC809.2 PC900.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC908.2 PC1000.1 PC1001.2 PC1002.2 PC1003.2 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1011.2 PC1014.2 PC1016.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1030.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1100.1 PC1102.2 PC1103.2 PC1104.2 PC1105.2 PC1106.2 PC1107.2 PC1108.2 PC1109.2 PC1110.1 PC1112.2 PC1113.2 PC1114.2 PC1115.2 PC1116.2 PC1117.2 PC1118.2 PC1119.2 PC1120.2 PC1121.2 PC1150.1 PC1152.2 PC1153.2 PC1154.2 PC1155.2 PC1156.2 PC1157.2 PC1158.2 PC1159.2 PC1160.2 PC1161.2 PC1162.2 PC1163.2 PC1164.1 PC1166.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1205.2 PC1206.2 PC1207.2 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1215.2 PC1216.2 PC1217.2 PC1218.2 PC1219.2 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1225.2 PC1226.2 PC1227.2 PC1228.2 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1233.2 PC1234.2 PC1235.2 PC1236.2 PC1237.2 PC1238.2 PC1239.2 PC1240.2 PC1241.2 PC1242.2 PC1243.2 PC1244.2 PC1245.2 PC1246.2 PC1247.2 PC1248.2 PC1249.2 PC1250.2 PC1251.2 PC1252.2 PC1253.2 PC1254.2 PC1255.2 PC1256.2 PC1257.2 PC1258.2 PC1259.2 PC1260.2 PC1261.2 PC1262.2 PC1263.2 PC1264.2 PC1265.2 PC1266.2 PC1267.2 PC1268.2 PC1269.2 PC1270.2 PC1271.2 PC1272.2 PC1273.2 PC1274.2 PC1275.2 PC1276.2 PC1277.2 PC1278.2 PC1279.2 PC1280.2 PC1281.2 PC1282.2 PC1283.2 PC1284.2 PC1285.2 PC1286.2 PC1287.2 PC1288.2 PC1289.2 PC1290.2 PC1291.2 PC1292.2 PC1293.2 PC1294.2 PC1295.2 PC1296.2 PC1297.2 PC1298.2 PC1299.2 PC1300.2 PC1301.2 PC1302.2 PC1303.2 PC1304.2 PC1305.2 PC1306.2 PC1307.2 PC1308.2 PC1309.2 PC1310.2 PC1311.2 PC1312.2 PC1313.2 PC1314.2 PC1315.2 PC1316.2 PC1317.2 PC1318.2 PC1319.2 PC1320.2 PC1321.2 PC1322.2 PC1323.2 PC1324.2 PC1325.2 PC1326.2 PC1327.2 PC1328.2 PC1329.2 PC1330.2 PC1331.2 PC1332.2 PC1333.2 PC1334.2 PC1335.2 PC1336.2 PC1337.2 PC1338.2 PC1339.2 PC1340.2 PC1341.2 PC1342.2 PC1343.2 PC1344.2 PC1345.2 PC1346.2 PC1347.2 PC1348.2 PC1349.2 PC1350.2 PC1351.2 PC1352.2 PC1353.2 PC1354.2 PC1355.2 PC1356.2 PC1357.2 PC1358.2 PC1359.2 PC1360.2 PC1361.2 PC1362.2 PC1363.2 PC1364.2 PC1365.2 PC1366.2 PC1367.2 PC1368.2 PC1369.2 PC1370.2 PC1371.2 PC1372.2 PC1373.2 PC1374.2 PC1375.2 PC1376.2 PC1377.2 PC1378.2 PC1379.2 PC1380.2 PC1381.2 PC1382.2 PC1383.2 PC1384.2 PC1385.2 PC1386.2 PC1387.2 PC1400.2 PC1401.2 PC1402.2 PC1403.2 PC1404.2 PC1405.2 PC1406.2 PC1408.2 PC1409.2 PC1410.2 PC1411.2 PC1412.2 PC1413.2 PC1414.2 PC1415.2 PC1416.2 PC1417.2 PC1418.2 PC1419.2 PC1420.2 PC1500.2 PC1501.2 PC1502.2 PC1503.2 PC1504.2 PC1505.2 PC1506.2 PC1508.2 PC1509.2 PC1510.2 PC1511.2 PC1512.2 PC1513.2 PC1514.2 PC1515.2 PC1516.2 PC1517.2 PC1518.2 PC1519.2 PC1520.2 PC1529.2 PD104.1 PD105.1 PH1000.1 PH1004.2 PQ106.3 PQ108.3 PQ109.1 PQ109.4 PQ117.1 PQ117.4 PQ118.3 PQ119.3 PQ120.1 PQ120.4 PQ121.1 PQ121.4 PQ122.4 PQ125.1 PQ125.4 PQ126.3 PQ127.1 PQ127.4 PQ129.1 PQ129.4 PQ134.1 PQ134.4 PQ136.1 PQ136.4 PQ149.1 PQ149.4 PQ151.1 PQ151.4 PQ156.3 PQ157.3 PQ300.3 PQ302.3 PQ302.4 PQ302.5 PQ307.3 PQ307.4 PQ307.5 PR102.2 PR153.2 PR166.2 PR172.2 PR176.2 PR177.2 PR178.1 PR179.1 PR218.2 PR219.2 PR228.2 PR229.2 PR266.2 PR269.2 PR272.2 PR275.2 PR277.1 PR307.2 PR320.2 PR322.2 PR326.2 PR331.2 PR333.2 PR334.1 PR335.2 PR340.2 PR509.2 PR605.2 PR606.2 PR608.2 PR610.2 PR704.2 PR705.2 PR707.2 PR804.2 PR904.2 PR1000.1 PR1006.1 PR1010.1 PR1013.2 PR1014.2 PR1015.2 PR1016.2 PR1023.2 PR1035.2 PR1043.2 PR1044.2 PR1402.2 PR1406.2 PR1407.2 PR1413.2 PR1417.2 PR1418.2 PR1422.2 PR1502.2 PR1507.2 PR1508.2 PR1513.2 PR1517.2 PR1518.2 PR1526.2 PR1527.2 PU101.2 PU300.33 PU301.3 PU500.7 PU500.8 PU500.18 PU500.21 PU501.7 PU501.8 PU501.18 PU501.21 PU600.4 PU600.9 PU600.15 PU700.7 PU700.8 PU700.18 PU700.21 PU800.6 PU800.8 PU800.15 PU800.16 PU800.17 PU900.6 PU900.8 PU900.15 PU900.16 PU900.17 PU1000.49 PU1100.7 PU1100.11 PU1101.7 PU1101.11 PU1150.7 PU1150.11 PU1151.7 PU1151.11 PU1400.6 PU1400.15 PU1400.16 PU1400.17 PU1401.6 PU1401.15 PU1401.16 PU1401.17 PU1500.15 PU1500.16 PU1500.17 PU1501.15 PU1501.16 PU1501.17 QE2.1 QE2.4 QE10.3 QE11.1 QE11.4 QR1.3 R13.2 R16.1 R17.2 R22.2 R45.1 R53.2 R54.1 R62.2 R63.2 R76.2 R85.1 R87.1 R88.1 R89.2 R96.1 R99.1 R165.2 R166.2 R183.2 R184.2 R186.1 R211.2 R213.2 R214.1 R239.2 R240.2 R270.1 R5744.2 R5745.1 R5748.1 R5749.2 R5750.1 R5751.2 R5756.2 R5757.1 R5760.2 R5761.2 R5768.2 R5769.2 R5783.1 R5784.1 R5785.1 R5789.2 R5790.1 R5793.2 R5794.1 R5795.2 R5796.1 R5800.2 R5802.1 R5803.2 R5805.2 R5812.2 R5815.1 R5834.1 R5839.2 RA7.2 RA12.2 RA23.2 RA28.1 RA29.1 RA31.1 RA32.1 RA34.1 RA36.1 RA38.2 RA40.1 RA46.2 RA47.2 RA48.2 RA49.2 RA66.2 RC2.1 RC4.1 RC6.1 RC9.2 RC10.2 RC11.2 RC12.2 RC13.2 RC47.2 RC48.2 RC49.2 RC57.2 RC76.2 RC77.1 RC92.2 RC106.2 RC107.2 RC108.2 RC109.2 RC116.2 RC120.1 RC121.1 RC122.1 RC123.1 RC124.2 RC151.2 RC161.2 RC164.2 RC165.2 RC217.2 RC223.2 RC244.2 RC257.2 RC258.2 RC381.1 RC391.1 RD1.2 RD2.2 RD3.2 RD4.2 RD5.2 RD6.2 RD7.2 RD8.2 RD11.2 RD12.2 RD17.2 RD18.2 RD19.2 RD20.2 RE5.2 RE7.2 RE8.2 RE9.2 RE29.2 RE154.2 RE155.2 RE157.2 RE159.2 RE160.2 RE161.2 RE162.2 RE164.2 RE176.2 RE199.2 RE205.2 RE234.1 RE250.1 RE254.2 RE255.1 RE260.2 RE282.2 RE288.2 RH52.1 RH54.1 RH56.1 RH58.1 RH60.1 RH63.1 RH68.2 RH69.2 RH70.2 RH72.2 RH77.2 RH85.1 RH88.1 RH89.1 RH90.2 RPE6.5 RPE6.6 RPE6.7 RPE6.8 RR8.1 RT7.1 RT9.1 RT18.1 RT21.1 RT23.2 RT32.1 RT33.1 RT34.1 RT35.1 RT36.1 RT37.1 RT38.1 RT39.1 RT40.1 RT41.1 RT42.2 RT43.1 RT53.2 RT54.2 RT55.2 RT56.2 RT59.2 RT60.2 RT61.2 RT62.2 RT67.2 RT68.2 RT80.1 RT81.1 RT82.1 RT83.1 RT95.2 RT96.2 RT97.2 RT99.1 RZ1.2 SW1.4 SW1.5 SW2.3 SW2.4 SW3.2 SW3.4 U1.4 U4.2 U5.49 U6.19 U6.20 U6.24 U6.33 U6.34 U6.39 U6.45 U6.46 U6.53 U6.54 U6.57 U7.9 U7.16 U7.23 U7.32 U7.33 U10.5 U11.11 U11.15 U12.11 U12.15 U13.11 U13.15 U14.11 U14.15 U16.3 U19.A1 U19.B8 U19.D8 U19.E5 U19.E6 U19.E7 U19.E8 U19.F5 U19.F6 U19.F7 U19.F8 U19.G5 U19.G6 U19.G7 U19.G8 U19.H4 U19.H5 U19.H8 U19.L1 U20.A1 U20.B8 U20.D8 U20.E5 U20.E6 U20.E7 U20.E8 U20.F5 U20.F6 U20.F7 U20.F8 U20.G5 U20.G6 U20.G7 U20.G8 U20.H4 U20.H5 U20.H8 U20.L1 U21.A1 U21.B8 U21.D8 U21.E5 U21.E6 U21.E7 U21.E8 U21.F5 U21.F6 U21.F7 U21.F8 U21.G5 U21.G6 U21.G7 U21.G8 U21.H4 U21.H5 U21.H8 U21.L1 U22.5 U24.B4 U26.1 U30.41 U31.5 UC2.3 UC4.3 UC5.3 UC6.3 UC7.3 UC8.3 UC9.3 UC10.3 UCPU1.A5 UCPU1.A67 UCPU1.A70 UCPU1.AA2 UCPU1.AA4 UCPU1.AA65 UCPU1.AA68 UCPU1.AB8 UCPU1.AB15 UCPU1.AB16 UCPU1.AB18 UCPU1.AB21 UCPU1.AD8 UCPU1.AD13 UCPU1.AD16 UCPU1.AD19 UCPU1.AD20 UCPU1.AD21 UCPU1.AD62 UCPU1.AE64 UCPU1.AE65 UCPU1.AE66 UCPU1.AE67 UCPU1.AE68 UCPU1.AE69 UCPU1.AF1 UCPU1.AF2 UCPU1.AF4 UCPU1.AF10 UCPU1.AF15 UCPU1.AF17 UCPU1.AF63 UCPU1.AG16 UCPU1.AG17 UCPU1.AG18 UCPU1.AG19 UCPU1.AG20 UCPU1.AG21 UCPU1.AG71 UCPU1.AH6 UCPU1.AH13 UCPU1.AH63 UCPU1.AH64 UCPU1.AH67 UCPU1.AJ4 UCPU1.AJ15 UCPU1.AJ18 UCPU1.AJ20 UCPU1.AK8 UCPU1.AK11 UCPU1.AK16 UCPU1.AK18 UCPU1.AK21 UCPU1.AK22 UCPU1.AK27 UCPU1.AK63 UCPU1.AK68 UCPU1.AK69 UCPU1.AL2 UCPU1.AL4 UCPU1.AL28 UCPU1.AL32 UCPU1.AL35 UCPU1.AL38 UCPU1.AL45 UCPU1.AL48 UCPU1.AL52 UCPU1.AL55 UCPU1.AL58 UCPU1.AL64 UCPU1.AL65 UCPU1.AL66 UCPU1.AM8 UCPU1.AM13 UCPU1.AM21 UCPU1.AM25 UCPU1.AM27 UCPU1.AM43 UCPU1.AM45 UCPU1.AM46 UCPU1.AM55 UCPU1.AM60 UCPU1.AM61 UCPU1.AM68 UCPU1.AM71 UCPU1.AN20 UCPU1.AN23 UCPU1.AN28 UCPU1.AN30 UCPU1.AN32 UCPU1.AN33 UCPU1.AN35 UCPU1.AN37 UCPU1.AN38 UCPU1.AN40 UCPU1.AN42 UCPU1.AN58 UCPU1.AN63 UCPU1.AP10 UCPU1.AP18 UCPU1.AP20 UCPU1.AP23 UCPU1.AP28 UCPU1.AP32 UCPU1.AP35 UCPU1.AP38 UCPU1.AP42 UCPU1.AP58 UCPU1.AP63 UCPU1.AP68 UCPU1.AP70 UCPU1.AR5 UCPU1.AR8 UCPU1.AR11 UCPU1.AR15 UCPU1.AR16 UCPU1.AR20 UCPU1.AR23 UCPU1.AR28 UCPU1.AR35 UCPU1.AR42 UCPU1.AR43 UCPU1.AR45 UCPU1.AR46 UCPU1.AR48 UCPU1.AR50 UCPU1.AR52 UCPU1.AR53 UCPU1.AR55 UCPU1.AR58 UCPU1.AR63 UCPU1.AT2 UCPU1.AT4 UCPU1.AT20 UCPU1.AT23 UCPU1.AT28 UCPU1.AT35 UCPU1.AT42 UCPU1.AT56 UCPU1.AT58 UCPU1.AT63 UCPU1.AT68 UCPU1.AT71 UCPU1.AU10 UCPU1.AU15 UCPU1.AU20 UCPU1.AU32 UCPU1.AU38 UCPU1.AV1 UCPU1.AV68 UCPU1.AV69 UCPU1.AV70 UCPU1.AV71 UCPU1.AW6 UCPU1.AW8 UCPU1.AW10 UCPU1.AW12 UCPU1.AW14 UCPU1.AW16 UCPU1.AW18 UCPU1.AW21 UCPU1.AW23 UCPU1.AW26 UCPU1.AW28 UCPU1.AW30 UCPU1.AW32 UCPU1.AW34 UCPU1.AW36 UCPU1.AW38 UCPU1.AW41 UCPU1.AW43 UCPU1.AW45 UCPU1.AW47 UCPU1.AW49 UCPU1.AW51 UCPU1.AW53 UCPU1.AW55 UCPU1.AW57 UCPU1.AW60 UCPU1.AW62 UCPU1.AW64 UCPU1.AW66 UCPU1.AY3 UCPU1.AY66 UCPU1.AY71 UCPU1.B10 UCPU1.B14 UCPU1.B18 UCPU1.B22 UCPU1.B30 UCPU1.B34 UCPU1.B39 UCPU1.B44 UCPU1.B48 UCPU1.B53 UCPU1.B58 UCPU1.B62 UCPU1.B66 UCPU1.B71 UCPU1.BA1 UCPU1.BA2 UCPU1.BA6 UCPU1.BA10 UCPU1.BA14 UCPU1.BA18 UCPU1.BA23 UCPU1.BA28 UCPU1.BA32 UCPU1.BA36 UCPU1.BA41 UCPU1.BA45 UCPU1.BA49 UCPU1.BA53 UCPU1.BA57 UCPU1.BA62 UCPU1.BA66 UCPU1.BA71 UCPU1.BB6 UCPU1.BB18 UCPU1.BB26 UCPU1.BB30 UCPU1.BB34 UCPU1.BB38 UCPU1.BB43 UCPU1.BB55 UCPU1.BB60 UCPU1.BB64 UCPU1.BB67 UCPU1.BB70 UCPU1.C1 UCPU1.C5 UCPU1.C25 UCPU1.D6 UCPU1.D10 UCPU1.D11 UCPU1.D14 UCPU1.D18 UCPU1.D22 UCPU1.D25 UCPU1.D26 UCPU1.D30 UCPU1.D34 UCPU1.D39 UCPU1.D44 UCPU1.D45 UCPU1.D47 UCPU1.D48 UCPU1.D53 UCPU1.D58 UCPU1.D62 UCPU1.D66 UCPU1.D69 UCPU1.E6 UCPU1.E11 UCPU1.E15 UCPU1.E18 UCPU1.E21 UCPU1.E46 UCPU1.E50 UCPU1.E53 UCPU1.E56 UCPU1.E65 UCPU1.E71 UCPU1.F1 UCPU1.F2 UCPU1.F4 UCPU1.F8 UCPU1.F13 UCPU1.F22 UCPU1.F23 UCPU1.F27 UCPU1.F28 UCPU1.F32 UCPU1.F33 UCPU1.F35 UCPU1.F37 UCPU1.F38 UCPU1.F40 UCPU1.F42 UCPU1.F68 UCPU1.G5 UCPU1.G6 UCPU1.G10 UCPU1.G22 UCPU1.G43 UCPU1.G45 UCPU1.G48 UCPU1.G52 UCPU1.G55 UCPU1.G58 UCPU1.G60 UCPU1.G63 UCPU1.G66 UCPU1.H15 UCPU1.H18 UCPU1.H71 UCPU1.J8 UCPU1.J11 UCPU1.J13 UCPU1.J25 UCPU1.J28 UCPU1.J32 UCPU1.J35 UCPU1.J38 UCPU1.J42 UCPU1.K16 UCPU1.K18 UCPU1.K22 UCPU1.K61 UCPU1.K63 UCPU1.K64 UCPU1.K65 UCPU1.K66 UCPU1.K67 UCPU1.K68 UCPU1.K70 UCPU1.K71 UCPU1.L2 UCPU1.L4 UCPU1.L8 UCPU1.L11 UCPU1.L16 UCPU1.L17 UCPU1.L18 UCPU1.L20 UCPU1.N6 UCPU1.N10 UCPU1.N13 UCPU1.N19 UCPU1.N21 UCPU1.N65 UCPU1.N68 UCPU1.P17 UCPU1.P19 UCPU1.P20 UCPU1.P21 UCPU1.R6 UCPU1.R13 UCPU1.T2 UCPU1.T4 UCPU1.T15 UCPU1.T17 UCPU1.T18 UCPU1.T21 UCPU1.U10 UCPU1.U63 UCPU1.U64 UCPU1.U66 UCPU1.U67 UCPU1.U69 UCPU1.U70 UCPU1.V16 UCPU1.V17 UCPU1.V18 UCPU1.W6 UCPU1.W9 UCPU1.W13 UCPU1.Y17 UCPU1.Y19 UCPU1.Y20 UCPU1.Y21 UD41.B2 UD41.B5 UD41.B6 UD41.B12 UD41.C3 UD41.C5 UD41.C6 UD41.D3 UD41.D8 UD41.D12 UD41.E4 UD41.E5 UD41.E6 UD41.F4 UD41.F5 UD41.F6 UD41.F12 UD41.G3 UD41.G4 UD41.G6 UD41.G8 UD41.G9 UD41.H2 UD41.H10 UD41.J4 UD41.J12 UD41.K2 UD41.K10 UD41.L6 UD41.L8 UD41.L9 UD41.M4 UD41.M5 UD41.M6 UD41.M12 UD41.N4 UD41.N5 UD41.N6 UD41.P3 UD41.P8 UD41.P12 UD41.R4 UD41.R5 UD41.R6 UD41.T2 UD41.T3 UD41.T4 UD41.T5 UD41.T6 UD41.T12 UD42.B2 UD42.B5 UD42.B6 UD42.B12 UD42.C3 UD42.C5 UD42.C6 UD42.D3 UD42.D8 UD42.D12 UD42.E4 UD42.E5 UD42.E6 UD42.F4 UD42.F5 UD42.F6 UD42.F12 UD42.G3 UD42.G4 UD42.G6 UD42.G8 UD42.G9 UD42.H2 UD42.H10 UD42.J4 UD42.J12 UD42.K2 UD42.K10 UD42.L6 UD42.L8 UD42.L9 UD42.M4 UD42.M5 UD42.M6 UD42.M12 UD42.N4 UD42.N5 UD42.N6 UD42.P3 UD42.P8 UD42.P12 UD42.R4 UD42.R5 UD42.R6 UD42.T2 UD42.T3 UD42.T4 UD42.T5 UD42.T6 UD42.T12 UD43.B2 UD43.B5 UD43.B6 UD43.B12 UD43.C3 UD43.C5 UD43.C6 UD43.D3 UD43.D8 UD43.D12 UD43.E4 UD43.E5 UD43.E6 UD43.F4 UD43.F5 UD43.F6 UD43.F12 UD43.G3 UD43.G4 UD43.G6 UD43.G8 UD43.G9 UD43.H2 UD43.H10 UD43.J4 UD43.J12 UD43.K2 UD43.K10 UD43.L6 UD43.L8 UD43.L9 UD43.M4 UD43.M5 UD43.M6 UD43.M12 UD43.N4 UD43.N5 UD43.N6 UD43.P3 UD43.P8 UD43.P12 UD43.R4 UD43.R5 UD43.R6 UD43.T2 UD43.T3 UD43.T4 UD43.T5 UD43.T6 UD43.T12 UD44.B2 UD44.B5 UD44.B6 UD44.B12 UD44.C3 UD44.C5 UD44.C6 UD44.D3 UD44.D8 UD44.D12 UD44.E4 UD44.E5 UD44.E6 UD44.F4 UD44.F5 UD44.F6 UD44.F12 UD44.G3 UD44.G4 UD44.G6 UD44.G8 UD44.G9 UD44.H2 UD44.H10 UD44.J4 UD44.J12 UD44.K2 UD44.K10 UD44.L6 UD44.L8 UD44.L9 UD44.M4 UD44.M5 UD44.M6 UD44.M12 UD44.N4 UD44.N5 UD44.N6 UD44.P3 UD44.P8 UD44.P12 UD44.R4 UD44.R5 UD44.R6 UD44.T2 UD44.T3 UD44.T4 UD44.T5 UD44.T6 UD44.T12 UE3.A6 UE3.A13 UE3.C4 UE3.E6 UE3.H4 UE5.3 UE6.3 UE7.3 UE8.3 UR1.33 UT2.A1 UT2.A6 UT2.A8 UT2.A10 UT2.A12 UT2.A14 UT2.A16 UT2.A18 UT2.A20 UT2.A22 UT2.AA22 UT2.AA23 UT2.AB1 UT2.AB2 UT2.AB6 UT2.AB8 UT2.AB10 UT2.AB12 UT2.AB14 UT2.AB16 UT2.AB18 UT2.AB20 UT2.AB22 UT2.AC1 UT2.AC2 UT2.AC6 UT2.AC8 UT2.AC10 UT2.AC12 UT2.AC14 UT2.AC16 UT2.AC18 UT2.AC20 UT2.AC22 UT2.B1 UT2.B2 UT2.B6 UT2.B8 UT2.B10 UT2.B12 UT2.B14 UT2.B16 UT2.B18 UT2.B20 UT2.B22 UT2.C22 UT2.C23 UT2.D5 UT2.D6 UT2.D8 UT2.D9 UT2.D11 UT2.D12 UT2.D13 UT2.D15 UT2.D16 UT2.D18 UT2.E4 UT2.E5 UT2.E6 UT2.E8 UT2.E9 UT2.E11 UT2.E15 UT2.E16 UT2.E22 UT2.E23 UT2.F5 UT2.F6 UT2.F9 UT2.F16 UT2.F20 UT2.G22 UT2.G23 UT2.H1 UT2.H2 UT2.H5 UT2.H8 UT2.H12 UT2.H13 UT2.H15 UT2.H16 UT2.H20 UT2.J5 UT2.J8 UT2.J12 UT2.J13 UT2.J15 UT2.J18 UT2.J19 UT2.J20 UT2.J22 UT2.J23 UT2.K1 UT2.K2 UT2.L5 UT2.L13 UT2.L15 UT2.L20 UT2.L22 UT2.L23 UT2.M1 UT2.M2 UT2.M5 UT2.M11 UT2.M12 UT2.M19 UT2.M20 UT2.N5 UT2.N8 UT2.N9 UT2.N11 UT2.N12 UT2.N13 UT2.N15 UT2.N20 UT2.N22 UT2.N23 UT2.P1 UT2.P2 UT2.R5 UT2.R18 UT2.R19 UT2.R20 UT2.R22 UT2.R23 UT2.T1 UT2.T2 UT2.T5 UT2.T6 UT2.T8 UT2.T9 UT2.T13 UT2.T15 UT2.T16 UT2.T18 UT2.T20 UT2.U22 UT2.U23 UT2.V5 UT2.V6 UT2.V8 UT2.V9 UT2.V15 UT2.V16 UT2.V20 UT2.W5 UT2.W6 UT2.W8 UT2.W9 UT2.W13 UT2.W18 UT2.W20 UT2.W22 UT2.W23 UT2.Y9 UT2.Y13 UT2.Y20 UT3.4 UT3.9 UT4.4 UT4.9 UT6.4 UT6.9 UZ1.5 UZ2.2 UZ3.5 UZ4.5 UZ5.5 WL1.6 WL1.17 WL1.20 WL1.23 WL1.26 WL1.32 WL1.35 WL1.38 WL1.41 WL1.62 WL1.68 WL1.71 WL1.74 WL1.75 WL1.76 WL1.77 WL1.78 WL1.79 WL1.80 WL1.81 WL1.82 WL1.83 WL1.84 WL1.85 WL1.86 WL1.87 WL1.88 WL1.89 WL1.90 WL1.91 WL1.92 WL1.93 WL1.94 WL1.95 WL1.96 WL1.97 WL1.98 WL1.99 WL1.100 WL1.101 WL1.102 WL1.103 WL1.104 WL1.105 WL1.106 WL1.107 WL1.108 YC1.2 YC1.4 YC3.2 YC3.4 YT1.2 YT1.4
VBUS1_ECOK: PR114.2 PR138.1 UE3.F13
VBUS2_ECOK: PR135.2 PR145.1 UE3.C13
VBUS3_ECOK: PR195.1 PR267.2 UE3.E12
VBUSSENSE: RC49.1 UCPU1.AG4
VCC0V9_LVR_OUT: C1105.1 C1106.1 CT85.1 CT86.1 CT87.1 CT88.1 UT2.F18 UT2.H11 UT2.H18 UT2.J11
VCC0V9_SVR: C1101.1 C1102.1 CT72.1 CT73.1 CT74.1 CT75.1 CT76.1 CT77.1 CT78.1 CT79.1 CT80.1 CT81.1 LT1.2 UT2.E12 UT2.E13 UT2.F11 UT2.F12 UT2.F13 UT2.F15 UT2.J9 UT2.L9 UT2.M9
VCC1V8A_TBT_LDO_A: CT94.1 RT52.2 U19.K1
VCC1V8A_TBT_LDO_B: CT97.1 RT58.2 U20.K1
VCC1V8A_TBT_LDO_C: CT100.1 RT64.2 U21.K1
VCC1V8D_TBT_LDO_A: CT95.1 U19.A2
VCC1V8D_TBT_LDO_B: CT98.1 U20.A2
VCC1V8D_TBT_LDO_C: CT101.1 U21.A2
VCC3V3_TBT_LDO_A: C142.1 C1087.1 CT51.1 R167.1 R168.1 R169.1 R170.1 R177.1 R179.1 R185.1 R5747.1 R5752.1 R5767.1 RT44.1 RT45.1 RT46.1 RT47.1 RT51.2 U19.G1 UT3.8 UT4.8
VCC3V3_TBT_LDO_B: C155.1 R205.1 R207.1 R212.1 R5759.1 R5762.1 R5782.1 RT57.2 U20.G1
VCC3V3_TBT_LDO_C: C168.1 C1088.1 R223.1 R224.1 R225.1 R226.1 R233.1 R235.1 R5792.1 R5814.1 RT63.2 U21.G1 UT6.8
VCC3V3_TBT_SX_A: C141.1 U19.H2
VCC3V3_TBT_SX_B: C154.1 U20.H2
VCC3V3_TBT_SX_C: C167.1 U21.H2
VCC_3V3_PCIE: C1109.1 C1110.1 CT89.1 UT2.L16
VCC_3V3_USB2: C1111.1 C1112.1 CT90.1 UT2.J16
VCC_EDRAM_SENSE: PR1509.2 UCPU1.AC63
VCC_EOPIO_SENSE: PR1520.2 UCPU1.AL63
VCC_SENSE: PC1034.2 PR1046.2 RC150.2 UCPU1.E32
VCCGT_SENSE: PC1009.1 PR1027.1 RC160.2 UCPU1.J70
VCCHDA: CC95.2 RA65.2 UCPU1.AJ19
VCCIO_SENSE: PR1409.2 RC163.2 UCPU1.AM23
VCCSA_SENSE: PC1015.2 PR1029.2 RC166.2 UCPU1.H20
VCCST_EN: RE7.1 UC6.4 UZ3.4
VCCST_PWRGD: RC86.2 UCPU1.B65
VCCSTG_EN: PR1401.1 RZ1.1 RZ2.1 UC4.4 UZ4.4
VDD: PC335.2 PR308.2 PR319.1 PU300.18
VIN_1V_PRIM: PC1513.1 PC1514.1 PC1517.1 PC1518.1 PL1502.2 PU1501.10 PU1501.11 PU1501.12
VIN_PRIM: PC1413.1 PC1414.1 PC1417.1 PC1418.1 PL1402.2 PU1401.10 PU1401.11 PU1401.12
VIN_VCC_EDRAM: PC1501.1 PC1502.1 PC1508.1 PC1509.1 PL1500.2 PU1500.10 PU1500.11 PU1500.12
VIN_VCCIO: PC1401.1 PC1402.1 PC1408.1 PC1409.1 PL1400.2 PU1400.10 PU1400.11 PU1400.12
VSS_EDRAM_SENSE: PR1510.2 UCPU1.AE63
VSS_EOPIO_SENSE: PR1521.2 UCPU1.AJ62
VSS_F65_G65: RC391.2 UCPU1.F65 UCPU1.G65
VSS_SENSE: PC1036.1 PU1000.18 RC151.1 UCPU1.E33
VSSGT_SENSE: PC1014.1 PU1000.6 RC161.1 UCPU1.J69
VSSIO_SENSE: RC165.1 UCPU1.AM22
VSSSA_SENSE: PC1016.1 PU1000.31 RC164.1 UCPU1.H21
32KHZ_OUT: CE57.1 UE3.F3
+BAT_TABLET: PC127.1 PC340.1 PL102.2 PL103.2 PL105.2 PQ304.5 PR102.1 PR330.2
+BATT: JT101.9 JT101.10 JT101.11 JT101.12 PC126.1 PC132.2 PL102.1 PL103.1 PL105.1
+CHG_SRC_20V: PC302.1 PC303.1 PC304.1 PC305.1 PC306.1 PC307.1 PC308.1 PC309.1 PC310.1 PL302.2 PQ302.2
+CHG_VIN_20V: PC111.1 PC124.1 PC291.1 PC301.1 PD108.1 PD109.1 PD110.1 PD111.2 PD300.2 PQ101.1 PQ101.2 PQ101.3 PQ104.3 PQ114.1 PQ114.2 PQ114.3 PQ115.3 PQ150.3 PQ155.1 PQ155.2 PQ155.3 PR101.1 PR103.1 PR129.1 PR130.1 PR261.1 PR268.1 PR300.1 PR303.1 PR305.1 PT100.1(TP-1)
+EC_DEBUG_VCC: JDEG1.1 RE200.2
+INV_PWR_SRC: C1049.1 C1052.1 C1053.1 C1054.1 JCAM1.3 JCAM1.4 JCAM1.5 JCAM1.6 R253.2 U24.A2
+INV_PWR_SRC_IN+: C312.2 R251.2 R253.1 U22.9 U24.A3
+LCDVDD: C104.1 C1018.1 C1065.1 C1066.1 C1067.1 JEDP1.16 JEDP1.17 JEDP1.18 JEDP1.19 R97.2 RC372.1 RC373.1 RR21.1 U24.B1
+LCDVDD_IN+: R97.1 U24.A1 UZ2.1
+ODR_PWR: CR1.1 CR2.1 JCR1.4 UR1.12
+PECI_VREF: CE56.1 RE147.2 UE3.J11
+RTC_CELL_VBAT: CE42.1 RE106.1 UE3.A2
+RTCBATT: JRTC1.1 RTCR1.2
+RTCVCC: CC72.1 CC73.1 CH3.1 CLRP1.1 RA3.2 RC68.2 RC71.2 RC78.2 RE106.2 RE137.2 RE142.2 RE184.1 RE244.2 RTCR1.1 RTCR2.2 UCPU1.AK19 UCPU1.BB14
+SD_VDD2: CR3.1 CR4.1 JCR1.15 UR1.13
+TPM_LPM: C31.1 CA82.1 RC178.2 RC179.2 U7.8
+TPM_VSB: C1081.1 C1082.1 RC382.2 U7.1
+V_DDR_REF_CA: CD79.1 RD10.1 UCPU1.AY67
+V_DDR_REFA_R: CD80.1 RD15.1 UCPU1.AY68
+V_DDR_REFB_R: CD81.1 RD16.1 UCPU1.BA67
+VR_CAP: CE64.1 UE3.C10 UE3.J1
+VREFCA: CD36.1 CD38.1 CD76.1 CD78.1 RD9.2 RD10.2 RD11.1 UD41.H4 UD42.H4 UD43.H4 UD44.H4
+VREFDQ_A: CD35.1 CD37.1 RD13.2 RD15.2 RD17.1 UD41.J11 UD42.J11
+VREFDQ_B: CD75.1 CD77.1 RD14.2 RD16.2 RD18.1 UD43.J11 UD44.J11
AC1_DISC#: PR123.1 PR201.1 PR321.1 U19.G11
AC2_DISC#: PR136.1 PR144.1 PR343.1 U20.G11
AC3_DISC#: PR196.1 PR278.1 PR344.1 U21.G11
AC_DIS: PQ300.2 PR340.1 UE3.C6
AC_DIS#: PC140.1 PQ122.3 PR170.2 PR174.2 PR192.2 PR200.2 PR202.1 PR230.2
AC_DISC#: PR230.1 UE3.E13
AC_DISC_OUT#: PR208.2 PR332.1
AC_PRESENT: RC82.1 UCPU1.AY15 UE3.K8
ACAV_IN: PR331.1 PR345.2 UE3.C7
ACAV_IN1: PQ300.1 PR319.2 PR320.1 PR346.1 PU300.24
ACAV_IN_NB: T52.1(TP-1) UE3.N6
ADDR: R48.2 R53.1 U30.3
AK52: R279.1 UCPU1.AK52
ALW_PWRGD_3V_5V: PQ126.2 PR151.1 PR502.2 PR506.1 PU500.9
ALWON: PR503.1 PR510.1 UE3.A5
AMP_ADDR_SEL: RA30.2 RA38.1 U6.18
AMP_I2C_CLK: RA10.2 RA33.2 U5.7
AMP_I2C_CLK_R: RA26.1 RA33.1 RA64.1 U6.8
AMP_I2C_DAT: RA9.2 RA27.2 U5.6
AMP_I2C_DAT_R: RA25.1 RA27.1 RA63.1 U6.7
AMP_I2S_BCLK: RA19.1 U5.10
AMP_I2S_BCLK_R: CA35.1 RA19.2 U6.10
AMP_I2S_IN: CA33.1 RA17.1 U5.8
AMP_I2S_IN_R: RA17.2 U6.14
AMP_I2S_LRCK: RA21.1 U5.12
AMP_I2S_LRCK_R: CA37.1 RA21.2 U6.11
AMP_I2S_MCLK: RA20.1 U5.11
AMP_I2S_MCLK_R: CA36.1 RA20.2 U6.9
AMP_I2S_OUT: RA18.1 U5.9
AMP_I2S_OUT_R: CA34.1 RA18.2 U6.12
AMP_MUTE#: D7.2 D8.2 D9.2 RA8.1 RA12.1 U6.15
AMP_OUT_L+: CA63.1 CA69.1 LA6.1 U6.52
AMP_OUT_L-: CA62.1 CA68.1 LA5.1 U6.55
AMP_OUT_P_L-: CA72.1 LA5.2 RA35.1 RA44.1
AMP_OUT_P_L-_R: RA28.2 RA35.2 U6.25
AMP_OUT_P_R-: CA74.1 LA7.2 RA41.1 RA45.1
AMP_OUT_P_R-_R: RA32.2 RA41.2 U6.28
AMP_OUT_R+: CA65.1 CA71.1 LA8.1 U6.44
AMP_OUT_R-: CA64.1 CA70.1 LA7.1 U6.47
AUD_PWR_EN: R86.1 R89.1 U12.5 U14.3 U14.5 UCPU1.AY5
AUX_EN_WOWL: D75.3 RE291.1 UE3.D3
AUX_EN_WOWL_R: D75.1 R96.2 RE290.2 RE291.2 U13.3
B+: C1051.1 C1120.1 PC315.1 PC316.1 PC317.1 PC318.1 PC319.1 PC320.1 PC321.1 PC324.1 PC325.1 PC326.1 PC329.1 PD301.2 PL500.1 PL502.1 PL503.1 PL600.1 PL700.1 PL800.1 PL900.1 PL1101.1 PL1102.1 PL1106.1 PL1108.1 PL1400.1 PL1402.1 PL1500.1 PL1502.1 PQ307.2 PR304.1 PR318.2 PR323.1 PR508.1 R18.1 R116.1 R5826.1 U22.3 U22.4 U31.3 U31.4
B+_1.0V: PC701.1 PC702.1 PC704.1 PC705.1 PL700.2 PU700.2 PU700.3 PU700.4 PU700.5
B+_3V: PC500.1 PC501.1 PC502.1 PC503.1 PL500.2 PU500.2 PU500.3 PU500.4 PU500.5
B+_5V: PC513.1 PC514.1 PC515.1 PC516.1 PC528.1 PC529.1 PL502.2 PL503.2 PU501.2 PU501.3 PU501.4 PU501.5
B+_AMP: CA38.1 CA39.1 CA40.1 CA41.1 CA42.1 CA43.1 CA44.1 CA45.1 CA46.1 CA50.1 CA51.1 CA52.1 CA58.1 CA59.1 CA60.1 CA61.1 R18.2 U6.1 U6.37 U6.42 U6.43 U6.48 U6.51 U6.56
B+_CAM: C1068.1 C1119.1 C1122.1 JCAM1.1 JCAM1.2 R6.2 R5826.2
B+_CAM_EN: RC389.2 RE260.1 RE261.1 U31.2
B+_CAM_F: C1121.2 R6.1 R5824.2 U31.9
BAT1_LED#: JKB1.9 UE3.D10
BAT2_LED#: JKB1.8 UE3.D11
BAT_LED#_LV1: LED1.1 R71.2
BAT_LED#_LV2: LED2.1 R70.2
BAT_LED#_LV3: LED3.1 R69.2
BAT_LED#_LV4: LED4.1 R68.2
BAT_LED#_LV5: LED5.1 R67.2
BATBTN#: C71.1 RE137.1 SW2.1 SW2.2 UE3.B5
BATT_LED#_LV1: Q4.3 RE287.1 UE3.F12
BATT_LED#_LV2: QH2.1 RE286.1 UE3.G10
BATT_LED#_LV3: QH2.4 RE283.1 UE3.H12
BATT_LED#_LV4: QH1.1 RE285.1 UE3.J7
BATT_LED#_LV5: QH1.4 RE284.1 UE3.M13
BATT_PRS#: JT101.6 PR157.1
BC_CLK_ECE1117: JKB1.7 UE3.D13
BC_DAT_ECE1117: JKB1.6 RE130.1 UE3.D12
BC_INT#_ECE1117: JKB1.5 UE3.E2
BEEP: RA2.1 UE3.L9
BIA_PWM_EC: D6.3 UE3.N1
BID_BC: RH84.1 RH85.2 UCPU1.U3
BL_PWMO: JCAM1.9 JEDP1.9
BOARD_ID: CE75.1 RE194.2 UE3.J13
BOT_MUX_N: ML7.4 U21.L7
BOT_MUX_N_R: D69.1 JUSBC3.B7 ML7.3
BOT_MUX_P: ML7.1 U21.K7
BOT_MUX_P_R: D71.1 JUSBC3.B6 ML7.2
BREATH_LED#: RE275.1 UE3.C11
BST_1.0V: PR701.1 PU700.1
BST_1.0V_R: PC703.1 PR701.2
BST_3V: PR500.1 PU500.1
BST_5V: PR505.1 PU501.1
BT_RADIO_DIS#: DZ3.1 RE133.1 UE3.C2
BT_RADIO_DIS#_R: DZ3.2 RC182.1 WL1.63
CAD_SNK: R49.1 R5812.1 RC394.2 U30.29
CAM_CBL_DET#: D72.1 JCAM1.12 RC114.1 UCPU1.AB11
CEXT: C70.2 R5808.2 U30.1
CFG0: RC120.2 T80.1(TP-1) UCPU1.E68
CFG0_1: RC256.1 T112.1(TP-1)
CFG1: RC121.2 UCPU1.B67
CFG1_1: JXDP1.11 T111.1(TP-1)
CFG2: T78.1(TP-1) UCPU1.D65
CFG2_1: JXDP1.15 T113.1(TP-1)
CFG3: RC122.2 UCPU1.D67
CFG3_1: JXDP1.17 T114.1(TP-1)
CFG4: RC123.2 T81.1(TP-1) UCPU1.E70
CFG4_1: JXDP1.27 T117.1(TP-1)
CFG5: T79.1(TP-1) UCPU1.C68
CFG5_1: JXDP1.29 T118.1(TP-1)
CFG6: T82.1(TP-1) UCPU1.D68
CFG6_1: JXDP1.33 T120.1(TP-1)
CFG7: T83.1(TP-1) UCPU1.C67
CFG7_1: JXDP1.35 T119.1(TP-1)
CFG8: T84.1(TP-1) UCPU1.F71
CFG8_1: JXDP1.10 T102.1(TP-1)
CFG9: T85.1(TP-1) UCPU1.G69
CFG9_1: JXDP1.12 T101.1(TP-1)
CFG10: T86.1(TP-1) UCPU1.F70
CFG10_1: JXDP1.16 T122.1(TP-1)
CFG11: T87.1(TP-1) UCPU1.G68
CFG11_1: JXDP1.18 T121.1(TP-1)
CFG12: JXDP1.28 UCPU1.H70
CFG13: T88.1(TP-1) UCPU1.G71
CFG13_1: JXDP1.30 T103.1(TP-1)
CFG14: JXDP1.34 UCPU1.H69
CFG15: T89.1(TP-1) UCPU1.G70
CFG15_1: JXDP1.36 T104.1(TP-1)
CFG16: JXDP1.6 UCPU1.E63
CFG17: JXDP1.4 UCPU1.F63
CFG18: JXDP1.24 UCPU1.E66
CFG19: JXDP1.22 UCPU1.F66
CFG_RCOMP: RC124.1 UCPU1.E60
CHG_ACIN: PC331.1 PR305.2 PR307.1 PU300.19
CHG_ADP: PC332.1 PR303.2 PU300.16
CHG_AMON: PR328.1 PU300.29
CHG_BGATE: PC339.1 PQ304.4 PU300.32
CHG_BST1: PR306.2 PU300.12
CHG_BST2: PC336.1 PU300.4
CHG_CLK: PR314.2 PU300.22
CHG_CMIN: PR334.2 PU300.20
CHG_COMP: PC348.1 PR327.1 PU300.28
CHG_CSIN: PC312.2 PC314.1 PR301.2 PU300.14
CHG_CSIP: PC312.1 PC313.1 PR302.2 PU300.15
CHG_CSON: PC346.2 PC347.1 PR324.2 PU300.1
CHG_CSOP: PC345.2 PC346.1 PR323.2 PU300.2
CHG_DAT: PR313.2 PU300.21
CHG_DCIN: PC333.2 PR309.2 PU300.17
CHG_LG1: PQ302.6 PU300.9
CHG_LG2: PQ307.6 PU300.7
CHG_LX1: PC330.2 PL301.1 PQ302.7 PR316.1 PU300.10
CHG_LX2: PL301.2 PQ307.7 PR311.1 PR317.1 PU300.6
CHG_PROCHOT#: PR209.2 PR315.2 PU300.23
CHG_PSYS: PR329.1 PU300.30
CHG_UG1: PQ302.1 PU300.11
CHG_UG2: PQ307.1 PU300.5
CHG_VBAT1: PC351.1 PR330.1 PU300.31
CHG_VDDP: PC334.1 PR308.1 PU300.8
CL_CLK: R24.1 UCPU1.G3
CL_CLK_R: R24.2 WL1.42
CL_DAT: R25.1 UCPU1.G2
CL_DAT_R: R25.2 WL1.43
CL_RST#: R26.1 UCPU1.G1
CL_RST#_R: R26.2 WL1.44
CLK0_PCIE_TBT: UCPU1.C42 UT2.V19
CLK0_PCIE_TBT#: UCPU1.D42 UT2.T19
CLK1_PCIE_WLAN: C37.1 UCPU1.A42 WL1.34
CLK1_PCIE_WLAN#: C36.1 UCPU1.B42 WL1.33
CLK_ITPXDP_N: JXDP1.42 RC60.2
CLK_ITPXDP_N_R: RC60.1 UCPU1.F43
CLK_ITPXDP_P: JXDP1.40 RC61.2
CLK_ITPXDP_P_R: RC61.1 UCPU1.E43
CLK_PCIE_MMI: UCPU1.E38 UR1.5
CLK_PCIE_MMI#: UCPU1.E40 UR1.6
CLK_PCIE_SSD: JNGFF1.55 UCPU1.C40
CLK_PCIE_SSD#: JNGFF1.53 UCPU1.D40
CLK_SMB: JT101.8 PR152.1
CLK_TP_SIO: C123.1 JTP1.8 MD1.3 RE235.2 UE3.E10
CLKREQ_PCIE#0: RC58.2 RT71.2 UCPU1.AR10
CLKREQ_PCIE#0_N: RT10.2 RT71.1 UT2.AC5
CLKREQ_PCIE#1: RC62.2 UCPU1.AT7 WL1.30
CLKREQ_PCIE#3: JNGFF1.52 RC65.2 UCPU1.AT10
CLKREQ_PCIE#4: RC67.2 RT433.1 UCPU1.AU8
CLKREQ_PCIE#5: RC70.2 UCPU1.AU7 UR1.2
CLKRUN#: RC16.2 UCPU1.AW11
CODEC_MUTE#: D9.1 RA15.2 U5.13
CORE_VID0: PR1419.1 UCPU1.AN11
CORE_VID1: PR1420.1 UCPU1.AN13
CPU_DDI1_AUXN: CT26.2 UCPU1.G50
CPU_DDI1_AUXN_C: CT26.1 UT2.W11
CPU_DDI1_AUXP: CT25.2 UCPU1.F50
CPU_DDI1_AUXP_C: CT25.1 UT2.Y11
CPU_DDI2_AUXN: CT36.2 UCPU1.E48
CPU_DDI2_AUXN_C: CT36.1 UT2.W12
CPU_DDI2_AUXP: CT35.2 UCPU1.F48
CPU_DDI2_AUXP_C: CT35.1 UT2.Y12
CPU_DP1_CTRL_CLK: RC1.1 RT91.2 UCPU1.L13
CPU_DP1_CTRL_DATA: RC3.1 RT92.2 UCPU1.L12
CPU_DP1_HPD: RC4.2 UCPU1.L9 UT2.AA2
CPU_DP2_CTRL_CLK: RC5.1 RT93.2 UCPU1.N7
CPU_DP2_CTRL_DATA: RC7.1 RT94.2 UCPU1.N8
CPU_DP2_HPD: RC6.2 UCPU1.L7 UT2.Y6
CPU_POPIRCOMP: RC106.1 UCPU1.AT16
CPU_XDP_PRDY#: JXDP1.5 UCPU1.D56
CPU_XDP_PREQ#: JXDP1.3 RC230.1 UCPU1.D61
CPU_XDP_TCK: RC228.1 RC244.1 UCPU1.B61
CPU_XDP_TDI: RC229.1 RC240.1 UCPU1.D60
CPU_XDP_TDO: RC227.1 RC242.2 UCPU1.A61
CPU_XDP_TMS: RC231.1 RC239.1 UCPU1.C60
CPU_XDP_TRST#: RC217.1 RC232.1 UCPU1.B59
CSI2_COMP: RC9.1 UCPU1.E13
DAT_SMB: JT101.7 PR154.1
DAT_TP_SIO: C124.1 JTP1.7 MD1.2 RE236.2 UE3.C12
DBC_EN: JEDP1.40 UCPU1.AP7
DCI_CLK: R51.2 RC393.1 UCPU1.P4
DCI_DATA: R5836.2 RC394.1 UCPU1.P1
DCIN1_EN: PR108.1 UE3.M10
DCIN2_EN: PR117.1 UE3.N9
DCIN3_EN: PR126.1 UE3.K3
DDI1_PTX_TBRX_N0: CT14.2 UCPU1.E55
DDI1_PTX_TBRX_N0_C: CT14.1 UT2.AC7
DDI1_PTX_TBRX_N1: CT15.2 UCPU1.E58
DDI1_PTX_TBRX_N1_C: CT15.1 UT2.AC9
DDI1_PTX_TBRX_N2: CT24.2 UCPU1.F53
DDI1_PTX_TBRX_N2_C: CT24.1 UT2.AC11
DDI1_PTX_TBRX_N3: CT18.2 UCPU1.F56
DDI1_PTX_TBRX_N3_C: CT18.1 UT2.AC13
DDI1_PTX_TBRX_P0: CT13.2 UCPU1.F55
DDI1_PTX_TBRX_P0_C: CT13.1 UT2.AB7
DDI1_PTX_TBRX_P1: CT23.2 UCPU1.F58
DDI1_PTX_TBRX_P1_C: CT23.1 UT2.AB9
DDI1_PTX_TBRX_P2: CT16.2 UCPU1.G53
DDI1_PTX_TBRX_P2_C: CT16.1 UT2.AB11
DDI1_PTX_TBRX_P3: CT17.2 UCPU1.G56
DDI1_PTX_TBRX_P3_C: CT17.1 UT2.AB13
DDI2_PTX_TBRX_N0: CT28.2 UCPU1.C50
DDI2_PTX_TBRX_N0_C: CT28.1 UT2.AC15
DDI2_PTX_TBRX_N1: CT30.2 UCPU1.C52
DDI2_PTX_TBRX_N1_C: CT30.1 UT2.AC17
DDI2_PTX_TBRX_N2: CT32.2 UCPU1.A50
DDI2_PTX_TBRX_N2_C: CT32.1 UT2.AC19
DDI2_PTX_TBRX_N3: CT34.2 UCPU1.D51
DDI2_PTX_TBRX_N3_C: CT34.1 UT2.AC21
DDI2_PTX_TBRX_P0: CT27.2 UCPU1.D50
DDI2_PTX_TBRX_P0_C: CT27.1 UT2.AB15
DDI2_PTX_TBRX_P1: CT29.2 UCPU1.D52
DDI2_PTX_TBRX_P1_C: CT29.1 UT2.AB17
DDI2_PTX_TBRX_P2: CT31.2 UCPU1.B50
DDI2_PTX_TBRX_P2_C: CT31.1 UT2.AB19
DDI2_PTX_TBRX_P3: CT33.2 UCPU1.C51
DDI2_PTX_TBRX_P3_C: CT33.1 UT2.AB21
DDR_A0_ZQ0: RD1.1 UD42.B3
DDR_A0_ZQ1: RD3.1 UD42.B4
DDR_A1_ZQ0: RD2.1 UD41.B3
DDR_A1_ZQ1: RD4.1 UD41.B4
DDR_A_CA1_0: RD21.1 UCPU1.BA51 UD42.R2
DDR_A_CA1_1: RD23.1 UCPU1.BB54 UD42.P2
DDR_A_CA1_2: RD25.1 UCPU1.BA52 UD42.N2
DDR_A_CA1_3: RD27.1 UCPU1.AY52 UD42.N3
DDR_A_CA1_4: RD29.1 UCPU1.AW52 UD42.M3
DDR_A_CA1_5: RD31.1 UCPU1.AY55 UD42.F3
DDR_A_CA1_6: RD33.1 UCPU1.AW54 UD42.E3
DDR_A_CA1_7: RD35.1 UCPU1.BA54 UD42.E2
DDR_A_CA1_8: RD37.1 UCPU1.BA55 UD42.D2
DDR_A_CA1_9: RD39.1 UCPU1.AY54 UD42.C2
DDR_A_CA2_0: RD41.1 UCPU1.AU46 UD41.R2
DDR_A_CA2_1: RD43.1 UCPU1.AU48 UD41.P2
DDR_A_CA2_2: RD45.1 UCPU1.AT46 UD41.N2
DDR_A_CA2_3: RD47.1 UCPU1.AU50 UD41.N3
DDR_A_CA2_4: RD49.1 UCPU1.AU52 UD41.M3
DDR_A_CA2_5: RD51.1 UCPU1.AY51 UD41.F3
DDR_A_CA2_6: RD53.1 UCPU1.AT48 UD41.E3
DDR_A_CA2_7: RD55.1 UCPU1.AT50 UD41.E2
DDR_A_CA2_8: RD57.1 UCPU1.BB50 UD41.D2
DDR_A_CA2_9: RD59.1 UCPU1.AY50 UD41.C2
DDR_A_CKE0: RD65.1 UCPU1.BA56 UD42.K3
DDR_A_CKE1: RD67.1 UCPU1.BB56 UD42.K4
DDR_A_CKE2: RD69.1 UCPU1.AW56 UD41.K3
DDR_A_CKE3: RD71.1 UCPU1.AY56 UD41.K4
DDR_A_CLK0: RD75.1 UCPU1.AT53 UD42.J3
DDR_A_CLK1: RD79.1 UCPU1.AT55 UD41.J3
DDR_A_CLK#0: RD77.1 UCPU1.AU53 UD42.J2
DDR_A_CLK#1: RD81.1 UCPU1.AU55 UD41.J2
DDR_A_CS#0: RD61.1 UCPU1.AU45 UD41.L3 UD42.L3
DDR_A_CS#1: RD63.1 UCPU1.AU43 UD41.L4 UD42.L4
DDR_A_D0: UCPU1.AL71 UD42.C8
DDR_A_D1: UCPU1.AL68 UD42.B11
DDR_A_D2: UCPU1.AN68 UD42.C9
DDR_A_D3: UCPU1.AN69 UD42.B10
DDR_A_D4: UCPU1.AL70 UD42.B9
DDR_A_D5: UCPU1.AL69 UD42.B8
DDR_A_D6: UCPU1.AN70 UD42.C11
DDR_A_D7: UCPU1.AN71 UD42.C10
DDR_A_D8: UCPU1.AR70 UD42.R10
DDR_A_D9: UCPU1.AR68 UD42.R11
DDR_A_D10: UCPU1.AU71 UD42.R9
DDR_A_D11: UCPU1.AU68 UD42.T10
DDR_A_D12: UCPU1.AR71 UD42.T11
DDR_A_D13: UCPU1.AR69 UD42.R8
DDR_A_D14: UCPU1.AU70 UD42.T9
DDR_A_D15: UCPU1.AU69 UD42.T8
DDR_A_D16: UCPU1.AF65 UD42.N9
DDR_A_D17: UCPU1.AF64 UD42.M8
DDR_A_D18: UCPU1.AK65 UD42.N11
DDR_A_D19: UCPU1.AK64 UD42.N10
DDR_A_D20: UCPU1.AF66 UD42.M9
DDR_A_D21: UCPU1.AF67 UD42.P9
DDR_A_D22: UCPU1.AK67 UD42.M11
DDR_A_D23: UCPU1.AK66 UD42.M10
DDR_A_D24: UCPU1.AF70 UD42.F11
DDR_A_D25: UCPU1.AF68 UD42.F10
DDR_A_D26: UCPU1.AH71 UD42.D9
DDR_A_D27: UCPU1.AH68 UD42.F8
DDR_A_D28: UCPU1.AF71 UD42.E10
DDR_A_D29: UCPU1.AF69 UD42.E11
DDR_A_D30: UCPU1.AH70 UD42.E9
DDR_A_D31: UCPU1.AH69 UD42.F9
DDR_A_D32: UCPU1.BB65 UD41.B9
DDR_A_D33: UCPU1.AW65 UD41.C11
DDR_A_D34: UCPU1.AW63 UD41.B11
DDR_A_D35: UCPU1.AY63 UD41.C8
DDR_A_D36: UCPU1.BA65 UD41.B8
DDR_A_D37: UCPU1.AY65 UD41.B10
DDR_A_D38: UCPU1.BA63 UD41.C10
DDR_A_D39: UCPU1.BB63 UD41.C9
DDR_A_D40: UCPU1.BA61 UD41.T9
DDR_A_D41: UCPU1.AW61 UD41.R9
DDR_A_D42: UCPU1.BB59 UD41.T11
DDR_A_D43: UCPU1.AW59 UD41.T10
DDR_A_D44: UCPU1.BB61 UD41.R8
DDR_A_D45: UCPU1.AY61 UD41.T8
DDR_A_D46: UCPU1.BA59 UD41.R10
DDR_A_D47: UCPU1.AY59 UD41.R11
DDR_A_D48: UCPU1.AT66 UD41.E10
DDR_A_D49: UCPU1.AU66 UD41.F10
DDR_A_D50: UCPU1.AP65 UD41.F8
DDR_A_D51: UCPU1.AN65 UD41.D9
DDR_A_D52: UCPU1.AN66 UD41.E9
DDR_A_D53: UCPU1.AP66 UD41.E11
DDR_A_D54: UCPU1.AT65 UD41.F9
DDR_A_D55: UCPU1.AU65 UD41.F11
