# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_ITPXDP_N: length 83.4
  GND1 w0.102: v1(40.78,70.06) 40.78,69.93 v3(41.06,69.65)
  IN2 w0.089: v3(114.41,71.53) 114.48,71.47 114.7,71.47 114.79,71.56 114.79,72.07 114.97,72.25 114.97,73.24 113.88,74.33 105.01,74.33 104.56,73.89 102.48,73.89 102.04,74.33 83.99,74.33 82.26,72.6 80.83,72.6 79.11,74.32 42.39,74.32 41.82,73.76 41.82,70.3 41.49,69.98 41.27,69.98 41.06,69.77 v3(41.06,69.65)
  GND3 w0.102: v3(114.41,71.53) 114.42,71.53 114.42,71.45 v4(114.72,71.15)
CLK_ITPXDP_N_R: length 9.7
  IN3 w0.076: v3(113.3,62.77) 113.3,62.81 113.54,63.05 113.81,63.05 114.48,63.71 114.48,66.86 114.48,66.86 114.48,67.09 114.48,69.26 114.48,69.98 114.71,70.21 114.87,70.21 115.15,69.93 v3(115.15,69.88)
  GND3 w0.102: v4(112.96,62.85) 113.22,62.85 v3(113.3,62.77) ; v4(114.72,70.24) 115.08,69.88 v3(115.15,69.88)
CLK_ITPXDP_P: length 83.6
  GND1 w0.102: v1(41.38,70.06) 41.38,70.18 v3(41.08,70.48)
  IN2 w0.089: v3(115.16,71.55) 115.14,71.57 115.14,71.92 115.33,72.1 115.33,72.4 115.33,73.38 114.03,74.68 104.86,74.68 104.42,74.24 102.63,74.24 102.19,74.69 83.85,74.69 82.12,72.96 80.98,72.96 79.25,74.68 42.24,74.68 41.46,73.9 41.46,70.45 41.35,70.33 41.23,70.33 v3(41.08,70.48)
  GND3 w0.102: v3(115.16,71.55) 115.26,71.55 115.61,71.2 v4(115.61,71.15)
CLK_ITPXDP_P_R: length 9.5
  IN3 w0.076: v3(113.3,63.36) 113.45,63.22 113.74,63.22 114.31,63.78 114.31,66.93 114.31,67.09 114.31,68.78 114.31,70.05 114.64,70.38 115.06,70.38 v3(115.14,70.46)
  GND3 w0.102: v3(115.14,70.46) 115.16,70.46 115.19,70.43 115.2,70.43 115.41,70.22 115.59,70.22 v4(115.61,70.24) ; v3(113.3,63.36) 113.17,63.5 v4(112.96,63.5)
CLK_PCIE_MMI: length 242.1
  IN3 w0.089: v3(288.38,31.48) 288.29,31.57 288.29,31.92 287.92,32.29 282.33,32.29 281.73,31.69 280.7,31.69 279.64,32.75 275.86,32.75 274.81,31.69 268.02,31.69 265.63,29.31 265.63,27.37 264.57,26.31 262.64,22.38 262.64,19.95 259.8,17.11 258.74,17.11 254.04,12.41 251.97,12.41 250.84,11.28 250.11,11.28 249.64,10.8 231.88,10.8 229.29,13.39 227.24,13.39 225.35,15.28 209.96,15.28 205.51,10.83 188.36,10.83 186.83,12.36 182.07,12.36 175.7,18.73 169.84,18.73 165.02,23.54 165.02,25.46 162.72,27.76 162.72,29.99 162.32,30.39 162.32,33.4 163.14,34.22 163.14,37.41 160.11,40.44 160.11,45.38 159.73,45.76 159.73,48.06 153.28,54.51 153.28,55.23 152.23,56.27 152.23,58.05 150.78,59.5 150.78,61.59 150.22,62.15 150.22,64.73 149.36,65.6 149.36,68.96 147.06,71.25 142.63,71.25 141.91,71.98 140.06,71.98 139.07,72.96 123.37,72.96 122.81,72.4 121.8,72.4 121.16,71.77 121.16,70.13 118.02,66.99 118.02,64.25 117.39,63.62 116.78,63.62 v3(116.6,63.8)
  GND3 w0.102: v3(116.6,63.8) 116.43,63.8 v4(116.27,63.96) ; v3(288.38,31.48) 288.27,31.38 v4(288.27,31.14)
  BOTTOM w0.076: v4(116.27,63.96) 116.13,64.1 115.82,64.1 115.7,63.98 UCPU1.E38
  BOTTOM w0.102: UR1.5 v4(288.27,31.14)
CLK_PCIE_MMI#: length 242.1
  IN3 w0.089: v3(115.95,63.63) 116.2,63.63 116.56,63.27 117.54,63.27 118.38,64.1 118.38,66.84 121.52,69.98 121.52,71.62 121.94,72.05 122.96,72.05 123.52,72.61 138.93,72.61 139.91,71.62 141.76,71.62 142.49,70.9 146.91,70.9 149,68.81 149,65.45 149.87,64.59 149.87,62 150.43,61.44 150.43,59.35 151.88,57.9 151.88,56.12 152.92,55.08 152.92,54.36 159.37,47.91 159.37,45.62 159.75,45.23 159.75,40.29 162.78,37.26 162.78,34.37 161.96,33.55 161.96,30.25 162.36,29.84 162.36,27.62 164.67,25.31 164.67,23.39 169.69,18.37 175.56,18.37 181.92,12.01 186.68,12.01 188.21,10.47 205.66,10.47 210.11,14.93 225.21,14.93 227.1,13.04 229.15,13.04 231.73,10.45 249.78,10.45 250.26,10.92 250.99,10.92 252.12,12.05 254.18,12.05 258.89,16.76 259.95,16.76 262.99,19.81 262.99,22.3 264.86,26.1 265.99,27.22 265.99,29.16 268.17,31.34 274.96,31.34 276.01,32.39 279.5,32.39 280.55,31.34 281.88,31.34 282.47,31.94 287.77,31.94 287.93,31.77 287.93,31.59 v3(287.82,31.47)
  GND3 w0.102: v3(287.82,31.47) 287.87,31.42 v4(287.87,31.13) ; v3(115.95,63.63) 115.51,63.63 v4(115.25,63.89)
  BOTTOM w0.076: UCPU1.E40 114.87,63.5 v4(115.25,63.89)
  BOTTOM w0.102: UR1.6 v4(287.87,31.13)
CLK_PCIE_SSD: length 95.7
  IN3 w0.089: v3(163.21,31.13) 163.21,30.88 163.31,30.77 163.52,30.77 163.64,30.89 163.64,38.59 162.06,40.17 162.06,45.04 160.31,46.8 160.31,48.16 153.81,54.65 153.81,55.38 152.75,56.44 152.75,58.2 151.25,59.7 151.25,61.79 150.71,62.34 150.71,64.96 149.89,65.78 149.89,69.15 147.15,71.89 144.29,71.89 142.72,73.46 116.16,73.46 115.9,73.19 115.9,69.27 115.01,68.37 115.01,68.24 115.07,68.17 v3(115.13,68.17)
  GND3 w0.102: v3(115.13,68.17) 114.58,68.17 v4(114.51,68.1) ; v3(163.21,31.13) 163.01,30.93 162.67,30.93 v4(162.45,31.16)
  BOTTOM w0.076: UCPU1.C40 114.31,64.82 114.31,64.72 114.2,64.6 114.03,64.6 113.91,64.72 113.91,65.12 114.02,65.23 114.32,65.23 114.43,65.34 114.48,65.52 114.48,65.67 114.46,65.72 114.46,65.99 114.5,66.27 114.5,67.16 114.94,67.59 114.94,68.36 114.81,68.49 114.7,68.49 114.51,68.3 v4(114.51,68.1)
  BOTTOM w0.102: v4(162.45,31.16) 162.32,31.03 161.27,31.03 161.1,31.2 JNGFF1.55
CLK_PCIE_SSD#: length 95.6
  IN3 w0.089: v3(114.97,68.88) 115.01,68.88 115.54,69.41 115.54,73.34 116.02,73.81 142.87,73.81 143.02,73.66 144.43,72.24 147.29,72.24 150.25,69.29 150.25,65.93 151.06,65.11 151.06,62.49 151.61,61.94 151.61,59.84 153.1,58.35 153.1,56.59 154.16,55.53 154.16,54.8 160.66,48.3 160.66,46.95 162.42,45.19 162.42,40.31 163.99,38.74 163.99,30.74 163.67,30.42 v3(163.18,30.42)
  GND3 w0.102: v3(163.18,30.42) 162.93,30.67 v4(162.43,30.67) ; v3(114.97,68.88) 114.97,68.76 114.86,68.65 114.61,68.65 v4(114.52,68.74)
  BOTTOM w0.076: UCPU1.D40 114.22,64.3 114.56,64.64 114.56,65.23 114.58,65.25 114.65,65.5 114.65,65.71 114.62,65.76 114.62,65.98 114.67,66.26 114.67,67.09 115.1,67.52 115.1,68.43 114.86,68.67 114.6,68.67 v4(114.52,68.74)
  BOTTOM w0.102: v4(162.43,30.67) 162.31,30.8 161.25,30.8 161.14,30.7 JNGFF1.53
CLK_SMB: length 4.9
  TOP w0.095: PR152.1 v1(96.7,13.89)
  GND1 w0.095: v3(97.96,13.58) 97.6,13.58 97.3,13.89 v1(96.7,13.89)
  GND3 w0.095: v3(97.96,13.58) v4(99.05,13.58)
  BOTTOM w0.095: JT101.8 99.69,13.82 99.45,13.58 v4(99.05,13.58)
CLK_TP_SIO: length 190
  TOP w0.095: UE3.E10 17.56,13.21 v8(17.89,13.54) ; v7(13.03,6.56) 13.03,5.84 12.74,5.54 12.16,5.54 RE235.2
  IN1 w0.076: v7(13.03,6.56) 13.03,6.64 13.53,7.13 13.53,7.84 12.84,8.53 12.84,10.93 13.63,11.72 14.95,11.72 15.21,11.97 15.91,11.97 16.14,12.2 16.14,12.39 16.92,13.16 17.51,13.16 v8(17.89,13.54)
  IN2 w0.064: v8(17.89,13.54) 17.89,13.51 17.56,13.19 16.57,13.19 15.81,12.43 15.81,12.12 16.02,11.91 16.44,11.91 16.78,11.56 18.81,11.56 19.52,10.86 19.52,10.44 19.91,10.06 21.34,10.06 21.68,9.72 22.67,9.72 22.99,9.4 24.79,9.4 25.83,8.36 28.97,8.36 30.22,7.11 31.17,7.11 32.68,5.6 33.43,5.6 34.09,4.95 46.96,4.95 47.4,4.51 48.81,4.51 49.3,5 51,5 51.63,4.38 53.02,4.38 76.99,4.38 79.79,7.17 108.93,7.17 111.67,9.91 134.96,9.91 135.78,10.73 147.73,10.73 150.62,7.84 157.49,7.84 158.91,6.41 163.4,6.41 163.89,6.9 166.2,6.9 166.67,6.43 166.67,6.29 v3(166.47,6.09)
  GND3 w0.095: v4(166.7,6.6) 166.7,6.32 v3(166.47,6.09)
  BOTTOM w0.095: v4(166.7,6.6) 166.7,6.89 167.12,7.31 C123.1 167.12,7.97 v2(167.44,8.29) 168.2,9.05 MD1.3 169.18,8.3 169.36,8.12 169.88,8.12 171.23,6.76 173.05,6.76 173.37,7.09 174.93,7.09 175.22,7.38 175.22,7.67 175.08,7.81 JTP1.8
CLKREQ_PCIE#0: length 153.1
  IN2 w0.064: 102.73,60.66 98.45,60.66 98.28,60.49 96.91,60.49 94.31,57.89 82.59,57.89 77.44,63.03 76.95,63.03 75.68,64.3 70.15,64.3 69.84,63.99 63.66,63.99 62.18,62.51 62.18,60.25 60.54,58.61 55.33,58.61 54.16,59.78 54.16,60.69 53.78,61.08 52.63,61.08 50.81,59.27 47.94,59.27 42.64,53.97 42.29,53.97 38.81,50.48 38.81,48.62 35.72,45.54 34.15,45.54 33.72,45.97 33.29,45.97 32.51,46.75 32.51,49.56 32.62,49.67 32.62,51.29 v3(32.66,51.33) ; 120.07,60.41 120.12,60.35 120.12,53.22 120.69,52.65 121.09,52.65 121.78,51.96 121.78,51.75 122.21,51.31 122.99,51.31 123.37,50.93 124.13,50.93 124.72,51.52 126.76,51.52 127.79,52.56 130.59,52.56 130.86,52.29 131.23,52.29 131.4,52.11 131.4,50.82 132.21,50.01 132.21,47.92 131.95,47.65 v8(131.7,47.65)
  IN2 w0.076: 120.07,60.41 119.2,61.28 118.23,61.28 117.93,61.58 108.45,61.58 108.33,61.45 107.03,61.45 106.24,60.66 102.73,60.66
  IN3 w0.064: v3(143.8,49.61) 143.29,49.61 142.81,49.14 141.09,49.14 140.05,48.1 135.47,48.1 134.65,47.29 133.31,47.29 132.88,47.72 131.78,47.72 v8(131.7,47.65)
  GND3 w0.095: v6(32.23,51.26) 32.3,51.33 v3(32.66,51.33) ; v3(143.8,49.61) v4(144.13,49.94)
  IN4 w0.076: v5(31.38,51.28) 31.4,51.26 v6(32.23,51.26)
  BOTTOM w0.095: v4(144.13,49.94) 144.18,49.99 RC58.2 ; v5(31.38,51.28) 31.35,51.28 30.74,50.67 RT71.2
  BOTTOM w0.112: UCPU1.AR10 132.07,48.01 v8(131.7,47.65)
CLKREQ_PCIE#0_N: length 2.7
  BOTTOM w0.095: RT10.2 30.59,51.26 30.05,50.72 RT71.1 29.88,50.84 28.67,50.84 28.6,50.77 UT2.AC5
CLKREQ_PCIE#1: length 215.3
  IN1 w0.076: v9(169.97,21.2) 169.48,20.7 v7(159.55,20.7) 157.43,20.7 156.4,19.67 v9(154.44,19.67)
  GND1 w0.095: v9(169.97,21.2) v3(170.37,21.2) ; v3(154.03,19.4) 154.18,19.4 v9(154.44,19.67)
  IN2 w0.064: v3(283.76,52.07) 283.76,52.03 283.47,51.73 279.54,51.73 277.49,49.68 277.49,49.68 274.24,46.43 274.24,46.01 265.61,37.39 265.61,33.23 265.61,33.22 265.61,31.69 265.25,31.33 265.25,27.4 263.86,26.01 263.86,24.58 262.61,23.33 262.61,20.49 259.59,17.47 258.28,17.47 253.33,12.52 252.4,12.52 250.6,10.73 249.86,10.73 248.74,9.61 231.87,9.61 230.4,11.08 227.9,11.08 225.21,13.77 210.37,13.77 206.15,9.55 187.73,9.55 186.04,11.24 182.82,11.82 182.13,11.82 180.51,13.43 180.51,13.69 173.01,21.2 v3(170.37,21.2)
  IN3 w0.064: v3(133.94,46.73) 134.06,46.85 135.77,46.85 136.13,47.21 140.44,47.21 141.48,48.25 143.22,48.25 143.57,48.59 144.16,48.59 v3(144.21,48.55) 144.82,47.94 144.82,46.99 142.33,44.5 142.33,41.19 144.22,39.31 145.65,39.31 148.38,36.58 148.38,35.17 150.21,33.34 150.71,33.34 151.19,33.34 152.97,31.57 152.97,19.65 153.22,19.4 v3(154.03,19.4)
  GND3 w0.095: v4(284.12,52.07) v3(283.76,52.07) ; v3(133.94,46.73) 133.82,46.85 133.82,47.16 133.99,47.33 v4(133.99,47.36) ; v4(144.52,48.75) 144.31,48.55 v3(144.21,48.55)
  BOTTOM w0.095: v4(144.52,48.75) 144.52,48.8 145.05,49.33 RC62.2
CLKREQ_PCIE#3: length 42.7
  IN3 w0.064: v3(149.03,35.23) 148.82,35.44 148.82,36.76 148.64,36.94 145.83,39.75 145.81,39.75 145.79,39.77 144.43,39.77 142.78,41.42 142.78,44.29 145.33,46.84 145.33,48.22 v3(144.31,49.23) 144.18,49.23 144.06,49.11 143.41,49.11 143,48.69 141.28,48.69 140.24,47.65 135.67,47.65 135.1,47.08 133.22,47.08 132.83,47.46 132.21,47.46 v8(131.72,46.97)
  GND3 w0.095: v3(144.31,49.23) 144.44,49.36 v4(144.44,49.54) ; v4(148.98,34.53) 148.98,35.18 v3(149.03,35.23)
  BOTTOM w0.095: RC65.2 145.07,50.17 v4(144.44,49.54) ; v4(148.98,34.53) 148.98,31.43 149.76,30.65 151.42,30.65 151.63,30.45 JNGFF1.52
  BOTTOM w0.112: UCPU1.AT10 132.1,47.36 v8(131.72,46.97)
CLKREQ_PCIE#4: length 201.8
  TOP w0.095: v7(29.8,50.35) RC67.2 RT433.1 ; v7(30.37,56.25) 30.41,56.29 v2(30.41,57.22) 30.41,57.99 31.26,58.85 39.36,58.85 46.11,65.6 55.04,65.6 56.49,67.05 56.49,73.42 v7(56.36,73.54) ; v8(133.47,46.39) 133.47,45.4 136.34,42.53 137.76,42.53 138.36,41.93 140.92,41.93 141.48,41.37 142.61,41.37 144.3,39.68 148.21,39.68 148.88,40.35 148.88,44.08 149.62,44.82 v7(158.33,44.82) ; v7(154.78,49.37) 154.78,50.74 151.33,54.19 151.33,56.81 150.34,57.79 v8(150.34,58.85)
  IN1 w0.076: v7(56.36,73.54) 56.45,73.62 78.77,73.62 80.45,71.95 82.65,71.95 84.35,73.64 94.81,73.64 94.96,73.49 101.67,73.49 102.19,72.97 105.12,72.97 105.42,73.27 109.98,73.27 110.29,73.58 135.45,73.58 138.62,70.41 140.4,70.41 142.39,68.42 142.39,66.91 144.42,64.88 148.28,64.88 150.87,62.29 150.87,60.13 150.34,59.6 v8(150.34,58.85) ; v7(30.37,56.25) 30.76,55.86 30.76,51.31 v7(29.8,50.35) ; v7(154.78,49.37) 154.78,48.19 158.14,44.82 v7(158.33,44.82)
  BOTTOM w0.112: v8(133.47,46.39) 133.39,46.39 UCPU1.AU8
CLKREQ_PCIE#5: length 212.9
  IN2 w0.064: v8(289.76,30.44) 289.62,30.31 278.38,30.31 276.64,28.57 276.64,24.76 275.88,24.01 275.88,23.05 276.23,22.7 276.23,21.73 274.81,20.31 274.81,19.09 273.88,18.16 273,18.16 271.87,17.03 271.51,17.03 270.8,16.32 270.8,15.47 268.37,13.04 267.97,13.04 259.34,4.41 228.09,4.41 226.79,5.71 221.54,5.71 220.18,4.35 185.42,4.35 183.7,6.06 173.7,6.06 173.21,5.57 170.3,5.57 167.21,8.67 166.11,8.67 v3(166.03,8.59)
  IN3 w0.064: v3(166.03,8.59) 166.03,8.67 164.82,9.87 163.53,9.87 162.4,11.01 161.51,11.01 159.84,12.68 159.37,12.68 156.78,15.27 156.62,15.27 154.54,15.27 153.3,16.5 153.3,18.07 151.8,19.58 151.8,21.65 152.52,22.37 152.52,31.34 150.97,32.89 150.03,32.89 149.12,33.8 147.9,35.02 147.9,36.43 145.46,38.86 144.01,38.86 141.89,40.98 141.89,44.68 144.31,47.11 v3(144.31,47.84) 144.19,47.71 143.28,47.71 143.18,47.8 141.66,47.8 140.65,46.79 140.65,46.61 140.25,46.21 138.93,46.21 138.71,46.43 138.35,46.43 138.09,46.69 136.71,46.69 135.85,45.83 135.07,45.83 v8(134.45,46.45)
  GND3 w0.095: v4(144.67,47.89) 144.62,47.84 v3(144.31,47.84)
  BOTTOM w0.095: v4(144.67,47.89) 145.05,48.27 RC70.2 ; UR1.2 289.47,30.72 v8(289.76,30.44)
  BOTTOM w0.112: v8(134.45,46.45) 134.19,46.71 UCPU1.AU7
CLKRUN#: length 9.3
  BOTTOM w0.076: 135.39,39.84 135.09,40.14 135.09,40.92 135.37,41.21 135.46,41.21 135.63,41.38 135.63,41.79 135.44,41.98 134.85,41.98 134.06,42.77 132.51,42.77 131.7,43.58 131.7,45.26 131.41,45.54 UCPU1.AW11
  BOTTOM w0.095: 135.39,39.84 RC16.2
CODEC_MUTE#: length 5.5
  TOP w0.095: D9.1 271.41,65.27 271.68,65.54 RA15.2 272.57,65.14 272.83,64.88 v1(273,64.88) 273,64.64 v2(272.75,64.38)
  GND1 w0.095: v1(273,64.88) 273.13,65.01 v3(273.34,65.01)
  GND3 w0.095: v3(273.34,65.01) 273.59,65.01 v4(273.67,65.09)
  BOTTOM w0.095: U5.13 274.46,65.26 274.35,65.37 273.95,65.37 v4(273.67,65.09)
CORE_VID0: length 58.6
  IN1 w0.076: v8(130.81,48.94) 130.81,49.04 130.44,49.41 130.44,49.81 130.74,50.11 131.34,50.11 131.54,50.32 131.85,50.62 132.59,50.62 132.79,50.82 134.45,50.82 134.55,50.72 135.18,50.72 135.29,50.83 137.81,50.83 138.74,51.76 140.62,51.76 142.22,50.16 148.51,50.16 150.98,52.63 150.98,56.76 152.01,57.79 152.01,58.79 153.04,59.82 153.04,63.22 151.11,65.14 151.11,69.5 152.34,70.73 152.34,72.9 152.62,73.18 156.53,73.18 157.34,72.37 162.55,72.37 v8(162.63,72.3)
  BOTTOM w0.095: v8(162.63,72.3) 162.57,72.24 PR1419.1
  BOTTOM w0.112: v8(130.81,48.94) 131.18,49.31 UCPU1.AN11
CORE_VID1: length 58.9
  IN1 w0.076: v8(129.82,49.04) 130.24,49.46 130.24,49.86 130.74,50.36 130.76,50.39 131.17,50.39 131.67,50.88 132.51,50.88 132.61,50.98 135.03,50.98 135.11,51.06 137.73,51.06 138.62,51.96 140.72,51.96 142.32,50.37 148.43,50.37 150.56,52.5 v7(150.56,53.22) 150.56,56.62 151.81,57.87 151.81,58.88 152.83,59.9 152.83,63.13 150.91,65.06 150.91,69.64 152.14,70.87 152.14,72.99 152.6,73.46 156.88,73.46 157.5,72.83 162.41,72.83 v8(162.67,73.09)
  BOTTOM w0.095: v8(162.67,73.09) 162.59,73.16 PR1420.1
  BOTTOM w0.112: v8(129.82,49.04) 130.09,49.31 UCPU1.AN13
CPU_DDI1_AUXN: length 93.1
  IN2 w0.076: 107.93,64.62 107.94,64.6 107.94,64.47 108.01,64.4 109.05,64.4 109.34,64.11 109.34,63.38 109.5,63.22 109.5,62.72 109.32,62.54 109.07,62.54 v3(108.88,62.34)
  IN2 w0.089: v3(32.92,52.38) 33.12,52.18 33.67,52.18 33.99,52.5 33.99,57.27 38.68,61.96 43.8,61.96 47.18,65.34 52.18,65.34 54.84,68.01 77.25,68.01 78.48,66.78 79.11,66.78 79.67,66.22 82.74,66.22 85.18,63.78 91.35,63.78 91.9,64.33 96.44,64.33 98.38,66.28 105.8,66.28 107.05,65.02 107.23,65.02 107.23,65.02 107.52,65.02 107.93,64.62
  GND3 w0.102: v3(108.88,62.34) 108.95,62.41 109.09,62.41 v4(109.3,62.2) ; v3(32.92,52.38) 32.75,52.21 32.47,52.21 v4(32.36,52.31)
CPU_DDI1_AUXN_C: length 8.1
  IN3 w0.076: v3(31.41,52.25) 31.41,52.25 31.21,52.05 30.92,52.05 29.99,51.12 28.17,51.12 26.84,49.79 26.57,49.79 26.26,49.48 26.26,48.5 v3(26.24,48.48)
  GND3 w0.102: v3(26.24,48.48) 26.44,48.28 v4(26.44,48.2) ; v3(31.41,52.25) 31.43,52.28 v4(31.79,52.28)
CPU_DDI1_AUXP: length 93.1
  IN2 w0.076: 107.67,64.37 107.69,64.35 107.82,64.35 107.94,64.23 108.98,64.23 109.18,64.04 109.18,63.31 109.34,63.15 109.34,62.79 109.26,62.71 108.7,62.71 108.56,62.85 108.56,62.99 108.67,63.1 v3(108.86,63.1)
  IN2 w0.089: v3(32.93,51.82) 33.82,51.82 34.35,52.35 34.35,57.12 38.83,61.6 43.95,61.6 47.33,64.99 52.32,64.99 54.99,67.65 77.11,67.65 78.33,66.43 78.97,66.43 79.53,65.87 82.59,65.87 85.03,63.43 91.5,63.43 92.05,63.98 96.59,63.98 98.53,65.92 105.65,65.92 106.91,64.67 107.37,64.67 107.67,64.37
  GND3 w0.102: v4(109.3,62.85) 109.05,63.1 v3(108.86,63.1) ; v3(32.93,51.82) 32.85,51.9 32.59,51.9 v4(32.36,51.68)
CPU_DDI1_AUXP_C: length 8
  IN3 w0.076: v3(31.43,51.67) 31.22,51.89 30.99,51.89 30.06,50.96 28.24,50.96 26.91,49.63 26.64,49.63 26.43,49.41 26.43,48.83 26.74,48.51 v3(26.78,48.51)
  GND3 w0.102: v4(31.79,51.65) 31.46,51.65 v3(31.43,51.67) ; v3(26.78,48.51) 26.78,48.46 27.04,48.2 v4(27.09,48.2)
CPU_DDI2_AUXN: length 97.2
  IN3 w0.076: v3(109.71,63.6) 109.71,63.42 109.79,63.35 109.98,63.35 110.08,63.45 110.08,64.07 109.46,64.69 109.46,65.99 108.9,66.54 108.9,67.25 108.38,67.77 106.88,67.77 106.46,68.19 106.06,68.19 106.02,68.14 106,68.14
  IN3 w0.089: 106,68.14 105.92,68.14 97.61,68.14 96.51,67.04 91.97,67.04 91.08,66.16 91.08,66.04 90.02,64.99 87.16,64.99 84.14,68.01 79.07,68.01 77.43,69.65 72.25,69.65 71.76,69.17 61.79,69.17 61.66,69.3 54.63,69.3 51.51,66.18 45.75,66.18 40.31,60.73 40.31,55.17 36.06,50.93 33.85,50.93 33.46,50.54 33.13,50.54 32.99,50.4 v3(32.99,50.34)
  GND3 w0.102: v4(32.37,50.25) 32.56,50.44 32.89,50.44 v3(32.99,50.34) ; v3(109.71,63.6) 109.81,63.5 v4(110.21,63.5)
CPU_DDI2_AUXN_C: length 8.2
  IN3 w0.076: v3(26.2,47.78) 26.4,47.59 26.4,47.44 26.63,47.21 28.45,47.21 30.39,49.15 30.39,50.04 30.84,50.49 31.17,50.49 v3(31.41,50.25)
  GND3 w0.102: v4(26.44,47.55) 26.21,47.78 v3(26.2,47.78) ; v4(31.79,50.25) v3(31.41,50.25)
CPU_DDI2_AUXP: length 97.3
  IN3 w0.076: 106,68.5 106.01,68.5 106.16,68.35 106.53,68.35 106.95,67.94 108.45,67.94 109.07,67.31 109.07,66.61 109.62,66.05 109.62,64.76 110.25,64.14 110.25,63.34 v3(109.88,62.97)
  IN3 w0.089: 106,68.5 105.15,68.5 97.47,68.5 96.37,67.4 91.82,67.4 90.72,66.3 90.72,66.19 89.88,65.34 87.31,65.34 84.28,68.37 79.22,68.37 77.58,70.01 72.1,70.01 71.61,69.53 61.94,69.53 61.81,69.65 54.48,69.65 51.37,66.54 45.6,66.54 39.95,60.88 39.95,55.32 35.92,51.28 33.7,51.28 33.31,50.9 v3(32.99,50.9)
  GND3 w0.102: v3(109.88,62.97) 109.88,62.97 110.09,62.97 v4(110.21,62.85) ; v4(32.37,50.88) 32.52,50.73 32.83,50.73 v3(32.99,50.9)
CPU_DDI2_AUXP_C: length 8.2
  IN3 w0.076: v3(26.81,47.83) 26.71,47.83 26.57,47.68 26.57,47.51 26.69,47.38 28.39,47.38 30.23,49.22 30.23,50.11 30.77,50.65 31.31,50.65 31.41,50.75 v3(31.41,50.86)
  GND3 w0.102: v3(31.41,50.86) 31.43,50.88 v4(31.79,50.88) ; v4(27.09,47.55) 27.09,47.55 26.82,47.83 v3(26.81,47.83)
CPU_DP1_CTRL_CLK: length 231.1
  TOP w0.095: v1(134.91,68.54) 134.75,68.7 v2(134.75,69.67)
  IN1 w0.076: v1(134.91,68.54) 134.29,67.92 134.29,67.61 131.31,64.63 131.31,61.43 v9(130.81,60.92)
  GND1 w0.095: v3(130.43,60.58) 130.47,60.58 v9(130.81,60.92) ; v3(135.24,68.62) 135.23,68.62 135.15,68.54 v1(134.91,68.54)
  GND3 w0.095: v3(135.24,68.62) 134.93,68.62 v6(134.89,68.67) ; v4(130.28,60.25) 130.28,60.44 v3(130.43,60.58)
  IN4 w0.076: v6(134.89,68.67) 134.89,67.67 133.44,66.23 133.44,64.95 133.73,64.67 133.73,64.02 133.96,63.79 135.02,63.79 135.19,63.62 135.19,63.09 135.51,62.77 136.24,62.77 137.22,61.79 137.22,60.65 137.63,60.25 137.78,60.25 138.82,59.21 141.12,59.21 141.83,58.5 143.96,58.5 146.25,56.21 146.25,55.56 148.45,53.36 148.45,51.55 152.2,47.8 152.2,39.07 151.87,38.74 151.87,35.37 153.04,34.2 153.04,32.82 154.17,31.69 154.17,26.78 152.96,25.57 152.96,17.13 149.61,13.77 146.51,13.77 146.19,13.46 145.33,13.46 144.9,13.89 139.51,13.89 138.99,13.37 130.05,13.37 129.92,13.5 125.56,13.5 125.44,13.38 120.09,13.38 119.74,13.03 118.55,13.03 118.29,13.29 114.82,13.29 114.15,12.62 110.19,12.62 109.15,11.58 100.34,11.58 99.24,10.47 81.98,10.47 81.59,10.08 79.45,10.08 76.3,6.93 66.15,6.93 65.43,7.65 51.61,7.65 49.48,9.77 47.65,9.77 47.01,10.41 42.24,10.41 41.75,10.9 35.7,10.9 34.18,12.43 34.18,18.01 32.33,19.85 32.33,22.64 33.01,23.32 33.01,28.08 33.21,28.28 33.21,30.14 32.79,30.55 32.79,32.4 33.3,32.91 33.3,35.91 32.62,36.59 v5(32.62,36.81)
  BOTTOM w0.095: v5(32.62,36.81) 32,36.81 31.7,37.11 RT91.2
CPU_DP1_CTRL_DATA: length 251.7
  TOP w0.095: v1(134.91,67.65) 134.91,66.72 v2(134.95,66.68)
  IN1 w0.076: v9(131.28,59.88) 131.27,59.89 131.27,61.03 131.6,61.36 131.6,64.52 134.73,67.65 v1(134.91,67.65)
  GND1 w0.095: v3(26.45,53.73) 26.45,53.83 v1(26.02,54.26) ; v1(134.91,67.65) v3(134.56,67.65) ; v3(130.93,59.88) v9(131.28,59.88)
  GND3 w0.095: v6(26.44,53.15) 26.45,53.17 v3(26.45,53.73) ; v3(134.56,67.65) v6(134.56,68) ; v4(130.93,60.25) v3(130.93,59.88)
  IN4 w0.076: v6(134.56,68) 134.56,67.63 133.22,66.3 133.22,64.88 133.43,64.68 133.43,64.29 133.53,64.19 133.53,63.85 133.88,63.5 133.88,62.3 134.23,61.96 134.89,61.96 135.49,62.56 136.13,62.56 137.02,61.67 137.02,60.57 137.57,60.02 137.68,60.02 138.74,58.97 141.07,58.97 141.75,58.28 143.89,58.28 146.05,56.12 146.05,55.47 148.25,53.28 148.25,51.46 151.99,47.71 151.99,39.16 151.67,38.83 151.67,35.29 152.84,34.12 152.84,32.73 153.96,31.61 153.96,26.86 152.76,25.66 152.76,17.26 149.59,14.09 139.42,14.09 138.9,13.57 130.13,13.57 130,13.7 125.47,13.7 125.36,13.58 120.12,13.58 120.04,13.66 114.9,13.66 114.06,12.82 110.11,12.82 109.07,11.78 100.26,11.78 99.15,10.68 81.9,10.68 81.5,10.28 79.37,10.28 76.22,7.13 66.25,7.13 65.53,7.85 51.69,7.85 49.57,9.98 47.73,9.98 46.6,11.11 35.78,11.11 34.38,12.51 34.38,18.09 33.75,18.73 33.75,22.12 33.21,22.66 33.21,28 33.41,28.2 33.41,30.22 33,30.64 33,32.32 33.5,32.83 33.5,36.21 33.15,36.57 33.15,37.97 33.77,38.59 33.77,40.68 32.8,41.65 31.78,41.65 31,40.86 29.8,40.86 27.41,43.26 27.41,46.82 26.76,47.46 26.76,49.01 26.57,49.2 26.33,49.2 26.15,49.38 26.15,51.64 26.44,51.93 v6(26.44,53.15)
CPU_DP1_HPD: length 230.9
  TOP w0.095: v2(132.95,59.32) 133.22,59.59 v8(133.22,59.78) 133.22,60.23 RC4.2
  IN4 w0.076: v5(27.33,52.15) 27.62,52.44 27.95,52.44 28.13,52.25 30.55,52.25 31.59,53.3 32.38,53.3 34.28,51.4 34.28,38.92 34.83,38.37 34.83,33.47 35.27,33.03 35.27,27.14 34.23,26.1 34.23,23.08 34.77,22.54 34.77,20.3 34.99,20.07 34.99,12.76 36.04,11.72 46.86,11.72 47.99,10.59 49.82,10.59 51.94,8.46 66.38,8.46 67.1,7.74 75.96,7.74 79.11,10.89 80.21,10.89 81.56,12.24 83.82,12.24 84.23,11.83 85.03,11.83 85.47,12.27 90.39,12.27 90.95,11.72 99.28,11.72 99.95,12.39 108.82,12.39 109.86,13.43 113.74,13.43 114.57,14.27 120.3,14.27 120.37,14.19 125.1,14.19 125.22,14.31 130.26,14.31 130.39,14.18 138.65,14.18 139.17,14.7 149.33,14.7 152.15,17.52 152.15,25.91 152.97,26.74 152.97,31.29 151.27,33 151.27,34.08 150.94,34.41 150.94,35 151.06,35.11 151.06,39.05 150.93,39.17 150.93,43.28 151.39,43.73 151.39,47.38 146.05,52.72 146.05,54.61 145.39,55.27 145.39,55.92 143.67,57.64 141.23,57.64 140.68,58.19 137.68,58.19 135.73,60.15 133.55,60.15 133.22,59.82 v8(133.22,59.78)
  BOTTOM w0.112: v8(133.22,59.78) 132.88,60.12 UCPU1.L9
CPU_DP2_CTRL_CLK: length 229.2
  TOP w0.095: v8(133.88,58.82) 134.07,58.63 134.86,58.63 135.31,59.07 136.57,59.07 136.71,58.93 139.66,58.93 v2(140.08,59.35) 140.5,59.77 140.5,59.92 RC5.1
  IN4 w0.076: v8(133.88,58.82) 134.45,58.25 135.37,58.25 135.59,58.03 135.59,57.55 135.88,57.26 140.26,57.26 140.78,56.75 141.71,56.75 144.24,54.22 144.24,53.01 150.12,47.13 150.12,38.37 149.51,37.77 149.51,35.42 149.83,35.11 149.83,33.2 152.01,31.02 152.01,26.98 151.29,26.26 151.29,17.82 149,15.52 138.76,15.52 138.23,14.99 131.33,14.99 131.19,15.13 123.97,15.13 123.85,15.01 121.14,15.01 121.05,15.09 119.49,15.09 114.18,15.09 113.33,14.25 101.69,14.25 100.64,13.2 99.58,13.2 98.9,12.53 91.28,12.53 90.7,13.11 81.28,13.11 79.87,11.7 78.66,11.7 77.73,10.78 76.51,10.78 76.1,10.37 75.67,10.37 73.89,8.59 67.5,8.59 66.82,9.28 61.39,9.28 61.32,9.34 61.32,9.34 61.23,9.43 57.52,9.43 57.2,9.75 56.53,9.75 56.35,9.57 52.3,9.57 50.47,11.4 48.32,11.4 47.18,12.54 36.41,12.54 36.12,12.83 36.12,12.96 35.84,13.24 35.84,20.38 35.63,20.58 35.63,22.51 35.59,22.55 35.59,22.92 35.07,23.44 35.07,25.79 36.1,26.83 36.1,33.43 35.64,33.9 35.64,38.8 35.1,39.34 35.1,51.74 33.74,53.1 33.74,53.22 32.6,54.36 32.3,54.36 v5(32.15,54.21)
  BOTTOM w0.095: RT93.2 32.15,55.24 32.27,55.11 32.27,54.34 v5(32.15,54.21)
  BOTTOM w0.112: v8(133.88,58.82) 133.88,58.94 134.18,59.24 UCPU1.N7
CPU_DP2_CTRL_DATA: length 231.8
  TOP w0.095: RC7.1 140.12,60.43 140.12,59.9 139.38,59.16 136.98,59.16 136.71,59.42 v2(136.06,59.42) 135.34,59.42 134.83,58.91 134.49,58.91 134.15,59.24 133.66,59.24 v8(133.25,58.83)
  IN4 w0.076: v5(31.79,54.06) 31.79,54.39 31.97,54.57 32.69,54.57 33.95,53.31 33.95,53.18 35.3,51.83 35.3,39.44 35.87,38.88 35.87,33.96 36.31,33.52 36.31,31.18 36.64,30.85 36.73,30.85 37.41,30.17 37.41,28.11 36.49,27.19 36.49,26.6 35.27,25.38 35.27,23.52 35.79,23 35.79,22.64 35.83,22.59 35.83,20.67 36.04,20.46 36.04,13.32 36.32,13.04 36.32,12.92 36.49,12.74 47.35,12.74 48.5,11.6 50.55,11.6 52.38,9.78 56.27,9.78 56.44,9.95 57.28,9.95 57.6,9.63 61.31,9.63 61.37,9.58 61.37,9.58 61.39,9.56 61.47,9.48 66.9,9.48 67.58,8.8 73.8,8.8 74.81,9.8 74.81,10.41 75.38,10.98 77.65,10.98 78.58,11.91 79.79,11.91 81.2,13.32 89.86,13.32 90.99,14.45 113.25,14.45 114.1,15.3 119.41,15.3 121.14,15.3 121.22,15.21 123.76,15.21 123.89,15.34 131.27,15.34 131.41,15.19 138.14,15.19 138.68,15.73 148.92,15.73 151.09,17.9 151.09,26.35 151.8,27.06 151.8,30.94 149.63,33.11 149.63,35.02 149.31,35.34 149.31,37.86 149.91,38.45 149.91,47.04 144.04,52.91 144.04,54.13 141.63,56.54 140.67,56.54 140.17,57.04 135.64,57.04 135.3,57.39 133.47,57.39 133.25,57.61 v8(133.25,58.83)
  BOTTOM w0.095: v5(31.79,54.06) 31.79,53.72 RT94.2
  BOTTOM w0.127: v8(133.25,58.83) 133.25,59.02 UCPU1.N8
CPU_DP2_HPD: length 232.5
  TOP w0.095: RC6.2 133.95,60.07 v8(133.95,59.76) 133.95,59.76 134.48,59.23 v2(134.62,59.23)
  IN4 w0.076: v8(133.95,59.76) 134.61,59.09 135.82,59.09 136.09,58.82 136.61,58.82 137.46,57.96 140.58,57.96 141.11,57.43 142.94,57.43 144.92,55.45 144.92,53.21 150.91,47.22 150.91,44.76 150.52,44.38 150.52,38.2 149.92,37.6 149.92,35.6 150.24,35.28 150.24,33.37 152.41,31.2 152.41,26.81 151.7,26.09 151.7,17.65 149.17,15.12 138.93,15.12 138.4,14.58 131.16,14.58 131.02,14.73 124.14,14.73 124.02,14.6 120.97,14.6 120.88,14.69 119.66,14.69 114.37,14.69 113.53,13.84 109.69,13.84 108.65,12.8 99.78,12.8 99.11,12.12 91.12,12.12 90.56,12.68 81.59,12.68 81.59,12.68 81.42,12.68 80.04,11.3 78.83,11.3 77.9,10.37 76.98,10.37 75.51,8.9 74.77,8.9 74.06,8.19 67.33,8.19 66.65,8.87 61.21,8.87 61.06,9.02 57.35,9.02 57.03,9.34 56.79,9.34 56.61,9.17 52.13,9.17 50.3,10.99 48.16,10.99 47.01,12.14 36.24,12.14 35.42,12.96 35.42,20.22 35.18,20.46 35.18,22.75 34.64,23.29 34.64,25.94 35.7,27 35.7,33.26 35.23,33.73 35.23,38.63 34.69,39.17 34.69,51.57 32.49,53.76 31.65,53.76 31.45,53.97 31,53.97 30.89,53.85 30.89,53.21 30.58,52.9 27.67,52.9 27.04,52.27 27.04,51.92 27.64,51.33 27.64,50.38 27.4,50.15 v5(27.09,50.15)
  BOTTOM w0.112: UCPU1.L7 134.18,59.99 v8(133.95,59.76)
CPU_POPIRCOMP: length 3.5
  TOP w0.254: v8(128.01,47.12) 128.13,47.12 128.55,46.71 v2(128.55,46.64) RC106.1
  BOTTOM w0.254: UCPU1.AT16 128.39,47.36 128.16,47.12 v8(128.01,47.12)
CPU_XDP_PRDY#: length 66
  TOP w0.095: JXDP1.5 v7(51.88,72.17)
  IN1 w0.076: v7(51.88,72.17) 52.73,71.32 57.6,71.32 58.05,71.77 77.9,71.77 79.58,70.09 84.55,70.09 86.65,72.19 93.92,72.19 94.21,71.9 96.11,71.9 96.83,71.19 101.64,71.19 102.68,70.14 104.1,70.14 104.66,70.7 105.32,70.7 v9(105.74,70.27)
  GND1 w0.095: v3(105.41,70.27) v9(105.74,70.27)
  GND3 w0.095: v4(105.08,70.27) v3(105.41,70.27)
  BOTTOM w0.076: UCPU1.D56 105.65,64.39 105.32,64.73 105.32,65.67 105.26,65.74 105.26,66 105.22,66.07 105.22,66.43 105.35,66.55 105.35,66.9 104.73,67.52 104.73,68.84 104.3,69.26 104.3,69.49 v4(105.08,70.27)
CPU_XDP_PREQ#: length 63.9
  TOP w0.095: JXDP1.3 v7(52.48,72.16)
  IN1 w0.076: v9(102.62,70.62) 101.85,71.39 97.59,71.39 96.88,72.1 94.32,72.1 94.04,72.39 86.56,72.39 84.47,70.3 79.66,70.3 77.98,71.97 57.97,71.97 57.52,71.53 53.12,71.53 v7(52.48,72.16)
  GND1 w0.095: v3(102.62,70.12) v9(102.62,70.62)
  GND3 w0.095: v4(102.81,69.73) 102.62,69.92 v3(102.62,70.12)
  BOTTOM w0.076: UCPU1.D61 103.18,64.49 103.48,64.79 103.48,65.04 103.43,65.09 103.43,66.72 103.49,66.78 103.49,66.98 102.61,67.87 102.61,68.83 v2(102.99,69.21) 102.99,69.4 102.81,69.58 v4(102.81,69.73) 102.81,69.92 103.1,70.21 104.09,70.21 104.61,70.73 RC230.1
CPU_XDP_TCK: length 19.5
  IN1 w0.076: v9(102.34,69.5) 102.34,69.83 101.45,70.73 96.64,70.73 95.92,71.44 94.01,71.44 93.89,71.56 92.94,71.56 92.62,71.24 91.86,71.24 v9(91.8,71.18)
  GND1 w0.095: v3(91.59,71.81) 91.59,71.75 91.8,71.53 v9(91.8,71.18) ; v9(102.34,69.5) 102.32,69.48 102.32,69.01 v3(102.29,68.98)
  GND3 w0.095: v3(102.29,68.98) 102.29,68.73 v4(102.21,68.65) ; v4(90.9,71.93) 91.47,71.93 v3(91.59,71.81)
  BOTTOM w0.076: v4(102.21,68.65) 102.26,68.59 v2(102.26,68.13) 102.26,67.98 102.66,67.58 102.66,66.96 102.93,66.08 103.18,65.61 UCPU1.B61
  BOTTOM w0.095: v4(90.9,71.93) 90.51,71.93 89.98,72.46 RC244.1 89.7,72.3 RC228.1
CPU_XDP_TDI: length 19.5
  IN1 w0.076: v9(93.04,70.14) 93.36,70.45 94.12,70.45 94.96,69.62 96.17,69.62 96.31,69.76 100.51,69.76 100.72,69.56 100.72,69.21 101.24,68.69 102.64,68.69 102.82,68.87 103.16,68.87 v9(103.46,68.57)
  GND1 w0.095: v9(103.46,68.57) 103.48,68.58 v3(103.48,68.99) ; v9(93.04,70.14) 93.04,70.31 v3(93.28,70.55)
  GND3 w0.095: v3(103.48,68.99) 103.48,68.65 103.38,68.54 v4(103.38,68.37) ; v4(93.24,71.44) 93.24,70.59 v3(93.28,70.55)
  BOTTOM w0.076: v4(103.38,68.37) 103.54,68.21 v2(103.54,67.9) 103.54,67.41 103.97,66.99 103.97,66.58 103.8,66.42 103.8,65.68 104.05,65.42 104.05,65.11 103.74,64.79 UCPU1.D60
  BOTTOM w0.095: v4(93.24,71.44) 93.14,71.44 RC240.1 RC229.1
CPU_XDP_TDO: length 15.6
  TOP w0.095: v8(94.44,68.5) 94.72,68.78 v11(95.42,68.78)
  IN1 w0.076: v9(102.82,67.96) 102.77,68.02 100.66,68.02 99.84,68.84 94.73,68.84 94.44,68.56 v8(94.44,68.5)
  GND1 w0.095: v3(102.71,66.76) 102.71,67.85 v9(102.82,67.96)
  GND3 w0.095: v3(102.71,66.76) 102.73,66.79 v4(103.09,66.79)
  BOTTOM w0.076: UCPU1.A61 103.18,66.7 v4(103.09,66.79) ; 93.11,70.57 RC242.2 94.28,69.4 94.28,68.66 v8(94.44,68.5)
  BOTTOM w0.095: RC227.1 93.11,70.57
CPU_XDP_TMS: length 19.3
  IN1 w0.076: v9(93.85,70.16) 94.97,69.05 96.21,69.05 96.68,69.51 97.58,69.51 98.05,69.05 100.53,69.05 101.1,68.49 102.85,68.49 v9(102.93,68.56)
  GND1 w0.095: v3(93.84,70.56) 93.84,70.18 v9(93.85,70.16) ; v3(102.93,68.97) 102.93,68.56 v9(102.93,68.56)
  GND3 w0.095: v4(102.95,68.32) 102.93,68.34 v3(102.93,68.97) ; v3(93.84,70.56) 93.62,70.78 93.62,71.85 v4(93.12,72.35)
  BOTTOM w0.076: UCPU1.C60 103.74,65.41 103.6,65.55 103.6,66.47 103.8,66.68 103.8,66.91 102.95,67.76 v4(102.95,68.32)
  BOTTOM w0.095: RC231.1 v4(93.12,72.35) v11(93.12,73.62)
CPU_XDP_TRST#: length 27
  TOP w0.095: v1(103.27,69.84) 103.3,69.87 103.3,70.22 104.09,71.01 v11(104.09,72.96) 104.09,73.17 v1(103.33,73.93)
  GND1 w0.095: v3(103.19,70.16) 103.3,70.06 103.3,69.87 v1(103.27,69.84) ; v1(103.33,73.93) 103.33,74.51 103.23,74.62 v3(103.21,74.62)
  GND3 w0.095: v4(103.19,69.72) v3(103.19,70.16) ; v4(102.83,74.6) 103.2,74.6 v3(103.21,74.62)
  BOTTOM w0.076: v4(103.19,69.72) 103.25,69.65 103.51,69.65 103.67,69.49 103.67,68.45 103.88,68.24 103.88,67.31 104.13,67.07 104.13,66.46 103.99,66.31 103.99,65.93 104.3,65.62 UCPU1.B59
  BOTTOM w0.095: v4(102.83,74.6) 102.75,74.68 89.67,74.68 89.14,74.15 RC232.1 89.14,73.44 89.25,73.34 RC217.1
CSI2_COMP: length 1.7
  TOP w0.254: RC9.1 130.47,63.42 v8(130.74,63.15)
  BOTTOM w0.254: v8(130.74,63.15) 130.68,63.15 UCPU1.E13
DAT_SMB: length 4.2
  TOP w0.095: PR154.1 v1(98.58,13.89)
  GND1 w0.095: v1(98.58,13.89) 99.78,13.89 v3(99.81,13.91)
  GND3 w0.095: v4(100.23,13.67) 99.99,13.91 v3(99.81,13.91)
  BOTTOM w0.095: JT101.7 100.94,13.89 100.72,13.67 v4(100.23,13.67)
DAT_TP_SIO: length 182.6
  TOP w0.095: v7(13.44,6.55) v2(13.44,5.93) 12.62,5.11 RE236.2
  IN1 w0.076: v1(15.9,11.61) 15.9,11.69 15.83,11.77 15.29,11.77 15.04,11.51 13.71,11.51 13.04,10.84 13.04,8.61 13.73,7.93 13.73,7.04 13.43,6.75 13.43,6.55 v7(13.44,6.55)
  GND1 w0.095: v1(15.9,11.61) 16.17,11.88 v3(16.17,12.28)
  IN2 w0.064: v3(167.02,6.08) 166.86,6.23 166.86,6.51 166.28,7.09 163.81,7.09 163.32,6.6 158.99,6.6 157.57,8.03 150.7,8.03 147.8,10.92 135.7,10.92 134.88,10.1 111.59,10.1 108.85,7.36 79.71,7.36 76.91,4.57 52.94,4.57 51.71,4.57 51.08,5.19 49.22,5.19 48.73,4.7 47.48,4.7 47.04,5.14 34.16,5.14 33.51,5.79 32.76,5.79 31.25,7.3 30.3,7.3 29.05,8.55 25.9,8.55 24.43,10.03 23.4,10.03 23.3,10.13 22.95,10.13 22.89,10.06 21.61,10.06 20.84,10.83 20.7,10.83 19.15,12.38 16.57,12.38 16.46,12.28 v3(16.17,12.28)
  GND3 w0.095: v3(167.02,6.08) 167.08,6.14 167.08,6.55 v4(167.1,6.57)
  BOTTOM w0.095: JTP1.7 175.58,7.82 175.44,7.69 175.44,7.29 175.02,6.87 173.47,6.87 173.14,6.54 171.14,6.54 169.78,7.9 169.28,7.9 169.18,7.79 MD1.2 167.88,7.12 167.33,6.57 v4(167.1,6.57) 167.1,6.08 C124.1
DBC_EN: length 219.1
  IN1 w0.076: v9(37.69,12.81) 37.82,12.68 48.49,12.68 52.9,8.27 60.98,8.27 61.49,7.77 66.19,7.77 66.7,7.26 71.36,7.26 71.57,7.05 75.46,7.05 80.67,12.26 89.71,12.26 89.84,12.13 99.61,12.13 102.07,14.59 v9(102.58,14.59)
  GND1 w0.095: v3(37.33,13.04) 37.4,13.04 37.62,12.81 v9(37.69,12.81) ; v9(102.58,14.59) v3(102.58,14.21)
  IN3 w0.064: v8(147.07,18.08) 145.87,18.08 145.14,17.36 142.72,17.36 142.66,17.29 137.55,17.29 136.76,18.08 129.63,18.08 129.01,17.46 126.04,17.46 125.63,17.87 123.24,17.87 122.73,18.37 117.66,18.37 115.11,15.82 110.52,15.82 108.97,14.27 106.03,14.27 105.46,14.84 103.21,14.84 v3(102.58,14.21)
  GND3 w0.095: v3(37.33,13.04) v6(36.62,13.04)
  IN4 w0.076: v5(31.58,61.8) 31.58,62.14 33.17,63.74 34.01,63.74 34.22,63.53 34.22,62.68 33.2,61.67 33.2,59.23 32.99,59.02 32.99,56.93 33.23,56.69 33.72,56.69 34.11,56.3 34.11,55 35.5,53.6 36.22,53.6 36.51,53.31 36.51,52.67 36.86,52.33 36.86,47.51 36.5,47.15 36.5,39.63 37.12,39.02 37.12,38.32 37.53,37.91 37.53,31.61 38.11,31.03 38.11,27.36 36.08,25.33 36.08,23.75 36.61,23.22 36.61,21.94 36.42,21.75 36.42,21.14 36.51,21.05 36.51,20.33 36.44,20.26 36.44,13.22 v6(36.62,13.04) ; v8(147.07,18.08) 147.62,18.08 148.16,18.62 148.16,24.66 148.47,24.97 148.47,28.41 147.09,29.79 147.09,31.06 146.31,31.84 145.27,31.84 141.6,35.51 141.6,38.49 139.7,40.39 139.7,40.8 135.71,44.79 135.71,46.56 135.3,46.96 133.47,46.96 133.15,47.29 133.15,47.89 v8(133.54,48.28)
  BOTTOM w0.112: v8(133.54,48.28) 133.92,48.66 UCPU1.AP7
DCI_CLK: length 199.4
  TOP w0.095: RC393.1 273.42,31.29 273.6,31.47 273.6,31.8 273.84,32.04 274.5,32.04 274.89,31.64 275.55,31.64 276.32,30.88 276.57,30.88 v1(276.63,30.94)
  GND1 w0.095: v1(276.63,30.94) 276.71,30.86 276.99,30.86 v3(277.15,31.02) ; v1(269.64,19.62) 269.64,20.22 v3(269.45,20.41)
  IN2 w0.064: v3(277.15,31.02) 276.98,30.86 276.75,30.86 275.56,29.66 275.56,25.78 271.95,22.17 271.95,21.25 270.93,20.24 269.51,20.24 269.45,20.3 v3(269.45,20.41) 269,20.86 268.11,20.86 266.81,19.57 266.81,18.17 265.74,17.09 265.74,15.8 256.58,6.64 254.45,6.64 253.95,6.15 230.17,6.15 228.64,7.68 226.48,7.68 226.06,8.1 218.24,8.1 216.27,6.13 212.5,6.13 211.68,6.95 209.65,6.95 208.83,6.12 186.16,6.12 184.5,7.78 173.64,7.78 173.12,8.3 171.34,8.3 168.13,11.51 166.8,11.51 165.42,12.9 164.62,12.9 158.47,19.05 158.47,26.32 157.7,27.09 157.7,30.35 156.72,31.33 156.72,32.36 152.99,36.09 152.99,38.82 150.12,41.69 150.12,44.73 149.78,45.08 149.78,46.75 149.22,47.3 148.76,47.3 144.95,51.11 144.95,52.2 143.77,53.38 143.77,54.12 142.5,55.39 142.2,55.39 138.36,59.22 136.82,59.22 v3(136.75,59.15)
  GND3 w0.095: v4(136.24,59.12) 136.25,59.12 136.72,59.12 v3(136.75,59.15)
  BOTTOM w0.076: UCPU1.P4 135.61,58.75 135.98,59.12 136.16,59.12 136.17,59.12 v4(136.24,59.12)
DCI_DATA: length 198.1
  TOP w0.095: v1(276.63,30.56) 276.54,30.66 276.22,30.66 275.46,31.42 v10(275.19,31.42) 274.8,31.42 274.41,31.81 273.93,31.81 273.83,31.71 273.83,31.46 274,31.29 RC394.1
  GND1 w0.095: v1(267.35,19.62) 267.45,19.62 267.69,19.86 267.84,19.86 268.1,20.12 v3(268.18,20.12) ; v3(277.15,30.49) 276.99,30.64 276.71,30.64 v1(276.63,30.56)
  IN2 w0.064: v3(137.19,58.71) 137.51,59.03 138.28,59.03 142.12,55.2 142.42,55.2 143.58,54.04 143.58,53.3 144.76,52.12 144.76,51.04 148.68,47.11 149.14,47.11 149.58,46.67 149.58,45 149.93,44.65 149.93,41.61 152.8,38.74 152.8,36.01 156.53,32.28 156.53,31.25 157.51,30.27 157.51,27.01 158.28,26.25 158.28,18.97 164.54,12.71 165.34,12.71 166.72,11.32 168.05,11.32 171.26,8.11 173.04,8.11 173.56,7.59 184.42,7.59 186.08,5.93 208.91,5.93 209.73,6.76 211.6,6.76 212.42,5.94 216.35,5.94 218.32,7.91 225.99,7.91 226.41,7.49 228.56,7.49 230.09,5.96 254.03,5.96 254.53,6.45 256.66,6.45 265.93,15.73 265.93,17.01 267,18.09 267,19.49 267.63,20.12 v3(268.18,20.12) 268.54,20.12 268.61,20.04 271.01,20.04 272.14,21.17 272.14,22.09 275.75,25.7 275.75,29.58 276.83,30.66 276.97,30.66 v3(277.15,30.49)
  GND3 w0.095: v4(137.67,59.1) 137.58,59.1 v3(137.19,58.71)
  BOTTOM w0.076: v4(137.67,59.1) 137.56,58.99 UCPU1.P1
DCIN1_EN: length 12.6
  TOP w0.095: UE3.M10 17.5,19.02 17.89,19.4 v7(17.89,20.77)
  IN1 w0.076: v7(17.89,20.77) 17.89,20.85 18.18,21.14 18.43,21.14 19.31,22.02 20.66,22.02 v9(21.21,22.57)
  GND1 w0.095: v3(21.76,22.78) 21.42,22.78 v9(21.21,22.57)
  GND3 w0.095: v3(21.76,22.78) 21.66,22.68 v4(21.35,22.68)
  BOTTOM w0.095: v2(22.37,27.06) 22.26,26.96 PR108.1 22.26,25.71 20.8,24.25 20.8,23.34 21.35,22.78 v4(21.35,22.68)
DCIN2_EN: length 31.2
  TOP w0.095: v7(18.33,20.77) 18.33,19.64 UE3.N9
  IN1 w0.076: v7(18.33,20.77) 17.87,20.31 16.36,20.31 16.31,20.27 13.8,20.27 13.32,20.75 13.32,21.33 14.05,22.06 15.08,22.06 16.41,23.39 16.41,24.04 v9(16.58,24.21)
  GND1 w0.095: v9(16.58,24.21) v3(16.58,24.56)
  GND3 w0.095: v3(16.58,24.56) 16.59,24.56 v6(16.94,24.91)
  IN4 w0.076: v6(16.94,24.91) 16.98,24.95 16.98,28.09 17.74,28.85 18.24,28.85 19.6,30.2 22.17,30.2 22.74,29.64 28.01,29.64 29.06,30.69 v5(29.06,31.52)
  BOTTOM w0.095: PR117.1 v5(29.06,31.52)
DCIN3_EN: length 237.8
  TOP w0.095: UE3.K3 v7(22.7,16.81)
  IN1 w0.076: v9(29.21,15.3) 28.93,15.02 28.16,15.02 27.08,16.09 25.1,16.09 24.35,16.85 22.73,16.85 v7(22.7,16.81)
  GND1 w0.095: v3(29.76,15.07) 29.53,15.3 v9(29.21,15.3)
  IN3 w0.064: v3(33.55,3.64) 33.15,4.04 30.42,4.04 29.64,4.83 29.64,6.51 29.88,6.75 29.88,10.02 29.29,10.61 29.29,11.37 29.76,11.84 v3(29.76,15.07)
  GND3 w0.095: v3(33.55,3.64) v6(33.95,3.64)
  IN4 w0.076: v5(219.21,9.56) 218.52,9.56 215.94,12.14 212.68,12.14 209.77,9.23 209.5,9.23 207.3,7.03 204.24,7.03 204,6.78 202.84,6.78 201.15,5.09 197.01,5.09 196.84,4.92 185.59,4.92 184.12,6.39 176.98,6.39 176.4,5.81 169.15,5.81 168.38,5.05 164.64,5.05 162.97,6.73 159.89,6.73 156.03,2.87 146.78,2.87 145.36,4.29 145.36,8.01 143.32,10.05 137.66,10.05 136.08,8.47 131.8,8.47 130.99,9.28 121.77,9.28 121.12,8.63 118.74,8.63 118.09,7.98 116.3,7.98 115.46,7.14 113.17,7.14 112.66,6.64 112.66,5.37 112.93,5.1 112.93,2.89 112.74,2.7 102.28,2.7 99.22,5.75 81,5.75 77.46,2.22 63.11,2.22 62.52,2.8 57.47,2.8 57.26,3.02 43.84,3.02 43.42,3.44 41.85,3.44 41.33,2.92 38.1,2.92 37.61,3.41 34.18,3.41 v6(33.95,3.64)
  BOTTOM w0.254: PR126.1 v2(217.82,13.46) 217.88,13.4 217.88,11.74 219.21,10.41 v5(219.21,9.56)
DDI1_PTX_TBRX_N0: length 91.1
  IN2 w0.076: v3(106.19,63.78) 106.19,63.59 106.29,63.49 106.45,63.49 106.57,63.61 106.57,64.04 106.1,64.51 105.97,64.51 105.95,64.53
  IN2 w0.089: v3(33.63,49.42) 33.84,49.63 34.2,49.63 34.64,50.07 34.64,50.63 39.46,55.45 39.46,57.1 42.62,60.26 43.68,60.26 47.58,64.16 52.68,64.16 55.44,66.93 76.81,66.93 78.03,65.7 78.62,65.7 82.9,61.42 84.48,61.42 84.88,61.83 91.12,61.83 92.51,63.21 96.9,63.21 98.84,65.16 105.32,65.16 105.95,64.53
  GND3 w0.102: v3(106.19,63.78) 106.26,63.71 v4(106.26,63.36) ; v4(32.51,49.41) 32.56,49.41 32.88,49.72 33.26,49.72 33.56,49.42 v3(33.63,49.42)
  BOTTOM w0.076: v4(106.26,63.36) 106.4,63.5 UCPU1.E55
  BOTTOM w0.102: CT14.2 30.82,49.64 31.76,49.64 31.91,49.49 32.44,49.49 v4(32.51,49.41)
DDI1_PTX_TBRX_N0_C: length 2.5
  BOTTOM w0.076: 29.16,49.89 29.07,49.89 29.04,49.92 28.66,49.92 28.56,49.81 28.56,49.75 28.42,49.61 28.22,49.61 28.14,49.69 28.14,49.78 28.2,49.85 UT2.AC7
  BOTTOM w0.102: CT14.1 29.79,49.68 29.37,49.68 29.16,49.89
DDI1_PTX_TBRX_N1: length 86.8
  IN2 w0.076: 102.25,64.32 102.26,64.32 102.27,64.32 102.27,64.33 102.39,64.46 103.93,64.46 104.27,64.11 104.27,63.52 v3(104.03,63.28)
  IN2 w0.089: v3(32.97,48.26) 33.03,48.26 33.39,48.63 33.78,48.63 33.93,48.48 34.56,48.48 35.46,49.37 35.46,50.3 44.67,59.52 45.07,59.52 46.98,61.42 48.11,61.42 50.08,63.39 53.09,63.39 55.9,66.2 76.5,66.2 77.73,64.98 78.31,64.98 83.44,59.85 93.49,59.85 96.1,62.46 97.37,62.46 99.23,64.32 102.25,64.32
  GND3 w0.102: v4(32.37,48.34) 32.89,48.34 v3(32.97,48.26) ; v4(104.27,63.74) 104.03,63.5 v3(104.03,63.28)
  BOTTOM w0.076: UCPU1.E58 104.44,63.5 104.27,63.67 v4(104.27,63.74)
DDI1_PTX_TBRX_N1_C: length 4.4
  BOTTOM w0.076: 29.95,48.75 29.93,48.75 29.9,48.78 29.42,48.78 29.25,48.95 28.65,48.95 28.57,48.88 28.57,48.8 28.47,48.7 28.2,48.7 28.12,48.77 28.12,48.87 28.18,48.93 UT2.AC9
  BOTTOM w0.102: CT15.1 31.58,48.55 31.19,48.55 30.99,48.75 29.95,48.75
DDI1_PTX_TBRX_N2: length 91.8
  IN2 w0.076: 103.04,63 103.06,63 103.15,63.1 103.41,63.1 103.59,62.92 103.59,62.47 103.95,62.11 104.65,62.11 104.89,62.35 104.89,62.63 105.19,62.94 106.5,62.94 106.6,62.84 106.85,62.84 107.02,62.67 v3(107.02,62.32)
  IN2 w0.089: 103.04,63 101.46,63 100.81,62.36 98.43,62.36 97.77,61.7 96.4,61.7 93.8,59.09 83.12,59.09 77.98,64.23 77.44,64.23 76.2,65.48 56.31,65.48 53.47,62.64 50.59,62.64 48.62,60.66 47.36,60.66 45.44,58.74 44.99,58.74 36.34,50.1 36.34,48.97 34.82,47.45 34.09,47.45 v3(34,47.35)
  GND3 w0.102: v4(32.52,47.51) 32.55,47.51 32.65,47.62 33.73,47.62 v3(34,47.35) ; v3(107.02,62.32) 107.02,62.52 107.06,62.56 v4(107.06,62.68)
  BOTTOM w0.076: v4(107.06,62.68) 107.23,62.85 UCPU1.F53
  BOTTOM w0.102: CT24.2 30.82,47.86 31.06,47.86 31.31,47.61 32.42,47.61 v4(32.52,47.51)
DDI1_PTX_TBRX_N2_C: length 2.5
  BOTTOM w0.076: 29.13,47.86 29.11,47.89 28.57,47.89 28.45,47.76 28.09,47.76 28.04,47.82 28.04,47.91 28.14,48.01 UT2.AC11
  BOTTOM w0.102: 29.13,47.86 29.83,47.86 CT24.1
DDI1_PTX_TBRX_N3: length 92
  IN2 w0.076: v3(106.01,62.51) 105.9,62.39 105.9,61.89 105.64,61.63 103.15,61.63 103.06,61.54 103.04,61.54
  IN2 w0.089: v3(33.42,46.35) 33.57,46.5 33.91,46.5 34.26,46.15 35.52,46.15 38.18,48.81 38.18,50.55 42.19,54.57 42.59,54.57 46.69,58.67 46.69,58.93 47.53,59.77 50.08,59.77 51.98,61.68 53.86,61.68 54.65,60.89 54.65,60.12 55.67,59.09 60.1,59.09 61.56,60.56 61.56,63 63.32,64.76 75.88,64.76 77.13,63.5 77.65,63.5 82.81,58.34 94.12,58.34 96.72,60.95 98.08,60.95 98.26,61.12 102.36,61.12 102.77,61.54 103.04,61.54
  GND3 w0.102: v3(106.01,62.51) 105.98,62.51 v4(105.64,62.85) ; v3(33.42,46.35) 32.76,46.35 32.68,46.44 v4(32.37,46.44)
DDI1_PTX_TBRX_N3_C: length 4.5
  BOTTOM w0.076: UT2.AC13 28.19,47.09 28.11,47.01 28.11,46.95 28.21,46.85 28.43,46.85 28.56,46.98 28.56,47.1 28.62,47.16 29.03,47.16 29.21,46.98 29.9,46.98 29.93,46.95 29.95,46.95
  BOTTOM w0.102: CT18.1 31.62,46.61 31.14,46.61 30.8,46.95 29.95,46.95
DDI1_PTX_TBRX_P0: length 91.1
  IN2 w0.076: v3(107.07,63.37) 106.84,63.37 106.74,63.48 106.74,64.11 106.22,64.63 106.22,64.76 106.21,64.78
  IN2 w0.089: v3(33.63,49.95) 33.66,49.98 34.05,49.98 34.28,50.21 34.28,50.78 39.1,55.59 39.1,57.25 42.47,60.62 43.54,60.62 47.44,64.52 52.53,64.52 55.29,67.28 76.95,67.28 78.18,66.06 78.76,66.06 83.05,61.77 84.33,61.77 84.74,62.18 90.97,62.18 92.36,63.57 96.75,63.57 98.69,65.51 105.47,65.51 106.21,64.78
  GND3 w0.102: v3(33.63,49.95) 32.78,49.95 32.63,49.8 v4(32.51,49.8) ; v3(107.07,63.37) 106.81,63.12 106.75,63.12 106.75,63.12 v4(106.75,63.12)
  BOTTOM w0.076: UCPU1.F55 106.56,62.92 106.75,63.12 v4(106.75,63.12)
  BOTTOM w0.102: v4(32.51,49.8) 32.42,49.71 32.01,49.71 31.86,49.86 30.82,49.86 CT13.2
DDI1_PTX_TBRX_P0_C: length 2.5
  BOTTOM w0.076: UT2.AB7 27.87,49.85 28.1,50.08 29.11,50.08
  BOTTOM w0.102: CT13.1 29.83,49.87 29.45,49.87 29.24,50.08 29.11,50.08
DDI1_PTX_TBRX_P1: length 86.8
  IN2 w0.076: v3(104.58,63.32) 104.43,63.46 104.43,64.18 103.99,64.62 102.3,64.62 102.25,64.67
  IN2 w0.089: v3(32.94,48.81) 33.07,48.81 33.25,48.98 33.93,48.98 34.08,48.84 34.42,48.84 35.1,49.52 35.1,50.45 44.52,59.87 44.92,59.87 46.83,61.78 47.97,61.78 49.94,63.75 52.94,63.75 55.75,66.56 76.65,66.56 77.87,65.34 78.46,65.34 83.58,60.21 93.34,60.21 95.95,62.81 97.22,62.81 99.08,64.67 102.25,64.67
  GND3 w0.102: v3(104.58,63.32) 104.97,63.32 v4(105.06,63.22) ; v4(32.37,48.98) 32.7,48.98 32.87,48.81 v3(32.94,48.81)
  BOTTOM w0.076: v4(105.06,63.22) 105.06,63.19 UCPU1.F58
DDI1_PTX_TBRX_P1_C: length 4.4
  BOTTOM w0.076: UT2.AB9 27.87,48.93 28.09,49.15 28.55,49.15 28.58,49.12 29.32,49.12 29.49,48.95 29.9,48.95 29.93,48.98 29.95,48.98
  BOTTOM w0.102: 29.95,48.98 31.09,48.98 31.29,48.78 31.59,48.78 CT23.1
DDI1_PTX_TBRX_P2: length 91.8
  IN2 w0.076: 103.04,63.36 103.06,63.36 103.15,63.26 103.48,63.26 103.75,62.99 103.75,62.54 104.02,62.27 104.58,62.27 104.73,62.42 104.73,62.7 105.12,63.1 106.57,63.1 106.66,63.01 106.92,63.01 107.06,62.86 107.43,62.86 v3(107.47,62.91)
  IN2 w0.089: v3(33.99,47.9) 34.09,47.8 34.67,47.8 35.99,49.12 35.99,50.25 44.84,59.1 45.29,59.1 47.21,61.02 48.47,61.02 50.45,62.99 53.32,62.99 56.16,65.83 76.34,65.83 77.59,64.59 78.13,64.59 83.27,59.45 93.65,59.45 96.26,62.06 97.62,62.06 98.28,62.71 100.66,62.71 101.31,63.36 103.04,63.36
  GND3 w0.102: v3(33.99,47.9) 33.94,47.85 32.58,47.85 v4(32.52,47.9) ; v4(107.67,62.49) 107.67,62.71 v3(107.47,62.91)
  BOTTOM w0.076: UCPU1.G53 107.67,62.4 v4(107.67,62.49)
  BOTTOM w0.102: CT16.2 30.82,48.09 31.16,48.09 31.41,47.84 32.45,47.84 v4(32.52,47.9)
DDI1_PTX_TBRX_P2_C: length 2.5
  BOTTOM w0.076: UT2.AB11 27.86,48.01 28.09,48.24 28.43,48.24 28.61,48.05 29.08,48.05 29.1,48.06
  BOTTOM w0.102: CT16.1 29.81,48.06 29.1,48.06
DDI1_PTX_TBRX_P3: length 91.9
  IN2 w0.076: 103.04,61.89 103.06,61.89 103.15,61.8 105.57,61.8 105.73,61.96 105.73,62.27 105.49,62.5 v3(105.33,62.5)
  IN2 w0.089: v3(33.43,46.9) 33.48,46.85 34.06,46.85 34.41,46.51 35.37,46.51 37.82,48.96 37.82,50.7 42.04,54.92 42.45,54.92 46.34,58.81 46.34,59.08 47.39,60.13 49.93,60.13 51.84,62.03 54.01,62.03 55,61.04 55,60.26 55.82,59.45 59.95,59.45 61.21,60.7 61.21,63.15 63.17,65.11 76.02,65.11 77.27,63.86 77.79,63.86 82.95,58.7 93.97,58.7 96.58,61.31 97.94,61.31 98.11,61.48 102.21,61.48 102.62,61.89 103.04,61.89
  GND3 w0.102: v4(32.37,47.07) 32.68,46.77 33.21,46.77 33.34,46.9 v3(33.43,46.9) ; v4(105.64,62.2) 105.64,62.2 v3(105.33,62.5)
DDI1_PTX_TBRX_P3_C: length 4.4
  BOTTOM w0.076: 29.95,47.18 29.93,47.18 29.9,47.15 29.28,47.15 29.1,47.32 28.1,47.32 27.87,47.09 UT2.AB13
  BOTTOM w0.102: 29.95,47.18 30.89,47.18 31.24,46.84 31.55,46.84 CT17.1
DDI2_PTX_TBRX_N0: length 102.8
  IN3 w0.076: 106.52,69.54 106.54,69.54 106.63,69.63 106.84,69.63 107.8,68.68 107.8,68.5 107.73,68.43 v3(107.61,68.43)
  IN3 w0.089: 106.52,69.54 105.81,69.54 105.67,69.39 95.12,69.39 94.68,68.95 91.1,68.95 89.71,70.35 87.57,70.35 87.15,69.93 87.15,69.93 85.99,68.76 79.35,68.76 77.73,70.38 71.95,70.38 71.5,69.93 62.19,69.93 62.08,70.03 54.27,70.03 51.17,66.93 45.33,66.93 39.54,61.14 39.54,55.52 36.8,52.79 33.8,52.79 33.63,52.96 32.86,52.96 32.29,52.38 32.29,46.59 31.86,46.16 31.43,46.16 31.28,46.01 v3(31.28,45.88)
  GND3 w0.102: v4(107.81,68.04) 107.61,68.24 v3(107.61,68.43) ; v4(30.62,45.88) v3(31.28,45.88)
  BOTTOM w0.076: UCPU1.C50 109.19,64.86 109.19,64.66 109.27,64.59 109.38,64.59 109.56,64.77 109.56,64.98 109.49,65.12 109.49,65.32 109.55,65.49 109.55,65.57 109.5,65.74 arc(109.49,65.8) 109.49,65.87 arc(109.49,65.97) 109.52,66.08 109.54,66.12 arc(109.55,66.28) 109.48,66.42 109.27,66.63 108.85,66.63 107.98,67.49 107.98,67.87 v4(107.81,68.04)
DDI2_PTX_TBRX_N0_C: length 2.5
  BOTTOM w0.076: 29.16,46.11 29.11,46.16 28.65,46.16 28.42,45.93 28.17,45.93 28.09,46 28.09,46.11 28.16,46.17 UT2.AC15
  BOTTOM w0.102: 29.16,46.11 29.18,46.09 29.82,46.09 CT28.1
DDI2_PTX_TBRX_N1: length 98.6
  IN3 w0.076: 106.32,66.81 107.13,66.01 107.59,66.01 107.95,66.36 107.95,67.2 v3(108.04,67.29)
  IN3 w0.089: v3(33.45,45.05) 33.64,45.24 34.34,45.24 35.4,46.31 35.4,49.19 41.08,54.87 41.08,59.65 46.81,65.38 51.87,65.38 55.06,68.57 61.36,68.57 61.49,68.45 72.06,68.45 72.55,68.93 76.82,68.93 78.49,67.26 82.32,67.26 82.84,66.74 84.28,66.74 86.79,64.23 90.49,64.23 91.5,65.23 96.61,65.23 98.77,67.39 105.61,67.39 106.19,66.81 106.32,66.81
  GND3 w0.102: v4(108.04,66.94) v3(108.04,67.29) ; v3(33.45,45.05) 33.27,45.23 32.48,45.23 32.37,45.13 v4(32.37,45.04)
  BOTTOM w0.076: UCPU1.C52 108.19,64.87 108.19,64.7 108.11,64.62 107.94,64.62 107.81,64.75 107.81,64.83 107.82,64.95 107.91,65.15 107.91,65.32 107.87,65.57 107.87,65.68 107.92,65.86 107.92,65.97 107.87,66.08 107.87,66.44 107.91,66.49 107.91,66.81 v4(108.04,66.94)
DDI2_PTX_TBRX_N1_C: length 4.2
  BOTTOM w0.076: 29.95,45.26 29.92,45.28 28.65,45.28 28.56,45.19 28.56,45.11 28.47,45.01 28.22,45.01 28.15,45.08 28.15,45.19 28.21,45.25 UT2.AC17
  BOTTOM w0.102: 29.95,45.26 31.57,45.26 CT30.1
DDI2_PTX_TBRX_N2: length 100.1
  IN3 w0.076: v3(108.89,66.02) 108.7,65.83 108.7,65.66 108.43,65.39 106.58,65.39 106.49,65.29 106.47,65.29
  IN3 w0.089: 106.47,65.29 97.92,65.29 96.61,63.98 91.3,63.98 90.71,63.38 85.26,63.38 82.66,65.98 79.63,65.98 79.11,66.5 78.18,66.5 77.04,67.65 61.14,67.65 60.95,67.84 55.43,67.84 52.1,64.51 47.13,64.51 41.84,59.21 41.84,54.48 37.85,50.5 37.85,49.89 37.27,49.3 36.63,49.3 36.48,49.15 36.48,45.46 33.61,42.6 32.7,42.6 32.17,43.12 32.17,44.41 31.97,44.61 31.38,44.61 31.04,44.26 v3(31.04,44.23)
  GND3 w0.102: v4(30.62,44.23) v3(31.04,44.23) ; v4(108.7,66.35) 108.7,66.21 v3(108.89,66.02)
  BOTTOM w0.076: v4(108.7,66.35) 108.7,66.14 108.8,66.05 109.08,66.05 UCPU1.A50
DDI2_PTX_TBRX_N2_C: length 2.6
  BOTTOM w0.076: 29.95,44.31 29.81,44.45 29.15,44.45 28.97,44.27 28.6,44.27 28.43,44.1 28.15,44.1 28.06,44.19 28.06,44.27 28.11,44.33 UT2.AC19
  BOTTOM w0.102: 29.95,44.31 CT32.1
DDI2_PTX_TBRX_N3: length 98.7
  IN3 w0.076: v3(108.37,64.92) 108.48,64.92 108.55,64.84 108.69,64.7 108.69,64.57 108.56,64.45 107.73,64.45 107.4,64.77 106.58,64.77 106.49,64.87 106.47,64.87
  IN3 w0.089: v3(31.01,43.27) 31.7,42.57 32.15,42.57 32.72,42 33.75,42 37.61,45.86 37.61,48.73 38.41,49.53 38.41,50.45 42.36,54.41 42.36,57.63 43.48,58.75 43.48,60.19 45.82,62.53 48.12,62.53 49.67,64.08 52.28,64.08 55.66,67.46 60.41,67.46 60.59,67.28 76.84,67.28 78,66.12 78.82,66.12 79.34,65.6 80.21,65.6 83.64,62.17 90.38,62.17 91.79,63.59 96.83,63.59 98.11,64.87 106.47,64.87
  GND3 w0.102: v4(30.62,43.34) 30.94,43.34 v3(31.01,43.27) ; v3(108.37,64.92) 108.38,64.92 v4(108.7,64.6)
