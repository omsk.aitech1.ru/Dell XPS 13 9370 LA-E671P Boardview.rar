# Allegro board LAE671PR10-1018.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RD30  68_0201_1%  [R_0201]  125.69 16.25 270 top
RD31  68_0201_1%  [R_0201]  86.48 15.98 270 top
RD32  68_0201_1%  [R_0201]  120.11 16.25 270 top
RD33  68_0201_1%  [R_0201]  85.32 15.98 270 top
RD34  68_0201_1%  [R_0201]  118.94 16.25 270 top
RD35  68_0201_1%  [R_0201]  85.9 15.98 270 top
RD36  68_0201_1%  [R_0201]  119.53 16.25 270 top
RD37  68_0201_1%  [R_0201]  84.74 15.98 270 top
RD38  68_0201_1%  [R_0201]  118.02 17.23 180 top
RD39  68_0201_1%  [R_0201]  84.15 15.98 270 top
RD40  68_0201_1%  [R_0201]  118.02 17.81 180 top
RD41  68_0201_1%  [R_0201]  108.32 15.98 270 top
RD42  68_0201_1%  [R_0201]  145.12 16.3 270 top
RD43  68_0201_1%  [R_0201]  107.74 15.98 270 top
RD44  68_0201_1%  [R_0201]  144.54 16.3 270 top
RD45  68_0201_1%  [R_0201]  106.57 15.98 270 top
RD46  68_0201_1%  [R_0201]  143.4 16.3 270 top
RD47  68_0201_1%  [R_0201]  107.15 15.98 270 top
RD48  68_0201_1%  [R_0201]  143.97 16.3 270 top
RD49  68_0201_1%  [R_0201]  105.98 15.98 270 top
RD50  68_0201_1%  [R_0201]  142.13 16.3 270 top
RD51  68_0201_1%  [R_0201]  103.06 15.98 270 top
RD52  68_0201_1%  [R_0201]  138.86 16.31 270 top
RD53  68_0201_1%  [R_0201]  102.48 15.98 270 top
RD54  68_0201_1%  [R_0201]  137.71 16.31 270 top
RD55  68_0201_1%  [R_0201]  101.89 15.98 270 top
RD56  68_0201_1%  [R_0201]  138.28 16.31 270 top
RD57  68_0201_1%  [R_0201]  101.31 15.98 270 top
RD58  68_0201_1%  [R_0201]  136.23 15.95 270 top
RD59  68_0201_1%  [R_0201]  100.73 15.98 270 top
RD60  68_0201_1%  [R_0201]  135.66 15.95 270 top
RD61  80.6_0201_1%~D  [R_0201]  97.23 15.98 270 top
RD62  80.6_0201_1%~D  [R_0201]  133.35 15.65 270 top
RD63  80.6_0201_1%~D  [R_0201]  97.8 15.98 270 top
RD64  80.6_0201_1%~D  [R_0201]  132.77 15.65 270 top
RD65  80.6_0201_1%~D  [R_0201]  91.53 15.98 270 top
RD66  80.6_0201_1%~D  [R_0201]  123.76 16.25 270 top
RD67  80.6_0201_1%~D  [R_0201]  88.24 15.98 270 top
RD68  80.6_0201_1%~D  [R_0201]  124.33 16.25 270 top
RD69  80.6_0201_1%~D  [R_0201]  105.4 15.98 270 top
RD70  80.6_0201_1%~D  [R_0201]  141.56 16.3 270 top
RD71  80.6_0201_1%~D  [R_0201]  103.65 15.98 270 top
RD72  80.6_0201_1%~D  [R_0201]  142.7 16.3 270 top
RD73  80.6_0201_1%~D  [R_0201]  98.39 15.98 270 top
RD74  80.6_0201_1%~D  [R_0201]  132.2 15.65 270 top
RD75  37.4_0201_1%~D  [R_0201]  87.06 15.98 270 top
RD76  37.4_0201_1%~D  [R_0201]  121.26 16.25 270 top
RD77  37.4_0201_1%~D  [R_0201]  87.66 15.98 270 top
RD78  37.4_0201_1%~D  [R_0201]  120.68 16.25 270 top
RD79  37.4_0201_1%~D  [R_0201]  104.81 15.98 270 top
RD80  37.4_0201_1%~D  [R_0201]  140.39 16.3 270 top
RD81  37.4_0201_1%~D  [R_0201]  104.23 15.98 270 top
RD82  37.4_0201_1%~D  [R_0201]  140.97 16.3 270 top
RE2  0_0402_5%  [R_0402]  172.18 9.74 0 bottom
RE4  0_0402_5%~D  [R_0402]  7.24 12.21 270 top
RE5  100K_0402_5%  [R_0402]  9.35 20.96 90 top
RE6  0_0402_5%~D  [R_0402]  8.45 20.96 90 top
RE7  100K_0402_5%  [R_0402]  11.03 30.33 90 top
RE8  100K_0402_5%  [R_0402]  6.96 30.68 270 top
RE9  100K_0402_5%  [R_0402]  5.84 25.88 0 top
RE10  0_0402_5%~D  [R_0402]  5.84 25 0 top
RE11  0_0402_5%~D  [R_0402]  8.93 27.07 0 top
RE27  4.7K_0402_5%  [R_0402]  165.28 16.61 270 bottom
RE29  10K_0402_5%  [R_0402]  165.18 14.83 180 bottom
RE104  0_0402_5%~D  [R_0402]  166.16 13.93 0 bottom
RE105  2.2K_0402_5%  [R_0402]  26.63 8.74 0 bottom
RE106  0_0402_1%  [R0402_0OHM]  24.53 11.18 90 bottom
RE107  2.2K_0402_5%  [R_0402]  26.63 9.63 0 bottom
RE108  100K_0402_5%  [R_0402]  12.56 17.02 180 bottom
RE109  100K_0402_5%  [R_0402]  28.25 16.8 180 bottom
RE111  2.2K_0402_5%  [R_0402]  27.22 22.56 0 top
RE112  2.2K_0402_5%  [R_0402]  27.22 21.6 0 top
RE113  100_0402_1%  [R_0402]  29.33 13.21 270 top
RE115  43K_0402_1%  [R_0402]  26.14 23.34 270 top
RE118  0_0402_5%  [R_0402]  7.02 22.56 270 bottom
RE119  100K_0402_5%  [R_0402]  9.31 17.48 0 top
RE124  10K_0402_5%  [R_0402]  14.14 7.82 270 top
RE125  300_0402_5%  [R_0402]  27.29 18.66 0 bottom
RE126  300_0402_5%  [R_0402]  27.32 17.75 0 bottom
RE127  10K_0402_5%  [R_0402]  11.53 22.83 270 top
RE130  100K_0402_5%  [R_0402]  12.44 9.86 180 top
RE132  0_0402_1%  [R0402_0OHM]  12.79 21.04 270 top
RE133  100K_0402_5%  [R_0402]  26.96 6.83 270 top
RE137  100K_0402_5%  [R_0402]  21.54 7.77 270 top
RE142  100K_0402_5%  [R_0402]  24.04 13.01 0 bottom
RE147  0_0402_1%  [R0402_0OHM]  11.85 19.29 270 top
RE152  1K_0402_5%  [R_0402]  26.94 9.94 0 top
RE153  43_0402_5%  [R_0402]  12.56 17.04 180 top
RE154  100K_0402_5%  [R_0402]  26.94 10.83 0 top
RE155  10K_0402_5%  [R_0402]  29.43 20.78 0 bottom
RE156  100K_0402_5%  [R_0402]  10.77 13.49 270 top
RE157  10K_0402_5%  [R_0402]  29.5 19.56 0 top
RE158  100_0402_1%  [R_0402]  12.56 14.37 180 top
RE159  10K_0402_5%  [R_0402]  29.4 21.36 0 top
RE160  100K_0402_5%  [R_0402]  27.14 20.28 0 top
RE161  100K_0402_5%  [R_0402]  28.92 9.56 0 top
RE162  100K_0402_5%  [R_0402]  11.88 20.12 90 top
RE164  100_0402_1%  [R_0402]  12.55 13.49 270 top
RE168  10K_0402_5%  [R_0402]  26.96 8.6 270 top
RE171  75_0402_5%  [R_0402]  9.08 7.07 270 top
RE172  33_0402_5%  [R_0402]  30.19 13.23 270 top
RE174  100K_0402_5%  [R_0402]  26.71 2.67 90 bottom
RE176  100K_0201_5%  [R_0201]  12.55 11.17 270 top
RE177  0_0402_1%  [R0402_0OHM]  27.4 20.78 0 bottom
RE178  0_0402_1%  [R0402_0OHM]  22.85 7.8 0 top
RE183  10K_0402_5%  [R_0402]  29.99 18.54 0 bottom
RE184  100K_0402_5%  [R_0402]  25.63 6.86 90 bottom
RE185  0_0402_1%  [R0402_0OHM]  11.62 25.05 270 top
RE186  0_0402_5%  [R_0402]  10.73 25.28 90 top
RE187  1K_0402_5%  [R_0402]  26.55 6.88 90 bottom
RE188  0_0402_5%  [R_0402]  3.55 27.9 180 bottom
RE191  0_0402_5%  [R_0402]  5.12 20.4 180 bottom
RE192  0_0402_5%  [R_0402]  2.45 20.4 0 bottom
RE193  0_0402_5%  [R_0402]  8.18 7.07 270 top
RE194  8.2K_0402_5%  [R_0402]  11.65 15.26 0 top
RE195  4.3K_0402_5%  [R_0402]  11.65 18.88 0 bottom
RE196  240K_0402_5%  [R_0402]  30 12.73 270 bottom
RE199  1.58K_0402_1%  [R_0402]  12.44 6.12 180 top
RE200  0_0402_1%  [R0402_0OHM]  12.1 10.24 0 bottom
RE201  10K_0402_5%  [R_0402]  10.89 14.37 0 bottom
RE202  10K_0402_5%  [R_0402]  11.65 16.15 0 bottom
RE203  10K_0402_5%  [R_0402]  10.89 13.48 0 bottom
RE204  100K_0402_5%  [R_0402]  11.65 12.59 0 bottom
RE205  10K_0402_5%  [R_0402]  12.56 11.26 180 bottom
RE206  0_0402_5%  [R_0402]  11.65 15.26 0 bottom
RE209  0_0402_1%  [R0402_0OHM]  12.87 14.38 270 bottom
RE215  8.2K_0402_5%  [R_0402]  28.06 18.5 180 top
RE219  2.2K_0402_5%  [R_0402]  6.72 28.87 270 top
RE222  0_0402_1%  [R0402_0OHM]  5.83 27.96 90 top
RE231  100K_0402_5%  [R_0402]  30.39 11.26 180 top
RE232  2.2K_0402_5%  [R_0402]  171.69 22.66 270 top
RE233  2.2K_0402_5%  [R_0402]  174.92 19.92 0 top
RE234  0_0402_5%  [R_0402]  175.83 18.14 180 top
RE235  4.7K_0402_5%~D  [R_0402]  11.72 4.2 90 top
RE236  4.7K_0402_5%~D  [R_0402]  12.61 4.2 90 top
RE237  0_0402_1%  [R0402_0OHM]  24.6 18.75 0 bottom
RE239  10K_0402_5%  [R_0402]  170.22 19.54 0 top
RE240  10K_0402_5%  [R_0402]  174.92 19.03 0 top
RE241  100K_0402_5%  [R_0402]  113.49 11.91 0 bottom
RE242  2.2K_0402_5%  [R_0402]  28.88 10.55 0 bottom
RE243  2.2K_0402_5%  [R_0402]  28.34 15.91 180 bottom
RE244  100K_0402_5%  [R_0402]  25.44 10.8 90 bottom
RE245  0_0402_1%  [R0402_0OHM]  29.05 14.18 0 top
RE247  100K_0402_5%  [R_0402]  31.54 15.37 90 top
RE248  0_0402_1%  [R0402_0OHM]  5.47 13.04 90 bottom
RE249  100K_0402_5%  [R_0402]  29.35 16.8 270 top
RE250  100K_0402_5%  [R_0402]  29.38 18.7 270 top
RE251  0_0402_1%  [R0402_0OHM]  27.55 15.89 0 top
RE252  0_0402_1%  [R0402_0OHM]  19.78 6.31 0 top
RE253  100K_0402_5%  [R_0402]  151.29 60.13 180 bottom
RE254  100K_0402_5%  [R_0402]  26.83 11.75 0 top
RE255  0_0402_1%  [R0402_0OHM]  278.17 10.57 270 bottom
RE260  100K_0402_5%  [R_0402]  10.66 8.91 90 top
RE261  0_0402_1%  [R0402_0OHM]  11.52 8.99 0 top
RE262  0_0402_1%  [R0402_0OHM]  176.53 14.65 180 bottom
RE263  0_0402_1%  [R0402_0OHM]  170.27 39.19 90 bottom
RE272  10K_0402_5%  [R_0402]  26.82 12.63 0 top
RE273  0_0402_1%  [R0402_0OHM]  271.07 8.92 270 bottom
RE274  0_0402_1%  [R0402_0OHM]  272.12 10.85 270 bottom
RE275  0_0402_1%  [R0402_0OHM]  287.03 56.14 0 bottom
RE280  10K_0402_5%  [R_0402]  28.87 7.94 0 top
RE281  33_0201_1%  [R_0201]  29.58 8.67 180 top
RE282  100K_0402_5%  [R_0402]  11.03 27.32 0 top
RE283  100K_0402_5%  [R_0402]  11.53 24.2 0 bottom
RE284  100K_0402_5%  [R_0402]  11.53 25.08 0 bottom
RE285  100K_0402_5%  [R_0402]  8.92 25.98 0 bottom
RE286  100K_0402_5%  [R_0402]  9.25 17.86 270 bottom
RE287  100K_0402_5%  [R_0402]  7.36 16.02 90 bottom
RE288  100K_0402_5%  [R_0402]  28.63 6.19 0 top
RE289  10K_0402_5%  [R_0402]  28.63 7.07 0 top
RE290  0_0402_5%  [R_0402]  269.24 53.44 180 top
RE291  0_0402_5%  [R_0402]  266.61 56.46 270 top
RH51  10K_0402_5%  [R_0402]  141.06 48.85 0 top
RH52  10K_0402_5%  [R_0402]  139.36 46.87 90 top
RH53  10K_0402_5%  [R_0402]  141.06 47.96 0 top
RH54  10K_0402_5%  [R_0402]  138.47 46.87 90 top
RH55  10K_0402_5%  [R_0402]  141.06 49.74 0 top
RH56  10K_0402_5%  [R_0402]  142 49.26 180 bottom
RH57  10K_0402_5%  [R_0402]  141.06 51.52 0 top
RH58  10K_0402_5%  [R_0402]  139.28 51.52 0 top
RH59  10K_0402_5%  [R_0402]  141.06 50.63 0 top
RH60  10K_0402_5%  [R_0402]  142 50.12 180 bottom
RH61  1K_0402_5%~D  [R_0402]  141.64 45.19 180 bottom
RH62  1K_0402_5%~D  [R_0402]  141.47 43.52 180 top
RH63  1K_0402_5%~D  [R_0402]  141.47 42.63 180 top
RH64  49.9K_0402_1%  [R_0402]  148.98 47.92 270 top
RH65  49.9K_0402_1%  [R_0402]  149.87 47.92 270 top
RH66  100K_0402_5%~D  [R_0402]  143.97 58.63 0 bottom
RH67  100K_0402_5%~D  [R_0402]  143.97 57.68 0 bottom
RH68  SHORT PADS  [SHORTPADS]  146.46 58.76 0 bottom
RH69  SHORT PADS  [SHORTPADS]  146.46 57.49 0 bottom
RH70  100K_0402_5%~D  [R_0402]  140.5 47.02 270 top
RH71  100K_0402_5%  [R_0402]  135.23 50.51 180 top
RH72  100K_0402_5%  [R_0402]  133.33 50.51 180 top
RH73  1K_0402_5%~D  [R_0402]  152.34 39.63 180 top
RH75  10K_0201_5%  [R_0201]  175.5 17.18 270 bottom
RH77  100K_0402_5%~D  [R_0402]  141.39 47.02 270 top
RH79  0_0402_1%  [R0402_0OHM]  166.23 3.18 270 bottom
RH80  0_0402_1%  [R0402_0OHM]  166.23 4.03 90 bottom
RH81  10K_0201_5%  [R_0201]  138.65 70.54 270 bottom
RH82  10K_0201_5%  [R_0201]  137.94 70.54 270 bottom
RH83  100K_0402_5%  [R_0402]  142.03 62.31 180 top
RH84  100K_0201_5%  [R_0201]  141.58 59.7 0 bottom
RH85  100K_0201_5%  [R_0201]  140.97 59.71 180 bottom
RH86  100K_0402_5%  [R_0402]  138.22 39.78 270 bottom
RH87  100K_0402_5%  [R_0402]  140.88 39.78 270 bottom
RH88  100K_0402_5%  [R_0402]  139.99 38.87 90 bottom
RH89  100K_0402_5%  [R_0402]  139.1 38.87 90 bottom
RH90  100K_0402_5%~D  [R_0402]  144.58 57.88 180 top
RN1  2.2K_0402_5%  [R_0402]  146.95 54.81 90 bottom
RN2  2.2K_0402_5%  [R_0402]  145.75 53.14 180 bottom
RP1  33_8P4R_5%  [RP_0804_8P4R]  169.64 42.7 180 bottom
RP2  33_8P4R_5%  [RP_0804_8P4R]  161.95 48.02 90 bottom
RPE4  2.2K_0804_8P4R_5%  [RP_0804_8P4R]  26.8 11.83 0 bottom
RPE6  100K_0804_8P4R_5%  [RP_0804_8P4R]  18.37 22.27 90 top
RPE7  10K_8P4R_5%  [RP_0804_8P4R]  4.68 16.83 180 bottom
RR1  10K_0201_5%  [R_0201]  290.73 30.46 270 bottom
RR4  0_0201_5%  [R0201_0OHM]  286.68 37.26 90 bottom
RR8  6.2K_0402_1%  [R_0402]  286.21 29.45 90 bottom
RR9  10K_0201_5%  [R_0201]  293.04 33.22 180 bottom
RR10  10K_0201_5%  [R_0201]  293.04 32.65 180 bottom
RR15  0_0402_1%  [R0402_0OHM]  50.57 55.32 90 bottom
RR16  0_0402_1%  [R0402_0OHM]  51.35 55.32 90 bottom
RR17  0_0402_1%  [R0402_0OHM]  52.45 58.96 180 bottom
RR18  0_0201_5%  [R_0201]  46.56 58 180 bottom
RR19  0_0201_5%  [R_0201]  46.56 58.63 180 bottom
RR20  0_0201_5%  [R0201_0OHM]  44.87 58.12 90 bottom
RR21  10K_0402_5%  [R_0402]  32.17 61.09 90 top
RR22  0_0402_1%  [R0402_0OHM]  31.28 61.09 90 top
RR23  0_0402_1%  [R0402_0OHM]  33.06 62.01 270 top
RT3  10K_0402_5%  [R_0402]  27.47 52.28 270 top
RT4  10K_0402_5%  [R_0402]  25.54 52.35 180 top
RT5  10K_0402_5%  [R_0402]  26.54 52.29 270 top
RT6  10K_0402_5%  [R_0402]  28.36 52.28 270 top
RT7  3.01K_0402_1%  [R_0402]  23.61 40.25 90 top
RT8  0_0201_5%  [R0201_0OHM]  23.75 56.34 0 bottom
RT9  14K_0402_1%  [R_0402]  24.6 54.32 270 top
RT10  10K_0201_1%  [R_0201]  30.59 51.88 270 bottom
RT11  2.2K_0201_5%  [R_0201]  28.8 55.19 270 bottom
RT12  0_0201_5%  [R_0201]  21.25 54.06 270 top
RT13  2.2K_0201_5%  [R_0201]  28.17 55.19 270 bottom
RT14  10K_0201_1%  [R_0201]  18.7 51.97 0 top
RT15  0_0201_5%  [R_0201]  19.98 54.06 270 top
RT16  0_0201_5%  [R0201_0OHM]  21.4 57.04 90 bottom
RT17  0_0201_5%  [R_0201]  18.71 53.3 0 top
RT18  100_0201_1%  [R_0201]  22.58 57.63 270 bottom
RT19  10K_0201_1%  [R_0201]  24.33 58.25 180 bottom
RT20  10K_0201_1%  [R_0201]  15.23 51.71 0 bottom
RT21  100_0201_1%  [R_0201]  30 51.88 270 bottom
RT22  0_0201_5%  [R_0201]  18.71 52.66 0 top
RT23  14K_0402_1%  [R_0402]  24.47 41.17 270 top
RT24  33_0201_1%  [R_0201]  17.32 38.5 0 bottom
RT25  2.2K_0201_5%  [R_0201]  24.36 55.19 270 bottom
RT26  2.2K_0201_5%  [R_0201]  24.99 55.19 270 bottom
RT27  10K_0201_1%  [R_0201]  30.65 56.19 90 bottom
RT28  4.75K_0402_0.5%  [R_0402]  22.2 50.45 270 top
RT29  10K_0201_1%  [R_0201]  27.53 55.19 270 bottom
RT30  10K_0201_1%  [R_0201]  22.57 58.35 0 bottom
RT31  10K_0201_1%  [R_0201]  22.09 52.6 270 top
RT32  100K_0201_5%  [R_0201]  25.63 55.19 270 bottom
RT33  10K_0201_1%  [R_0201]  21 52.6 270 top
RT34  10K_0201_1%  [R_0201]  24.33 57.61 180 bottom
RT35  100K_0201_5%  [R_0201]  15.23 51.13 0 bottom
RT36  100K_0201_5%  [R_0201]  23.14 52.42 270 top
RT37  1M_0201_1%  [R_0201]  17.01 50.8 180 top
RT38  1M_0201_1%  [R_0201]  17.01 51.39 180 top
RT39  100K_0201_5%  [R_0201]  24.33 56.98 180 bottom
RT40  1M_0201_1%  [R_0201]  19.15 51.34 180 top
RT41  1M_0201_1%  [R_0201]  19.17 50.73 180 top
RT42  499_0201_1%  [R_0201]  20.94 43.31 270 top
RT43  499_0201_1%  [R_0201]  20.36 42.72 90 top
RT44  2.2K_0201_1%  [R_0201]  15.47 64.56 45 top
RT45  2.2K_0201_1%  [R_0201]  19.43 65.81 0 top
RT46  2.2K_0201_1%  [R_0201]  19.43 65.23 0 top
RT47  2.2K_0201_1%  [R_0201]  19.43 63.96 0 top
RT49  0_0603_5%  [R0603_0OHM]  24.8 58.06 270 top
RT50  0_0603_5%  [R0603_0OHM]  29.75 57.88 270 bottom
RT51  0_0402_5%  [R_0402]  18.33 28.2 90 bottom
RT52  0_0402_5%  [R_0402]  13.27 36.25 0 top
RT53  100K_0201_5%  [R_0201]  14.3 32.75 180 top
RT54  100K_0201_5%  [R_0201]  14.3 32.19 180 top
RT55  0_0402_1%  [R0402_0OHM]  19.55 34.88 90 top
RT56  0_0402_1%  [R0402_0OHM]  19.34 28.2 90 bottom
RT57  0_0402_5%  [R_0402]  30.71 30.64 180 bottom
RT58  0_0402_5%  [R_0402]  25.82 38.46 0 top
RT59  100K_0201_5%  [R_0201]  26.27 34.98 0 top
RT60  100K_0201_5%  [R_0201]  26.27 34.42 0 top
RT61  0_0402_5%  [R_0402]  32.09 37.12 90 top
RT62  0_0402_1%  [R0402_0OHM]  30.71 29.75 180 bottom
RT63  0_0402_5%  [R_0402]  281.6 17.99 180 bottom
RT64  0_0402_5%  [R_0402]  281.43 21.03 0 bottom
RT67  0_0402_1%  [R0402_0OHM]  283.17 15.82 180 bottom
RT68  0_0402_1%  [R0402_0OHM]  286.45 22.18 180 bottom
RT69  0_0201_5%  [R_0201]  18.71 53.93 0 top
RT70  0_0603_5%  [R0603_0OHM]  293.89 37.15 180 bottom
RT71  0_0201_5%  [R0201_0OHM]  30.05 50.67 0 bottom
RT72  33_0201_1%  [R_0201]  17.29 39.17 0 bottom
RT80  100K_0201_5%  [R_0201]  32.28 37.58 90 bottom
RT81  100K_0201_5%  [R_0201]  26.02 53.68 180 top
RT82  100K_0201_5%  [R_0201]  31.28 55.24 270 bottom
RT83  100K_0201_5%  [R_0201]  31.15 53.59 270 bottom
RT84  10K_0201_1%  [R_0201]  21.97 57.63 270 bottom
RT88  0_0402_5%~D  [R_0402]  14.5 51.39 90 bottom
RT89  0_0603_5%  [R_0603]  19.92 56.09 0 top
RT90  0_0603_5%  [R_0603]  26.33 56.66 90 top
RT91  0_0201_5%  [R_0201]  31.7 38.2 270 bottom
RT92  0_0201_5%  [R_0201]  25.44 54.26 0 top
RT93  0_0201_5%  [R_0201]  31.92 54.65 90 bottom
RT94  0_0201_5%  [R_0201]  31.92 53 90 bottom
RT95  0_0402_5%  [R_0402]  13.76 26.88 180 top
RT96  0_0402_5%  [R_0402]  26.86 29.67 180 top
RT97  0_0402_5%  [R_0402]  289.96 20.3 90 bottom
RT98  0_0201_5%  [R_0201]  295.12 15.03 180 bottom
RT99  100K_0201_5%  [R_0201]  295.12 14.45 180 bottom
RT100  10K_0201_1%  [R_0201]  21.93 58.34 180 bottom
RT428  0_0402_5%  [R_0402]  23.73 54.32 270 top
RT429  10K_0201_1%  [R_0201]  27.05 54.41 0 top
RT430  10K_0201_1%  [R_0201]  26.93 55.19 270 bottom
RT431  0_0402_5%  [R_0402]  31.35 56.85 0 bottom
RT432  0_0402_5%  [R_0402]  29.87 47.53 90 top
RT433  0_0402_5%  [R_0402]  29.87 51.24 90 top
RTCD1  -  [RB751V40_SC76-2]  251.56 11.25 180 bottom
RTCR1  1.3K_0402_5%~D  [R_0402]  254.55 8 270 bottom
RTCR2  200_0402_0.5%  [R_0402]  252.78 9.58 270 bottom
RZ1  100K_0402_5%  [R_0402]  165.32 13.93 180 bottom
RZ2  0_0402_1%  [R0402_0OHM]  125.2 36.87 90 top
SW1  SSAL120100_3P  [SW_SSAL120100_3P]  156.02 41.75 180 top
SW2  TBFD12KQR_4P  [SW_NTC311-EA1T-A160T_4P]  4.95 35.22 270 top
SW3  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  293.69 65.44 90 top
T1  PAD~D  [TPC12]  110.2 62.82 0 top
T2  PAD~D  [TPC12]  110.86 64.01 0 top
T3  PAD~D  [TPC12]  110 41.41 180 bottom
T4  PAD~D  [TPC12]  110.06 45.87 0 top
T5  PAD~D  [TPC12]  112.93 49.24 0 top
T6  PAD~D  [TPC12]  112.98 47.94 0 top
T7  PAD~D  [TPC12]  130.06 45.73 0 top
T8  PAD~D  [TPC12]  135.52 52.08 0 top
T9  PAD~D  [TPC12]  137.73 40.67 180 bottom
T10  PAD~D  [TPC12]  95.34 66.15 0 top
T11  PAD~D  [TPC12]  128.47 47.94 0 top
T12  PAD~D  [TPC12]  130.72 48.22 0 top
T15  PAD~D  [TPC12]  122.98 38.69 180 bottom
T16  PAD~D  [TPC12]  97.19 38.69 180 bottom
T17  PAD~D  [TPC12]  96.94 40.34 180 bottom
T18  PAD~D  [TPC12]  130.32 49.47 0 top
T19  PAD~D  [TPC12]  130.49 50.86 0 top
T20  PAD~D  [TPC12]  139.53 46.68 180 bottom
T21  PAD~D  [TPC12]  139.94 48.39 180 bottom
T22  PAD~D  [TPC12]  140.4 41.68 180 bottom
T23  PAD~D  [TPC12]  95.54 39.96 180 bottom
T24  PAD~D  [TPC12]  141.58 43.54 180 bottom
T25  PAD~D  [TPC12]  95.57 38.59 180 bottom
T26  PAD~D  [TPC12]  140.51 44.25 180 bottom
T27  PAD~D  [TPC12]  94.02 39.96 180 bottom
T28  PAD~D  [TPC12]  93.92 38.56 180 bottom
T29  PAD~D  [TPC12]  119.78 60.87 0 top
T30  PAD~D  [TPC12]  119.09 51.09 0 top
T31  PAD~D  [TPC12]  102.34 50.89 0 top
T32  PAD~D  [TPC12]  103.57 50.5 0 top
T50  PAD~D  [TPC12]  107.75 69.37 180 bottom
T51  PAD~D  [TPC12]  105.79 67.88 180 bottom
T52  PAD~D  [TPC12]  21.06 21.27 0 top
T56  PAD~D  [TPC12]  19.79 21.09 0 top
T57  PAD~D  [TPC12]  23.4 18.14 180 bottom
T58  PAD~D  [TPC12]  21.22 8.6 0 top
T62  PAD~D  [TPC12]  29.53 14.99 0 top
T68  PAD~D  [TPC12]  10.29 14.82 0 top
T69  PAD~D  [TPC12]  36.25 10.05 0 top
T70  PAD~D  [TPC12]  106.91 71.88 180 bottom
T73  PAD~D  [TPC12]  107.82 70.76 180 bottom
T78  PAD~D  [TPC12]  95.62 69.25 180 bottom
T79  PAD~D  [TPC12]  93.22 66.73 180 bottom
T80  PAD~D  [TPC12]  94.73 70.45 180 bottom
T81  PAD~D  [TPC12]  93.98 65.63 0 top
T82  PAD~D  [TPC12]  93.32 66.16 180 bottom
T83  PAD~D  [TPC12]  93.94 66.69 180 bottom
T84  PAD~D  [TPC12]  93.42 65.21 180 bottom
T85  PAD~D  [TPC12]  92.86 64.47 180 bottom
T86  PAD~D  [TPC12]  92.86 65.21 180 bottom
T87  PAD~D  [TPC12]  93.98 65.21 180 bottom
T88  PAD~D  [TPC12]  93.42 64.47 180 bottom
T89  PAD~D  [TPC12]  93.98 64.47 180 bottom
T101  PAD~D  [TPC12]  49.94 67.28 0 top
T102  PAD~D  [TPC12]  51.26 67.32 0 top
T103  PAD~D  [TPC12]  44.05 68.5 0 top
T104  PAD~D  [TPC12]  42.65 68.57 0 top
T111  PAD~D  [TPC12]  54.81 74.52 0 top
T112  PAD~D  [TPC12]  56.12 74.28 0 top
T113  PAD~D  [TPC12]  54.83 71.44 0 top
T114  PAD~D  [TPC12]  56.16 71.36 0 top
T115  PAD~D  [TPC12]  56.12 68.87 0 top
T116  PAD~D  [TPC12]  55.09 70.14 0 top
T117  PAD~D  [TPC12]  55.01 68.17 0 top
T118  PAD~D  [TPC12]  53.71 67.88 0 top
T119  PAD~D  [TPC12]  32.39 70.34 0 top
T120  PAD~D  [TPC12]  31.08 70.34 0 top
T121  PAD~D  [TPC12]  47.35 67.66 0 top
T122  PAD~D  [TPC12]  48.66 67.35 0 top
T124  PAD~D  [TPC12]  6.85 13.76 0 top
TC1  PAD~D  [TPC12]  18.07 36.8 0 top
TC2  PAD~D  [TPC12]  18.98 37.76 0 top
TC3  PAD~D  [TPC12]  23.03 34.25 0 top
TC5  PAD~D  [TPC12]  18.65 27.11 0 top
TC6  PAD~D  [TPC12]  31.05 39.32 0 top
TC7  PAD~D  [TPC12]  32.67 39.15 0 top
TC8  PAD~D  [TPC12]  33.94 36.86 0 top
TC10  PAD~D  [TPC12]  30.71 29.33 0 top
TC11  PAD~D  [TPC12]  279.8 18.12 270 bottom
TC12  PAD~D  [TPC12]  279.82 16.83 270 bottom
TC45  PAD~D  [TPC12]  291.37 19.12 180 bottom
TC46  PAD~D  [TPC12]  31.84 28.71 0 top
TC47  PAD~D  [TPC12]  28.13 27.24 0 top
TC48  PAD~D  [TPC12]  21.69 28.2 180 bottom
TC49  PAD~D  [TPC12]  15.18 28.05 0 top
TC50  PAD~D  [TPC12]  286.3 20.06 180 bottom
U1  W25Q256FVEIQ_WSON8  [W25Q256FVEIG_WSON8]  156.67 41.91 90 bottom
U4  AZ5125-01H.R7G_SOD523-2  [AZ5125-01HPR7G_SOD523-2]  276.6 55.29 90 top
U5  ALC3271-CG_MQFN48_6X6  [ALC3271-CG_MQFN48_6X6-S]  273.61 59.68 0 bottom
U6  ALC1309-CG_QFN56_7X7  [ALC1309-CG_QFN56_7X7-S]  274.74 12.4 270 top
U7  NPCT650VBCYX  [NPCT650JAAYX_QFN32_5X5-S]  169.25 12.14 0 bottom
U10  -  [AP22850SH8-7_W-DFN2020-8]  162.64 5.3 90 bottom
U11  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  151.9 32.53 90 top
U12  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  221.59 10.71 270 top
U13  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  269.37 48.13 180 top
U14  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  252.38 8.66 270 top
U16  -  [MC74VHC1G09DFT2G_SC70-5]  8.61 21.15 90 bottom
U19  TPS65982D_BGA96  [TPS65982_BGA_96P]  21.48 33.31 270 top
U20  TPS65982D_BGA96  [TPS65982_BGA_96P]  34.03 35.54 270 top
U21  TPS65982D_BGA96  [TPS65982_BGA_96P]  285.02 13.82 0 bottom
U22  -  [AP22850SH8-7_W-DFN2020-8]  282.16 15.03 0 top
U24  MAX34407EWE+T_WLP16  [MAX34407EWE-T_WLP_16P]  172.36 18.83 90 top
U26  -  [TCS40DLR_SOT23F3]  79.39 2.48 90 top
U30  -  [TUSB546_QFN40_4X6]  267.46 25.68 0 top
U31  -  [AP22850SH8-7_W-DFN2020-8]  278.56 36.29 90 bottom
UC2  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  145.31 50.25 0 top
UC4  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  163.83 11.57 90 bottom
UC5  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  7.24 23.03 180 top
UC6  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  8.02 31.85 270 top
UC7  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  9.97 28.11 90 top
UC8  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  9.68 25.8 180 top
UC9  SN74AUP1G07DCKR_SC70  [74AUP1G07GW_TSSOP5]  116.24 14.31 270 bottom
UC10  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  133.37 34.23 90 top
UCPU1  SKL-U_BGA1356  [SKL-U_BGA_1356P-T]  137.56 66.22 0 bottom
UD41  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  100.13 18.42 90 top
UD42  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  84.61 18.42 90 top
UD43  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  135.61 18.42 90 top
UD44  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  120.04 18.42 90 top
UE3  MEC5105_WFBGA169_11X11  [MEC5105_WFBGA_169P]  24.7 10.01 180 top
UE5  74AUP1G07SE-7 SOT353  [74AUP1G07GW_TSSOP5]  30.79 15.29 180 bottom
UE6  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  2.61 25.53 90 bottom
UE7  74AUP1G07SE-7 SOT353  [74AUP1G07GW_TSSOP5]  5.87 26.57 0 bottom
UE8  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  3.99 21.49 180 bottom
UR1  RTS5242-GR_QFN32_4X4  [RTS5242-GR_QFN32_4X4-S]  289.87 31.79 90 bottom
UT2  AR-4C_BGA337  [AR-4C_BGA_337P-T]  18.13 52.61 90 bottom
UT3  W25Q64FVZPIQ  [W25Q80DVZPIG_WSON8]  19.56 66.45 270 bottom
UT4  W25Q64FVZPIQ  [W25Q64FVZPIG_WSON8_6X5]  13.53 33.48 270 bottom
UT6  W25Q64FVZPIQ  [W25Q64FVZPIG_WSON8_6X5]  288.61 19.63 90 top
UZ1  -  [TPS22961DNYR_WSON8]  50.65 60.79 90 top
UZ2  -  [SY6288C20AAC_SOT23-5]  47.47 54.5 270 bottom
UZ3  -  [TPS22961DNYR_WSON8]  141.34 69.21 90 top
UZ4  -  [TPS22961DNYR_WSON8]  149.08 11.19 180 bottom
UZ5  -  [TPS22961DNYR_WSON8]  122.06 37.12 0 top
WL1  8265D2WML.NVQ_108P  [INTEL_8260PD2WMLGPNVQ_108P]  269.77 53.42 270 bottom
YC1  24MHZ_12PF_X3G024000DC1H  [Y_X3G024000DC1H_4P]  119.59 70.52 180 bottom
YC2  9PF 20PPM 9H03280012  [Y_9H03220008_2P]  138.84 36.41 180 top
YC3  24MHZ_12PF_X3G024000DC1H  [Y_X3G024000DC1H_4P]  146.39 62.89 270 bottom
YE2  32.768KHZ_9PF_X1A000141000200  [Y_X1A000141000200_2P]  25.24 5.26 180 top
YT1  25MHZ_20PF_FL2500123Z  [Y_7M25000016_4P]  15.73 39.93 270 bottom

## Library data of the parts
C18 C21 C33 C35-C37 C40-C47 C51 C70 C71 C74 C76 C80-C107 C121-C124 C131 C139 C142 C149 C150 C152 C155 C162 C163 C165 C168 C175 C176 C178-C189 C312 C375-C377 C1052 C1066 C1071 C1072 C1075 C1076 C1079 C1082 C1085 C1086 C1121 C1122 C1128 CA1 CA2 CA5 CA7-CA9 CA12 CA15-CA18 CA20-CA24 CA31-CA37 CA40-CA42 CA45 CA46 CA49 CA51 CA52 CA55 CA60-CA67 CA72-CA79 CA82 CC2 CC4-CC13 CC19 CC26-CC29 CC31 CC35-CC43 CC45 CC46 CC51 CC52 CC57-CC59 CC64-CC69 CC71-CC76 CC78-CC80 CC83 CC89-CC92 CC94 CC96 CC97 CD1 CD3 CD5 CD7 CD8 CD10-CD14 CD16-CD21 CD23-CD28 CD30 CD31 CD33-CD38 CD41 CD42 CD45 CD46 CD48-CD50 CD52-CD54 CD56-CD61 CD63-CD68 CD70 CD71 CD73-CD81 CD92-CD103 CD105-CD108 CE44 CE52 CE53 CE57-CE70 CE72 CE73 CE75 CE76 CE78 CE79 CE83 CE86 CE87 CE89-CE91 CE93-CE95 CH1-CH5 CR1 CR3 CR6 CR7 CR17 CR21 CT62-CT65 CT85 CT86 CT94-CT102 CT105 CZ1-CZ9 MC1 PC100-PC106 PC108 PC109 PC111 PC114 PC116-PC127 PC129 PC130 PC132 PC136 PC137 PC140 PC283 PC284 PC286-PC294 PC301 PC303 PC306 PC313 PC314 PC321 PC329 PC331 PC334 PC335 PC337 PC339-PC343 PC345 PC347-PC352 PC500 PC501 PC511 PC513 PC514 PC525 PC602-PC607 PC609 PC614 PC617 PC618 PC701 PC702 PC706 PC711-PC713 PC800 PC801 PC803 PC804 PC806 PC807 PC900 PC901 PC903 PC904 PC906 PC907 PC1000-PC1002 PC1004-PC1024 PC1026-PC1039 PC1101 PC1106 PC1107 PC1111 PC1114 PC1115 PC1151 PC1154 PC1155 PC1159 PC1160 PC1400 PC1408-PC1412 PC1417-PC1420 PC1500 PC1508-PC1512 PC1517-PC1520 = C_0402
C19 C20 C27-C29 C31 C32 C39 C48-C50 C52-C69 C132 C133 C141 C151 C154 C164 C167 C177 C1018 C1049 C1050 C1054-C1064 C1067 C1069 C1073 C1077 C1080 C1081 C1083 C1087-C1119 C1123 C1126 C1127 CA28 CA29 CA47 CA48 CA53 CA56 CA68-CA71 CA83 CC20-CC25 CC30 CC44 CC47-CC50 CC53-CC56 CC77 CC85-CC88 CC93 CC95 CE42 CE43 CE45 CE48-CE51 CE54-CE56 CE84 CE96 CR2 CR4 CR5 CR8-CR11 CR18-CR20 CR22-CR26 CT1-CT61 CT66-CT78 CT82-CT84 CT87-CT91 PC703 PC1259-PC1305 PC1322-PC1328 PC1338-PC1343 PC1363-PC1377 = C_0201
C30 C34 C140 C143-C146 C148 C153 C156-C159 C161 C166 C169-C172 C174 C1051 C1053 C1065 C1068 C1070 C1120 C1124 C1125 CA3 CA4 CA6 CA10 CA11 CA13 CA14 CA19 CA25-CA27 CA30 CA38 CA39 CA43 CA44 CA50 CA54 CA57-CA59 CA80 CA81 CC32-CC34 CC60-CC63 CC70 CC81 CC82 CD2 CD4 CD6 CD9 CD15 CD22 CD29 CD32 CD39 CD40 CD43 CD44 CD47 CD51 CD55 CD62 CD69 CD72 CD104 CD109 CE46 CE47 CT79-CT81 CT92 CT93 CT103 CT104 PC107 PC115 PC128 PC131 PC133 PC134 PC285 PC295 PC302 PC304 PC305 PC307-PC310 PC312 PC315-PC320 PC322-PC326 PC330 PC332 PC333 PC336 PC346 PC502-PC510 PC512 PC515-PC524 PC526-PC529 PC600 PC601 PC608 PC610-PC613 PC615 PC616 PC700 PC704 PC705 PC707-PC710 PC802 PC805 PC808 PC809 PC902 PC908 PC1003 PC1100 PC1104 PC1105 PC1109 PC1110 PC1112 PC1113 PC1116 PC1119-PC1121 PC1150 PC1152 PC1153 PC1156-PC1158 PC1161-PC1166 PC1200-PC1258 PC1308 PC1310-PC1321 PC1330-PC1337 PC1344-PC1362 PC1378-PC1387 PC1401-PC1406 PC1413-PC1416 PC1501-PC1506 PC1513-PC1516 = C_0603
CLRP1 CMOS1 JTAG2 RH68 RH69 = SHORTPADS: User Part Number: PART#
D2 D10 D20 D73 PD104 PD105 = TVNST52302AB0_SOT523-3
D3 D4 = AZ5B25-01F_DFN0603P2Y2
D5 D6 D13 D75 PD305 PD306 = BAT54CW_SOT323-3
D7-D9 D11 D12 DZ2 DZ3 RTCD1 = RB751V40_SC76-2
D18 D24-D72 = ESD101-B1-02ELS_TSSLP-2-4-2
D21-D23 D78 D79 = BZT52C15LP-7_DFN1006-2-2
D74 MD1-MD3 = PESD5V0U2BT_SOT23-3
DA1-DA4 = ESD203-B1-02EL_TSLP-2-20-2
DA5-DA9 = ESD207-B1-02EL_TSLP-2-19-2
DI1-DI3 = PESD24VS2UT_SOT23-3
FD1-FD4 = FIDUCIAL_C40M80
H1-H7 = H_3P3-G
H8-H10 = H_2P6-G
H11-H13 H16 H17 H21 H23 = H_2P0-G
H14 H18 = H_2P0N
H19 H20 = H_1P8-G
H22 = H_1P8N
H24 = CLIP_C6-PM
H25 = H_1P2X1P7N
H26 = H_1P8X2P3N
JAPS1 = ACES_50506-01841-P01_18P
JAUDIO1 = HRS_BM20B0P810DS0P4V51_10P-T
JCAM1 = ACES_50406-02071-001_20P
JCR1 = T-SOL_158-1090902600_18P-T
JDEG1 JESPI1 = JXT_FP225H-010G1AM_10P
JEDP1 = ACES_50398-04041-001_40P
JFAN1 JFAN2 = ACES_50224-00401-001_4P
JFP2 = ACES_50521-00841-P01_8P-T
JKB1 = E-T_6710K-Y15M-31L_15P
JNGFF1 = LOTES_APCI0146-P004A_75P
JP2 JP3 JPA1 JPA2 PJP601 PJP800 PJP900 = JUMP_43X39
JRTC1 = ACES_50278-00201-001_2P
JSPI1 = ACES_50696-0200M-P01_20P
JSPK1 = ACES_50208-00801-003_8P
JT101 = ACES_50278-01201-001_12P-T
JTP1 = ACES_50506-00841-P01_8P
JUART1 = CVILU_CI1804M1VRA-NH_4P
JUSBC1 JUSBC2 = JAE_DX07SD24JJ3_24P-T
JUSBC3 = JAE_DX07SA24XJ2_24P-T
JXDP1 = E-T_6601K-Y61N-04L_61P
L1 L2 ML1-ML7 = INPAQ_MCM1012B900F06BP_4P
LA1 LA11 = MURAT_BLM15PX600SN1D_2P
LA2 LA4 = MURAT_BLM15BB220SN1D_2P
LA3 = TAI-T_HCB1005KF-600T25_2P
LA5-LA8 = MURAT_BLM15PX181SN1D_2P
LA9 LA10 RA52 RA55 = MURAT_BLM15PX330SN1D_2P
LED1-LED5 = LED_27-11-T1D-CP1Q1RY-3C_2P
LED6 = LED_HT-F196BP5_2P
LT1 = COILC_XFL4012-601MEC_2P
LT2 = CHILI_PBY160808T-300Y-N_2P
LT3-LT7 PL100-PL105 PL500 PL502 PL503 PL600 PL700 PL1101 PL1102 PL1106 PL1108 = TAI-T_HCB2012KF-121T50_2P
PC905 = C_0805
PC1102 PC1103 = C_D
PC1108 = C_D2
PC1117 PC1118 = C_B3
PC1306 PC1307 PC1309 PC1329 PC1529 = C_B2
PD103 PD106 PD107 PD111 PD300 PD301 = RB751V-40_SOD323-2
PD108-PD110 = SE30AFB-M3-6A_SMA2
PH1000-PH1004 PR100 PR101 PR103 PR106 PR107 PR109 PR115 PR118 PR124 PR127-PR130 PR133 PR134 PR139 PR142 PR143 PR148-PR150 PR152-PR155 PR157 PR158 PR166 PR171-PR179 PR203-PR205 PR213-PR215 PR218-PR222 PR228 PR229 PR260-PR264 PR266 PR268-PR270 PR272-PR277 PR301 PR302 PR305 PR307 PR308 PR315 PR319 PR320 PR322-PR328 PR330 PR331 PR333 PR335 PR336 PR340 PR500 PR502 PR504-PR506 PR508 PR509 PR511 PR600 PR601 PR603-PR605 PR608 PR610 PR611 PR701 PR702 PR704-PR706 PR800 PR802 PR804 PR805 PR901 PR902 PR904 PR905 PR1000 PR1001 PR1003-PR1006 PR1008-PR1016 PR1018 PR1019 PR1021-PR1048 PR1050 PR1100 PR1102-PR1104 PR1106-PR1109 PR1111 PR1113 PR1115-PR1119 PR1150 PR1153-PR1155 PR1402 PR1404-PR1408 PR1411-PR1415 PR1417-PR1420 PR1422-PR1424 PR1500-PR1504 PR1506-PR1515 PR1517-PR1527 PR1530 PR1531 R13 R16 R17 R23-R26 R29 R32-R34 R36-R41 R48-R51 R53-R58 R67-R71 R76 R81 R85-R90 R96 R99 R100 R113-R117 R164 R177 R179 R183-R186 R205 R207 R211-R214 R233 R235 R239 R240 R251 R264-R267 R269 R270 R279 R280 R288 R5744 R5747-R5752 R5756 R5759-R5762 R5767-R5769 R5771-R5773 R5782 R5792 R5793 R5797 R5798 R5800-R5809 R5811 R5812 R5814 R5815 R5824 R5827 R5833-R5837 R5839 RA2 RA4-RA7 RA9-RA11 RA13 RA16-RA21 RA23-RA26 RA28-RA32 RA34-RA43 RA46-RA51 RA53 RA54 RA56 RA59-RA62 RA66 RC1-RC13 RC16-RC29 RC37-RC41 RC45-RC47 RC49 RC50 RC53-RC68 RC70 RC71 RC73 RC74 RC76-RC83 RC85 RC86 RC88-RC90 RC92 RC106-RC114 RC116 RC118-RC126 RC150 RC151 RC154-RC156 RC158 RC160 RC161 RC163 RC164 RC166 RC178 RC183 RC184 RC217-RC223 RC226 RC230 RC239 RC240 RC242 RC244 RC249-RC258 RC366-RC374 RC381 RC389 RC390 RC393-RC396 RD1-RD20 RE2 RE4-RE11 RE27 RE29 RE104 RE105 RE107-RE109 RE111-RE113 RE115 RE118 RE119 RE124-RE127 RE130 RE133 RE137 RE142 RE152-RE162 RE164 RE168 RE171 RE172 RE174 RE183 RE184 RE186-RE188 RE191-RE196 RE199 RE201-RE206 RE215 RE219 RE231-RE236 RE239-RE244 RE247 RE249 RE250 RE253 RE254 RE260 RE272 RE280 RE282-RE291 RH51-RH67 RH70-RH73 RH77 RH83 RH86-RH90 RN1 RN2 RR8 RR21 RT3-RT7 RT9 RT23 RT28 RT51 RT52 RT57 RT58 RT61 RT63 RT64 RT88 RT95-RT97 RT428 RT431-RT433 RTCR1 RTCR2 RZ1 = R_0402
PJP500 PJP501 PJP600 = JUMP_43X118
PJP700 PJP1400 PJP1401 = JUMP_43X79
PL301 PL1100 PL1150 = CHILI_MHCB06030-2R2M-C1L_2P
PL302 = MAG_MMD-04BZ-1R0M-V1_2P
PL501 = MAG_MMD-05CZN1R5M-V1L_2P
PL504 = CYNTE_PCMC063T-1R5MN_2P
PL601 PL701 = L_5X5X3_M_2P
PL800 PL900 PL1400 PL1402 PL1500 PL1502 = TAI-T_HCB1608KF-121T3_L0603_2P
PL801 PL901 PL1401 PL1403 PL1501 PL1503 = CHILI_HEI322512A-2R2M-Q8_2P
PL1103 PL1107 = NEC_MPCH0730LR15_2P
PL1151 = CYNTE_PCMB053T-R47MS_2P
PQ100 PQ101 PQ113 PQ114 PQ153 PQ155 PQ304 = AON7405_DFN8-5
PQ104 PQ115 PQ123 PQ124 PQ133 PQ135 PQ150 PQ158 = SI1303DL-T1-E3_SOT323-3
PQ106 PQ108 PQ118 PQ119 PQ156 PQ157 PQ199-PQ201 PQ300 = L2N7002WT1G_SC70-3
PQ109 PQ117 PQ120-PQ122 PQ125 PQ127-PQ129 PQ134 PQ136 PQ149 PQ151 QC1 QC2 QE2 QH1 QH2 = DMN66D0LDW-7_SOT363-6
PQ126 = DMN65D8LW-7_SOT323-3
PQ302 PQ307 = AON6992_DFN5X6D-8-7
PR102 PR306 PR311 PR602 PR612 PR803 PR1105 PR1112 PR1114 PR1152 PR1156 PR1158 PR1403 PR1416 PR1505 PR1516 R19 R42 R281 R282 R5826 R5838 RT89 RT90 = R_0603
PR108 PR111 PR114 PR117 PR120 PR122 PR123 PR126 PR132 PR135-PR138 PR144 PR145 PR151 PR156 PR170 PR192 PR195 PR196 PR200-PR202 PR206-PR209 PR217 PR224 PR230 PR259 PR267 PR271 PR278 PR313 PR314 PR318 PR321 PR329 PR332 PR334 PR341-PR346 PR503 PR510 PR606 PR607 PR609 PR703 PR707 PR801 PR806 PR900 PR906 PR1002 PR1007 PR1017 PR1020 PR1049 PR1159 PR1400 PR1401 PR1409 PR1421 R1 R30 R31 R35 R46 R47 R82 R91 R180 R182 R208 R210 R5746 R5758 R5766 R5794-R5796 R5823 RA1 RA3 RA22 RA27 RA33 RA57 RA58 RA63 RA64 RC30-RC36 RC48 RC69 RC87 RC115 RC117 RC157 RC159 RC162 RC179 RC379 RC383 RC384 RC386-RC388 RE106 RE132 RE147 RE177 RE178 RE185 RE200 RE209 RE222 RE237 RE245 RE248 RE251 RE252 RE255 RE261-RE263 RE273-RE275 RH79 RH80 RR15-RR17 RR22 RR23 RT55 RT56 RT62 RT67 RT68 RZ2 = R0402_0OHM
PR110 PR112 PR119 PR121 PR140 PR141 R3 R4 R22 R44 R45 R62 R63 R165-R170 R181 R191 R192 R209 R218 R220 R223-R228 R237 R252 R271 R274 R283-R286 R5745 R5753-R5755 R5757 R5763-R5765 R5778-R5781 R5783-R5786 R5789 R5790 R5816-R5821 R5825 RA8 RA12 RA14 RA15 RC52 RC165 RC181 RC182 RC225 RC227-RC229 RC231-RC238 RC241 RC243 RC245-RC248 RC375-RC378 RC391 RD21-RD82 RE176 RE281 RH75 RH81 RH82 RH84 RH85 RR1 RR9 RR10 RR18 RR19 RT10-RT15 RT17-RT22 RT24-RT27 RT29-RT47 RT53 RT54 RT59 RT60 RT69 RT72 RT80-RT84 RT91-RT94 RT98-RT100 RT429 RT430 = R_0201
PR300 = R_1206_4P-D
PR303 PR309 PR316 PR317 PR501 PR507 PR700 PR1101 PR1110 PR1151 PR1157 = R_1206
PR304 = R_2512
PR512 R2 R6 R18 R73 R79 R80 R83 R84 R92-R95 R97 R98 R101-R104 R253 R268 R272 RC152 RC153 RC167-RC176 RC382 RT49 RT50 RT70 = R0603_0OHM
PR903 PR1528 PR1529 R275-R278 RA44 RA45 = R_0805
PT100-PT109 T1-T12 T15-T32 T50-T52 T56-T58 T62 T68-T70 T73 T78-T89 T101-T104 T111-T122 T124 TC1-TC3 TC5-TC8 TC10-TC12 TC45-TC50 = TPC12
PU101 = RT9069-33GB_SOT23-5
PU300 = ISL88738HRTZ-T_TQFN32_4X4
PU301 = MC74VHC1G08DFT2G_SC70-5
PU500 = SY8286BRAC_QFN20_3X3
PU501 = SY8286CRAC_QFN20_3X3
PU600 = SY8210AQVC_QFN19_4X3
PU700 = SY8286RAC_QFN20_3X3
PU800 PU900 = TLV62150RGTR_QFN16_3X3-S
PU1000 = ISL95829AHRTZ-T_TQFN48_6X6
PU1100 PU1101 PU1150 = AOZ5049QI_QFN24_5X3P5-S
PU1151 = AOZ5029QI_QFN24_5X3P5
PU1400 = TPS62134ARGT_QFN16_3X3-S
PU1401 = TPS62134BRGT_QFN16_3X3-S
PU1500 PU1501 = TPS62134CRGT_QFN16_3X3-S
Q4 QE10 QE13 QE23 QR1 = L2N7002WT1G_SC-70-3
QE11 = DMN65D8LDW-7_SOT363-6
QE12 QE14-QE16 QE19-QE22 = MMBT3904WT1G_SC70-3
QZ1 = DMG2301U-7_SOT23-3
R14 R15 R173 R175 R176 R178 R187 R189 R201 R203 R204 R206 R215 R216 R229 R230 R232 R234 R236 R238 R255-R262 R5770 R5774-R5777 R5787 R5788 R5791 RR4 RR20 RT8 RT16 RT71 = R0201_0OHM
RA65 RC177 = MURAT_BLM18EG221SN1D_2P
RP1 RP2 RPE4 RPE6 RPE7 = RP_0804_8P4R
SW1 = SW_SSAL120100_3P
SW2 = SW_NTC311-EA1T-A160T_4P
SW3 = SW_SKRBAAE010_4P
U1 = W25Q256FVEIG_WSON8
U4 = AZ5125-01HPR7G_SOD523-2
U5 = ALC3271-CG_MQFN48_6X6-S
U6 = ALC1309-CG_QFN56_7X7-S
U7 = NPCT650JAAYX_QFN32_5X5-S
U10 U22 U31 = AP22850SH8-7_W-DFN2020-8
U11-U14 = TPS22966DPUR_SON14_2X3
U16 = MC74VHC1G09DFT2G_SC70-5
U19-U21 = TPS65982_BGA_96P
U24 = MAX34407EWE-T_WLP_16P
U26 = TCS40DLR_SOT23F3
U30 = TUSB546_QFN40_4X6
UC2 UC4-UC8 UC10 UE6 UE8 = TC7SH08FU_SSOP5
UC9 UE5 UE7 = 74AUP1G07GW_TSSOP5
UCPU1 = SKL-U_BGA_1356P-T
UD41-UD44 = H9CCNNN8JTMLAR-NTM_FBGA_178P
UE3 = MEC5105_WFBGA_169P
UR1 = RTS5242-GR_QFN32_4X4-S
UT2 = AR-4C_BGA_337P-T
UT3 = W25Q80DVZPIG_WSON8
UT4 UT6 = W25Q64FVZPIG_WSON8_6X5
UZ1 UZ3-UZ5 = TPS22961DNYR_WSON8
UZ2 = SY6288C20AAC_SOT23-5
WL1 = INTEL_8260PD2WMLGPNVQ_108P
YC1 YC3 = Y_X3G024000DC1H_4P
YC2 = Y_9H03220008_2P
YE2 = Y_X1A000141000200_2P
YT1 = Y_7M25000016_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50208-00801-003_8P
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0) 5(-3.2,0) 6(-4,0) 7(-4.8,0) 8(-5.6,0)
  rect 1.194x1.702 smd: 9(1.3,-1.95) 10(-6.9,-1.95)
ACES_50224-00401-001_4P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 1.194x1.803 smd: 5(4.3,-3.875) 6(-1.3,-3.875)
ACES_50278-00201-001_2P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0)
  rect 1.295x3.353 smd: 3(-2.85,-4.925) 4(4.1,-4.925)
ACES_50278-01201-001_12P-T
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0) 7(7.5,0) 8(8.75,0) 9(10,0) 10(11.25,0) 11(12.5,0) 12(13.75,0)
  rect 1.295x3.353 smd: 13(-2.85,-4.925) 14(16.6,-4.925)
ACES_50398-04041-001_40P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.194x3.2 smd: 41(-2.4,1.95) 45(21.9,1.95)
  rect 2.311x1.295 smd: 42(0.85,3.9) 43(9.75,3.9) 44(18.65,3.9)
ACES_50406-02071-001_20P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.194x2.692 smd: 21(-2.4,1.95) 22(11.9,1.95)
  rect 2.311x1.295 smd: 23(0.85,3.9) 24(8.65,3.9)
ACES_50506-00841-P01_8P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0)
  rect 0.991x2.007 smd: 9(-2.1,-3.05) 10(5.6,-3.05)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50521-00841-P01_8P-T
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0)
  rect 0.406x0.787 smd: 9(-4.5,-2.65) 10(1,-2.65)
ACES_50696-0200M-P01_20P
  oval 0.305x0.787 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0)
  rect 0.406x0.787 smd: 21(1,-2.5) 22(-10.5,-2.5)
ALC1309-CG_QFN56_7X7-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7.1,-5.2) 30(7.1,-4.8) 31(7.1,-4.4) 32(7.1,-4) 33(7.1,-3.6) 34(7.1,-3.2) 35(7.1,-2.8) 36(7.1,-2.4) 37(7.1,-2) 38(7.1,-1.6) 39(7.1,-1.2) 40(7.1,-0.8) 41(7.1,-0.4) 42(7.1,0)
  oval 0.203x0.889 smd: 15(0.95,-6.15) 16(1.35,-6.15) 17(1.75,-6.15) 18(2.15,-6.15) 19(2.55,-6.15) 20(2.95,-6.15) 21(3.35,-6.15) 22(3.75,-6.15) 23(4.15,-6.15) 24(4.55,-6.15) 25(4.95,-6.15) 26(5.35,-6.15) 27(5.75,-6.15) 28(6.15,-6.15) 43(6.15,0.95) 44(5.75,0.95) 45(5.35,0.95) 46(4.95,0.95) 47(4.55,0.95) 48(4.15,0.95) 49(3.75,0.95) 50(3.35,0.95) 51(2.95,0.95) 52(2.55,0.95) 53(2.15,0.95) 54(1.75,0.95) 55(1.35,0.95) 56(0.95,0.95)
  rect 4.597x4.597 smd: 57(3.55,-2.6)
ALC3271-CG_MQFN48_6X6-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
AON6992_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.62)
AON7405_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AOZ5029QI_QFN24_5X3P5
  oval 0.254x0.762 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0)
  rect 3.15x1.473 smd: 6(1.47,1.31)
  custom 0.588x0.588 smd: 7(1,2.425)
  rect 1.956x0.864 smd: 8(1.25,4.787)
  oval 0.762x0.254 smd: 9(-0.675,2.925) 10(-0.675,2.425) 11(-0.675,1.925) 12(-0.675,1.425) 13(-0.675,0.925) 14(-0.675,0.425)
AOZ5049QI_QFN24_5X3P5-S
  oval 0.254x0.762 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0)
  rect 3.15x1.473 smd: 6(1.47,1.31)
  custom 0.588x0.588 smd: 7(1,2.425)
  rect 1.956x0.864 smd: 8(1.25,4.787)
  oval 0.762x0.254 smd: 9(-0.675,2.925) 10(-0.675,2.425) 11(-0.675,1.925) 12(-0.675,1.425) 13(-0.675,0.925) 14(-0.675,0.425)
AP22850SH8-7_W-DFN2020-8
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.21) 6(1,2.21) 7(0.5,2.21) 8(0,2.21)
  rect 1.6x0.889 smd: 9(0.75,1.105)
AR-4C_BGA_337P-T
  round 0.254 smd: A1(0,0) A23(-10.12,0) AA2(-0.46,9.2) AA22(-9.66,9.2) AB2(-0.46,9.66) AB3(-0.92,9.66) AB4(-1.38,9.66) AB5(-1.84,9.66) AB6(-2.3,9.66) AB7(-2.76,9.66) AB8(-3.22,9.66) AB9(-3.68,9.66) AB10(-4.14,9.66) AB11(-4.6,9.66) AB12(-5.06,9.66) AB13(-5.52,9.66) AB14(-5.98,9.66) AB15(-6.44,9.66) AB16(-6.9,9.66) AB17(-7.36,9.66) AB18(-7.82,9.66) AB19(-8.28,9.66) AB20(-8.74,9.66) AB21(-9.2,9.66) AB22(-9.66,9.66) AC1(0,10.12) AC23(-10.12,10.12) B2(-0.46,0.46) B3(-0.92,0.46) B4(-1.38,0.46) B5(-1.84,0.46) B6(-2.3,0.46) B7(-2.76,0.46) B8(-3.22,0.46) B9(-3.68,0.46) B10(-4.14,0.46) B11(-4.6,0.46) B12(-5.06,0.46) B13(-5.52,0.46) B14(-5.98,0.46) B15(-6.44,0.46) B16(-6.9,0.46) B17(-7.36,0.46) B18(-7.82,0.46) B19(-8.28,0.46) B20(-8.74,0.46) B21(-9.2,0.46) B22(-9.66,0.46) C2(-0.46,0.92) C22(-9.66,0.92) D2(-0.46,1.38) D4(-1.16,1.16) D5(-1.81,1.16) D6(-2.46,1.16) D8(-3.11,1.16) D9(-3.76,1.16) D11(-4.41,1.16) D12(-5.06,1.16) D13(-5.71,1.16) D15(-6.36,1.16) D16(-7.01,1.16) D18(-7.66,1.16) D19(-8.31,1.16) D20(-8.96,1.16) D22(-9.66,1.38) E2(-0.46,1.84) E4(-1.16,1.81) E5(-1.81,1.81) E6(-2.46,1.81) E8(-3.11,1.81) E9(-3.76,1.81) E11(-4.41,1.81) E12(-5.06,1.81) E13(-5.71,1.81) E15(-6.36,1.81) E16(-7.01,1.81) E18(-7.66,1.81) E19(-8.31,1.81) E20(-8.96,1.81) E22(-9.66,1.84) F2(-0.46,2.3) F4(-1.16,2.46) F5(-1.81,2.46) F6(-2.46,2.46) F8(-3.11,2.46) F9(-3.76,2.46) F11(-4.41,2.46) F12(-5.06,2.46) F13(-5.71,2.46) F15(-6.36,2.46) F16(-7.01,2.46) F18(-7.66,2.46) F19(-8.31,2.46) F20(-8.96,2.46) F22(-9.66,2.3) G2(-0.46,2.76) G22(-9.66,2.76) H2(-0.46,3.22) H4(-1.16,3.11) H5(-1.81,3.11) H6(-2.46,3.11) H8(-3.11,3.11) H9(-3.76,3.11) H11(-4.41,3.11) H12(-5.06,3.11) H13(-5.71,3.11) H15(-6.36,3.11) H16(-7.01,3.11) H18(-7.66,3.11) H19(-8.31,3.11) H20(-8.96,3.11) H22(-9.66,3.22) J2(-0.46,3.68) J4(-1.16,3.76) J5(-1.81,3.76) J6(-2.46,3.76) J8(-3.11,3.76) J9(-3.76,3.76) J11(-4.41,3.76) J12(-5.06,3.76) J13(-5.71,3.76) J15(-6.36,3.76) J16(-7.01,3.76) J18(-7.66,3.76) J19(-8.31,3.76) J20(-8.96,3.76) J22(-9.66,3.68) K2(-0.46,4.14) K22(-9.66,4.14) L2(-0.46,4.6) L4(-1.16,4.41) L5(-1.81,4.41) L6(-2.46,4.41) L8(-3.11,4.41) L9(-3.76,4.41) L11(-4.41,4.41) L12(-5.06,4.41) L13(-5.71,4.41) L15(-6.36,4.41) L16(-7.01,4.41) L18(-7.66,4.41) L19(-8.31,4.41) L20(-8.96,4.41) L22(-9.66,4.6) M2(-0.46,5.06) M4(-1.16,5.06) M5(-1.81,5.06) M6(-2.46,5.06) M8(-3.11,5.06) M9(-3.76,5.06) M11(-4.41,5.06) M12(-5.06,5.06) M13(-5.71,5.06) M15(-6.36,5.06) M16(-7.01,5.06) M18(-7.66,5.06) M19(-8.31,5.06) M20(-8.96,5.06) M22(-9.66,5.06) N2(-0.46,5.52) N4(-1.16,5.71) N5(-1.81,5.71) N6(-2.46,5.71) N8(-3.11,5.71) N9(-3.76,5.71) N11(-4.41,5.71) N12(-5.06,5.71) N13(-5.71,5.71) N15(-6.36,5.71) N16(-7.01,5.71) N18(-7.66,5.71) N19(-8.31,5.71) N20(-8.96,5.71) N22(-9.66,5.52) P2(-0.46,5.98) P22(-9.66,5.98) R2(-0.46,6.44) R4(-1.16,6.36) R5(-1.81,6.36) R6(-2.46,6.36) R8(-3.11,6.36) R9(-3.76,6.36) R11(-4.41,6.36) R12(-5.06,6.36) R13(-5.71,6.36) R15(-6.36,6.36) R16(-7.01,6.36) R18(-7.66,6.36) R19(-8.31,6.36) R20(-8.96,6.36) R22(-9.66,6.44) T2(-0.46,6.9) T4(-1.16,7.01) T5(-1.81,7.01) T6(-2.46,7.01) T8(-3.11,7.01) T9(-3.76,7.01) T11(-4.41,7.01) T12(-5.06,7.01) T13(-5.71,7.01) T15(-6.36,7.01) T16(-7.01,7.01) T18(-7.66,7.01) T19(-8.31,7.01) T20(-8.96,7.01) T22(-9.66,6.9) U2(-0.46,7.36) U22(-9.66,7.36) V2(-0.46,7.82) V4(-1.16,7.66) V5(-1.81,7.66) V6(-2.46,7.66) V8(-3.11,7.66) V9(-3.76,7.66) V11(-4.41,7.66) V12(-5.06,7.66) V13(-5.71,7.66) V15(-6.36,7.66) V16(-7.01,7.66) V18(-7.66,7.66) V19(-8.31,7.66) V20(-8.96,7.66) V22(-9.66,7.82) W2(-0.46,8.28) W4(-1.16,8.31) W5(-1.81,8.31) W6(-2.46,8.31) W8(-3.11,8.31) W9(-3.76,8.31) W11(-4.41,8.31) W12(-5.06,8.31) W13(-5.71,8.31) W15(-6.36,8.31) W16(-7.01,8.31) W18(-7.66,8.31) W19(-8.31,8.31) W20(-8.96,8.31) W22(-9.66,8.28) Y2(-0.46,8.74) Y4(-1.16,8.96) Y5(-1.81,8.96) Y6(-2.46,8.96) Y8(-3.11,8.96) Y9(-3.76,8.96) Y11(-4.41,8.96) Y12(-5.06,8.96) Y13(-5.71,8.96) Y15(-6.36,8.96) Y16(-7.01,8.96) Y18(-7.66,8.96) Y19(-8.31,8.96) Y20(-8.96,8.96) Y22(-9.66,8.74)
  oval 0.178x0.33 smd: A2(-0.46,0) A3(-0.92,0) A4(-1.38,0) A5(-1.84,0) A6(-2.3,0) A7(-2.76,0) A8(-3.22,0) A9(-3.68,0) A10(-4.14,0) A11(-4.6,0) A12(-5.06,0) A13(-5.52,0) A14(-5.98,0) A15(-6.44,0) A16(-6.9,0) A17(-7.36,0) A18(-7.82,0) A19(-8.28,0) A20(-8.74,0) A21(-9.2,0) A22(-9.66,0) AC2(-0.46,10.12) AC3(-0.92,10.12) AC4(-1.38,10.12) AC5(-1.84,10.12) AC6(-2.3,10.12) AC7(-2.76,10.12) AC8(-3.22,10.12) AC9(-3.68,10.12) AC10(-4.14,10.12) AC11(-4.6,10.12) AC12(-5.06,10.12) AC13(-5.52,10.12) AC14(-5.98,10.12) AC15(-6.44,10.12) AC16(-6.9,10.12) AC17(-7.36,10.12) AC18(-7.82,10.12) AC19(-8.28,10.12) AC20(-8.74,10.12) AC21(-9.2,10.12) AC22(-9.66,10.12)
  oval 0.33x0.178 smd: AA1(0,9.2) AA23(-10.12,9.2) AB1(0,9.66) AB23(-10.12,9.66) B1(0,0.46) B23(-10.12,0.46) C1(0,0.92) C23(-10.12,0.92) D1(0,1.38) D23(-10.12,1.38) E1(0,1.84) E23(-10.12,1.84) F1(0,2.3) F23(-10.12,2.3) G1(0,2.76) G23(-10.12,2.76) H1(0,3.22) H23(-10.12,3.22) J1(0,3.68) J23(-10.12,3.68) K1(0,4.14) K23(-10.12,4.14) L1(0,4.6) L23(-10.12,4.6) M1(0,5.06) M23(-10.12,5.06) N1(0,5.52) N23(-10.12,5.52) P1(0,5.98) P23(-10.12,5.98) R1(0,6.44) R23(-10.12,6.44) T1(0,6.9) T23(-10.12,6.9) U1(0,7.36) U23(-10.12,7.36) V1(0,7.82) V23(-10.12,7.82) W1(0,8.28) W23(-10.12,8.28) Y1(0,8.74) Y23(-10.12,8.74)
AZ5B25-01F_DFN0603P2Y2
  rect 0.305x0.356 smd: 1(0,0) 2(0.4,0)
AZ5125-01HPR7G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.5,0)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BZT52C15LP-7_DFN1006-2-2
  rect 0.406x0.711 smd: 1(0,0) 2(0.7,0)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_B3
  rect 1.346x2.692 smd: 1(0,0) 2(2.75,0)
C_D
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
CHILI_HEI322512A-2R2M-Q8_2P
  rect 1.194x2.794 smd: 1(0,0) 2(2.9,0)
CHILI_MHCB06030-2R2M-C1L_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CHILI_PBY160808T-300Y-N_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
CLIP_C6-PM
  round 5.994 smd: 1(0,0)
COILC_XFL4012-601MEC_2P
  rect 0.991x3.404 smd: 1(0,0) 2(2.37,0)
CVILU_CI1804M1VRA-NH_4P
  oval 0.508x0.991 smd: 1(0,-0.05) 2(-0.8,-0.05) 3(-1.6,-0.05) 4(-2.4,-0.05)
  rect 1.194x1.702 smd: 5(-3.7,1.4) 6(1.3,1.4)
CYNTE_PCMB053T-R47MS_2P
  rect 2.007x2.489 smd: 1(0,0) 2(5,0)
CYNTE_PCMC063T-1R5MN_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
DMG2301U-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
E-T_6601K-Y61N-04L_61P
  oval 0.305x1.245 smd: 1(0,0) 3(0.6,0) 5(1.2,0) 7(1.8,0) 9(2.4,0) 11(3,0) 13(3.6,0) 15(4.2,0) 17(4.8,0) 19(5.4,0) 21(6,0) 23(6.6,0) 25(7.2,0) 27(7.8,0) 29(8.4,0) 31(9,0) 33(9.6,0) 35(10.2,0) 37(10.8,0) 39(11.4,0) 41(12,0) 43(12.6,0) 45(13.2,0) 47(13.8,0) 49(14.4,0) 51(15,0) 53(15.6,0) 55(16.2,0) 57(16.8,0) 59(17.4,0) 61(18,0)
  oval 0.305x0.94 smd: 2(0.3,3.25) 4(0.9,3.25) 6(1.5,3.25) 8(2.1,3.25) 10(2.7,3.25) 12(3.3,3.25) 14(3.9,3.25) 16(4.5,3.25) 18(5.1,3.25) 20(5.7,3.25) 22(6.3,3.25) 24(6.9,3.25) 26(7.5,3.25) 28(8.1,3.25) 30(8.7,3.25) 32(9.3,3.25) 34(9.9,3.25) 36(10.5,3.25) 38(11.1,3.25) 40(11.7,3.25) 42(12.3,3.25) 44(12.9,3.25) 46(13.5,3.25) 48(14.1,3.25) 50(14.7,3.25) 52(15.3,3.25) 54(15.9,3.25) 56(16.5,3.25) 58(17.1,3.25) 60(17.7,3.25)
  rect 0.305x1.143 smd: 62(-0.65,0.6) 63(18.65,0.6)
E-T_6710K-Y15M-31L_15P
  oval 0.305x0.965 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0)
  rect 0.305x1.143 smd: 16(7.885,-2.965) 17(-0.885,-2.965)
ESD101-B1-02ELS_TSSLP-2-4-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
ESD203-B1-02EL_TSLP-2-20-2
  rect 0.356x0.61 smd: 1(0,0) 2(0.65,0)
ESD207-B1-02EL_TSLP-2-19-2
  rect 0.356x0.61 smd: 1(0,0) 2(0.65,0)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
H9CCNNN8JTMLAR-NTM_FBGA_178P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A6(4,0) A8(5.601,0) A9(6.401,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) B1(0,-0.65) B2(0.8,-0.65) B3(1.6,-0.65) B4(2.4,-0.65) B5(3.2,-0.65) B6(4,-0.65) B8(5.601,-0.65) B9(6.401,-0.65) B10(7.201,-0.65) B11(8.001,-0.65) B12(8.801,-0.65) B13(9.601,-0.65) C2(0.8,-1.3) C3(1.6,-1.3) C4(2.4,-1.3) C5(3.2,-1.3) C6(4,-1.3) C8(5.601,-1.3) C9(6.401,-1.3) C10(7.201,-1.3) C11(8.001,-1.3) C12(8.801,-1.3) D2(0.8,-1.95) D3(1.6,-1.95) D4(2.4,-1.95) D5(3.2,-1.95) D6(4,-1.95) D8(5.601,-1.95) D9(6.401,-1.95) D10(7.201,-1.95) D11(8.001,-1.95) D12(8.801,-1.95) E2(0.8,-2.6) E3(1.6,-2.6) E4(2.4,-2.6) E5(3.2,-2.6) E6(4,-2.6) E8(5.601,-2.6) E9(6.401,-2.6) E10(7.201,-2.6) E11(8.001,-2.6) E12(8.801,-2.6) F2(0.8,-3.25) F3(1.6,-3.25) F4(2.4,-3.25) F5(3.2,-3.25) F6(4,-3.25) F8(5.601,-3.25) F9(6.401,-3.25) F10(7.201,-3.25) F11(8.001,-3.25) F12(8.801,-3.25) G2(0.8,-3.9) G3(1.6,-3.9) G4(2.4,-3.9) G5(3.2,-3.9) G6(4,-3.9) G8(5.601,-3.9) G9(6.401,-3.9) G10(7.201,-3.9) G11(8.001,-3.9) G12(8.801,-3.9) H2(0.8,-4.55) H3(1.6,-4.55) H4(2.4,-4.55) H5(3.2,-4.55) H6(4,-4.55) H8(5.601,-4.55) H9(6.401,-4.55) H10(7.201,-4.55) H11(8.001,-4.55) H12(8.801,-4.55) J2(0.8,-5.2) J3(1.6,-5.2) J4(2.4,-5.2) J5(3.2,-5.2) J6(4,-5.2) J8(5.601,-5.2) J9(6.401,-5.2) J10(7.201,-5.2) J11(8.001,-5.2) J12(8.801,-5.2) K2(0.8,-5.85) K3(1.6,-5.85) K4(2.4,-5.85) K5(3.2,-5.85) K6(4,-5.85) K8(5.601,-5.85) K9(6.401,-5.85) K10(7.201,-5.85) K11(8.001,-5.85) K12(8.801,-5.85) L2(0.8,-6.5) L3(1.6,-6.5) L4(2.4,-6.5) L5(3.2,-6.5) L6(4,-6.5) L8(5.601,-6.5) L9(6.401,-6.5) L10(7.201,-6.5) L11(8.001,-6.5) L12(8.801,-6.5) M2(0.8,-7.15) M3(1.6,-7.15) M4(2.4,-7.15) M5(3.2,-7.15) M6(4,-7.15) M8(5.601,-7.15) M9(6.401,-7.15) M10(7.201,-7.15) M11(8.001,-7.15) M12(8.801,-7.15) N2(0.8,-7.8) N3(1.6,-7.8) N4(2.4,-7.8) N5(3.2,-7.8) N6(4,-7.8) N8(5.601,-7.8) N9(6.401,-7.8) N10(7.201,-7.8) N11(8.001,-7.8) N12(8.801,-7.8) P2(0.8,-8.45) P3(1.6,-8.45) P4(2.4,-8.45) P5(3.2,-8.45) P6(4,-8.45) P8(5.601,-8.45) P9(6.401,-8.45) P10(7.201,-8.45) P11(8.001,-8.45) P12(8.801,-8.45) R2(0.8,-9.1) R3(1.6,-9.1) R4(2.4,-9.1) R5(3.2,-9.1) R6(4,-9.1) R8(5.601,-9.1) R9(6.401,-9.1) R10(7.201,-9.1) R11(8.001,-9.1) R12(8.801,-9.1) T1(0,-9.75) T2(0.8,-9.75) T3(1.6,-9.75) T4(2.4,-9.75) T5(3.2,-9.75) T6(4,-9.75) T8(5.601,-9.75) T9(6.401,-9.75) T10(7.201,-9.75) T11(8.001,-9.75) T12(8.801,-9.75) T13(9.601,-9.75) U1(0,-10.4) U2(0.8,-10.4) U3(1.6,-10.4) U4(2.4,-10.4) U5(3.2,-10.4) U6(4,-10.4) U8(5.601,-10.4) U9(6.401,-10.4) U10(7.201,-10.4) U11(8.001,-10.4) U12(8.801,-10.4) U13(9.601,-10.4)
