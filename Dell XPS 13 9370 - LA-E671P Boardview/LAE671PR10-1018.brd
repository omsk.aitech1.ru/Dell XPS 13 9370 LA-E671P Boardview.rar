# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_CA2_2: length 57.1
  TOP w0.152: UD43.N2 143.41,18.38 v8(142.99,17.95) 143.56,17.38 143.56,16.47 RD46.1
  IN1 w0.114: v8(142.99,17.95) 142.78,17.75 141.28,17.75 141.17,17.63 141.17,17.58 141.05,17.46 140.82,17.46 140.71,17.58 140.71,17.63 140.59,17.75 140.37,17.75 140.25,17.63 140.25,17.58 140.14,17.46 139.91,17.46 139.79,17.58 139.79,17.63 139.68,17.75 139.28,17.75 138.27,18.76 138.27,18.79 137.83,19.23 137.19,19.23 136.89,18.93 135.44,18.93 135.05,19.33 134.8,19.33 134.63,19.16 134.4,19.16 132.81,20.75 132.81,27.51 129.93,30.39 126.84,30.39 126.51,30.72 126.4,30.72 126.21,30.53 126.08,30.53 125.95,30.67 125.95,30.8 126.13,30.99 126.13,31.09 125.97,31.26 125.86,31.26 125.69,31.08 125.55,31.08 125.42,31.22 125.42,31.35 125.59,31.52 125.59,31.63 124.63,32.59 122.3,32.59 122.29,32.59 116.7,32.59 113.73,35.57 113.73,37.14 v9(113.82,37.23)
  GND1 w0.152: v3(113.95,37.56) 113.82,37.43 v9(113.82,37.23)
  GND3 w0.152: v4(113.8,37.19) 113.95,37.34 v3(113.95,37.56)
  BOTTOM w0.076: 113.38,38.09 113.38,38.98 113.47,39.06 113.47,43.21 113.08,43.59 113.08,43.67 113.03,43.78 113.03,43.99 113.1,44.21 113.1,44.3 113.04,44.46 113.04,44.76 UCPU1.AY44
  BOTTOM w0.152: 113.38,38.09 113.38,37.61 v2(113.51,37.48) v4(113.8,37.19)
DDR_B_CA2_3: length 57.6
  TOP w0.076: 143.74,18.87 v8(143.74,19.63)
  TOP w0.152: RD48.1 143.97,17.67 143.74,17.9 143.74,18.87 ; v8(143.74,19.63) 143.74,19.7 UD43.N3
  IN1 w0.114: v8(143.74,19.63) 143.27,19.16 139.84,19.16 138.76,20.24 138.76,21.23 138.98,21.44 138.98,22.23 138.39,22.82 136.72,22.82 136.11,23.43 135.77,23.43 135.55,23.64 135.55,24.89 134.6,25.85 134.6,28.26 130.18,32.68 129.83,32.68 128.35,32.68 126.04,34.99 126.02,34.99 126,35.01 120.41,35.01 117.67,37.75 116.96,37.75 116.41,38.3 116.41,39.95 115.5,40.86 115.5,42.62 114.83,43.28 113.06,43.28 112.57,42.79 112.57,41.73 v9(112.78,41.52)
  GND1 w0.152: v3(112.96,41.25) 112.79,41.42 112.79,41.52 v9(112.78,41.52)
  GND3 w0.152: v4(112.95,41.59) 112.96,41.58 v3(112.96,41.25)
  BOTTOM w0.076: v4(112.95,41.59) 112.95,42.41 112.38,42.99 112.38,44.22 112.59,44.42 112.59,45.04 112.91,45.37 UCPU1.AW44
DDR_B_CA2_4: length 55.5
  TOP w0.076: 142.81,18.45 143.09,18.73 143.09,19.7 UD43.M3
  TOP w0.152: RD50.1 142.13,16.51 v8(142.47,16.85) 142.47,18.1 142.81,18.45
  IN1 w0.114: v9(113.21,40.48) 113.34,40.35 113.34,39.12 112.72,38.51 112.72,35.28 116.32,31.68 121.25,31.68 122.22,30.71 123.9,30.71 125.47,29.14 128.54,29.14 129.38,28.3 130.66,28.3 131.85,27.12 131.85,20.3 134.15,18 137.63,18 137.71,18.07 138.04,18.07 138.91,17.2 139.27,17.2 139.62,16.85 v8(142.47,16.85)
  GND1 w0.152: v9(113.21,40.48) 113.16,40.48 v3(112.94,40.71)
  GND3 w0.152: v4(112.92,40.36) 112.92,40.69 v3(112.94,40.71)
  BOTTOM w0.076: UCPU1.BB44 113.3,43.1 113.3,40.76 112.92,40.38 v4(112.92,40.36)
DDR_B_CA2_5: length 56.8
  TOP w0.076: 138.52,18.4 138.52,19.68 UD43.F3 ; 138.52,17.58 138.5,17.56
  TOP w0.152: RD52.1 138.86,16.45 v8(138.41,16.9) 138.41,17.47 138.5,17.56 ; 138.52,18.4 138.52,17.58
  IN1 w0.114: v8(138.41,16.9) 137.65,16.9 137.24,17.31 133.96,17.31 132.68,18.59 131.73,18.59 130.34,19.98 130.34,22.31 130.62,22.59 130.82,22.59 130.93,22.69 130.93,22.9 130.83,22.99 130.65,22.99 130.44,23.2 130.44,23.45 130.16,23.73 128.94,23.73 128.76,23.92 127.36,23.92 126.14,25.14 124.68,25.14 124.14,25.68 124.14,28.33 123.49,28.97 122.87,29.6 122.45,30.02 121.68,30.02 121.59,30.11 121.59,30.37 121.48,30.48 121.31,30.48 121.21,30.38 121.21,30.11 121.12,30.01 120.11,30.01 120,29.9 119.42,29.9 119.22,30.11 119.22,30.89 119.12,30.98 118.9,30.98 118.78,30.86 118.78,30.11 118.7,30.02 118.41,30.02 118.34,30.1 118.34,30.75 118.05,31.04 116.1,31.04 112.11,35.03 112.11,37.67 112.07,37.71 112.07,39.41 111.93,39.55 v9(111.67,39.81)
  GND1 w0.152: v3(111.26,39.7) 111.37,39.81 v9(111.67,39.81)
  GND3 w0.152: v4(110.93,39.95) 111.01,39.95 v3(111.26,39.7)
  BOTTOM w0.076: UCPU1.AY47 111.09,45.06 111.39,44.75 111.39,44.49 111.35,44.35 111.35,44.17 111.41,43.94 111.41,43.86 111.35,43.74 111.35,43.37 111.61,43.12 111.61,40.63 v4(110.93,39.95)
DDR_B_CA2_6: length 56.1
  TOP w0.076: UD43.E3 137.91,19.72 137.91,18.93 v8(137.52,18.54)
  TOP w0.152: RD54.1 137.71,16.48 137.42,16.77 137.42,18.44 v8(137.52,18.54)
  IN1 w0.114: v8(137.52,18.54) 137.31,18.33 134.26,18.33 132.15,20.43 132.15,27.25 130.81,28.59 129.85,28.59 129,29.45 126.28,29.45 125.97,29.76 125.83,29.76 125.64,29.56 125.5,29.56 125.37,29.7 125.37,29.83 125.56,30.03 125.56,30.16 125.43,30.3 125.29,30.3 125.1,30.1 124.96,30.1 124.83,30.24 124.83,30.37 125.02,30.57 125.02,30.7 124.89,30.84 124.75,30.84 124.56,30.64 124.42,30.64 124.29,30.77 124.29,30.91 124.48,31.1 124.48,31.24 124.35,31.37 124.21,31.37 124.02,31.18 123.88,31.18 123.75,31.31 123.75,31.45 123.9,31.6 123.9,31.76 123.79,31.88 123.43,31.88 123.35,31.8 123.35,31.11 123.27,31.03 123.04,31.03 122.97,31.11 122.97,31.83 122.89,31.9 122.66,31.9 122.59,31.83 122.59,31.22 122.49,31.12 122.3,31.12 122.21,31.22 122.21,31.82 122.04,31.98 116.45,31.98 113.03,35.41 113.03,38.38 113.66,39.02 113.66,41.33 113.55,41.44 113.39,41.44 113.28,41.55 113.28,41.78 113.39,41.9 113.64,41.9 113.75,42.01 113.75,42.45 113.6,42.6 v9(113.42,42.6)
  GND1 w0.152: v3(112.99,42.6) 113.42,42.6 v9(113.42,42.6)
  GND3 w0.152: v3(112.99,42.6) 112.97,42.62 v4(112.97,42.95)
  BOTTOM w0.076: UCPU1.BA44 112.55,43.98 112.55,43.37 v4(112.97,42.95)
DDR_B_CA2_7: length 56.7
  TOP w0.152: UD43.E2 138.21,18.56 137.87,18.22 v8(137.87,17.67) 137.87,16.81 138.28,16.4 RD56.1
  IN1 w0.114: v8(137.87,17.67) 137.84,17.63 134.09,17.63 131.43,20.29 131.43,23.23 130.62,24.04 129.19,24.04 129.01,24.21 127.5,24.21 127.06,24.64 126.27,25.44 124.78,25.44 124.43,25.78 124.43,28.01 124.53,28.11 124.76,28.11 124.86,28.2 124.86,28.48 124.76,28.58 124.53,28.58 124.43,28.67 124.43,29.74 123.88,30.29 123.63,30.29 123.55,30.21 123.55,29.93 123.45,29.84 123.26,29.84 123.17,29.93 123.17,30.21 122.99,30.38 122.12,30.38 121.17,31.33 120.89,31.33 120.82,31.26 120.82,30.46 120.72,30.36 120.51,30.36 120.41,30.46 120.41,31.21 120.3,31.32 120.11,31.32 120,31.21 120,30.48 119.9,30.39 119.67,30.39 119.57,30.48 119.57,31.19 119.39,31.37 116.2,31.37 112.42,35.15 112.42,37.8 112.38,37.84 112.38,39.13 v9(112.56,39.31)
  GND1 w0.152: v9(112.56,39.31) 112.57,39.32 v3(112.91,39.32)
  GND3 w0.152: v3(112.91,39.32) 112.9,39.31 112.9,38.96 v4(112.92,38.95)
  BOTTOM w0.076: v4(112.92,38.95) v2(112.51,39.35) 112.21,39.66 112.21,42.52 112.22,42.53 112.22,44.22 112,44.43 112,45.04 111.69,45.36 UCPU1.AW46
DDR_B_CA2_8: length 54.9
  TOP w0.152: UD43.D2 137.07,18.73 137.07,17.69 136.21,16.83 v8(136.21,16.58) 136.23,16.55 RD58.1
  IN1 w0.114: v9(111.54,38.93) 111.77,38.7 111.77,37.58 111.81,37.54 111.81,34.9 116.38,30.33 116.54,30.33 116.95,30.74 117.14,30.74 117.29,30.59 117.29,30.43 116.86,30.01 116.86,29.84 117.02,29.68 117.19,29.68 117.71,30.21 117.87,30.21 118.03,30.04 118.03,29.88 117.51,29.36 117.51,29.2 117.67,29.04 117.83,29.04 118.43,29.64 118.59,29.64 118.76,29.47 118.76,29.31 118.16,28.71 118.16,28.55 118.66,28.05 118.66,25.19 118.67,25.18 118.67,25.17 119.09,24.75 119.61,24.22 119.65,24.19 119.69,24.16 120.89,22.96 128.68,22.96 129.02,22.62 129.55,22.62 129.92,22.24 129.92,19.8 131.44,18.29 132.55,18.29 133.83,17.01 135.78,17.01 v8(136.21,16.58)
  GND1 w0.152: v3(111.27,39.11) 111.45,38.93 v9(111.54,38.93)
  GND3 w0.152: v4(110.95,39.35) 111.03,39.35 v3(111.27,39.11)
  BOTTOM w0.076: UCPU1.AY46 111.56,44.77 111.56,44.41 111.51,44.27 111.51,44.19 111.57,43.96 111.57,43.79 111.52,43.67 111.52,43.44 111.8,43.16 111.8,40.2 v4(110.95,39.35)
DDR_B_CA2_9: length 54.8
  TOP w0.152: RD60.1 135.66,16.45 v8(135.52,16.59) 135.51,16.6 135.51,17.09 136.68,18.26 136.68,18.99 UD43.C2
  IN1 w0.114: v9(111.28,37.63) 111.5,37.42 111.5,34.76 118.3,27.97 118.3,27.69 118.18,27.57 117.32,27.57 117.21,27.46 117.21,27.23 117.32,27.12 118.18,27.12 118.3,27 118.3,26.77 118.18,26.66 117.32,26.66 117.21,26.55 117.21,26.32 117.32,26.2 118.18,26.2 118.3,26.09 118.3,25.86 118.18,25.75 117.53,25.75 117.41,25.63 117.41,25.4 117.53,25.29 118.09,25.29 118.3,25.08 120.71,22.67 128.54,22.67 128.94,22.27 128.94,19.54 129.54,18.94 130.28,18.94 131.24,17.98 132.42,17.98 133.71,16.7 135.41,16.7 v8(135.52,16.59)
  GND1 w0.152: v9(111.28,37.63) 111.27,37.65 v3(111.27,37.98)
  GND3 w0.152: v3(111.27,37.98) 111.27,37.62 v4(111.28,37.61)
  BOTTOM w0.076: UCPU1.BA46 111.79,44.07 112.04,43.81 112.04,39.76 111.28,39 v2(111.28,38.08) 111.28,37.66
  BOTTOM w0.152: 111.28,37.66 v4(111.28,37.61)
DDR_B_CKE0: length 57.7
  TOP w0.076: UD44.K3 125.89,19.8 126.25,19.44 126.25,19.06 126.02,18.84 126.02,18.43 125.81,18.23
  TOP w0.152: 125.81,18.23 125.43,17.84 124.41,17.84 123.93,17.35 v8(123.93,16.88) 123.76,16.71 RD66.1
  IN2 w0.076: v8(105.18,48.92) 105.51,49.24 106.22,49.24 106.62,48.85 106.62,46.18 107.11,45.69 107.11,45.66
  IN2 w0.095: v8(123.93,16.88) 123.87,16.94 121,16.94 120.94,17 119.76,17 119.64,17.11 119.64,17.24 119.53,17.36 119.3,17.36 119.19,17.24 119.19,17.11 119.07,17 118.84,17 118.73,17.11 118.73,17.24 118.62,17.36 118.39,17.36 118.27,17.24 118.27,17.11 118.16,17 117.27,17 116.99,17.28 116.83,17.28 116.75,17.21 116.59,17.21 116.43,17.37 116.43,17.53 116.5,17.61 116.5,17.77 116.34,17.93 116.18,17.93 115.66,17.41 115.5,17.41 115.34,17.57 115.34,17.74 115.86,18.25 115.86,18.42 115.7,18.58 115.53,18.58 115.03,18.07 114.87,18.07 114.71,18.23 114.71,18.39 115.21,18.9 115.21,19.06 115.05,19.22 114.89,19.22 114.81,19.15 114.65,19.15 114.49,19.31 114.49,19.47 114.56,19.55 114.56,19.71 114.4,19.87 114.24,19.87 114.16,19.79 114,19.79 113.84,19.95 113.84,20.12 113.92,20.19 113.92,20.36 113.7,20.57 113.7,20.94 113.48,21.16 113.11,21.16 113.03,21.24 113.03,21.48 113.15,21.6 113.62,21.6 113.73,21.71 113.73,21.94 113.62,22.05 113.15,22.05 113.03,22.17 113.03,29.13 113.03,29.47 112.41,30.1 112.41,31.45 109.48,34.38 109.48,41.57 109.37,41.68 109.37,43.27 107.76,44.88 107.76,44.91 107.54,45.13 107.33,45.13 107.11,45.35 107.11,45.66 107.11,45.66
  BOTTOM w0.152: v8(105.18,48.92) 105.25,48.92 UCPU1.AN56
DDR_B_CKE1: length 58.3
  TOP w0.076: UD44.K4 126.2,20.52 126.2,19.79 126.4,19.59 126.74,19.59 126.86,19.46 126.86,18.94 126.74,18.82 126.74,18.24 126.65,18.16
  TOP w0.152: RD68.1 124.33,16.6 v8(124.54,16.8) 124.68,16.94 125.43,16.94 126.65,18.16
  IN2 w0.076: 107.31,44.89 106.92,45.28 106.92,45.55 106.45,46.02 106.45,47.93 v8(106.1,48.28)
  IN2 w0.095: 107.31,44.89 109.08,43.12 109.08,41.57 109.18,41.47 109.18,34.28 112.1,31.35 112.1,29.97 112.73,29.35 112.73,29 112.73,29 112.73,20.42 113.09,20.06 113.09,19.93 112.58,19.42 112.58,19.31 112.75,19.14 112.91,19.14 113.47,19.69 113.63,19.69 113.79,19.53 113.79,19.37 113.51,19.09 113.51,18.92 113.72,18.71 113.72,18.55 113,17.84 113,17.68 113.17,17.51 113.33,17.51 114.04,18.23 114.2,18.23 114.37,18.07 114.37,17.9 114.3,17.84 114.3,17.68 114.46,17.52 114.62,17.52 114.69,17.58 114.85,17.58 115.01,17.42 115.01,17.26 114.44,16.68 114.44,16.52 114.6,16.36 114.76,16.36 115.34,16.93 115.5,16.93 115.77,16.66 120.85,16.66 120.88,16.63 123.4,16.63 123.69,16.34 124.07,16.34 v8(124.54,16.8)
  BOTTOM w0.152: UCPU1.AP55 106.18,48.28 v8(106.1,48.28)
DDR_B_CKE2: length 62.9
  TOP w0.076: 141.91,18.46 141.91,18.75 141.79,18.87 v8(141.79,19.63)
  TOP w0.152: UD43.K3 141.79,19.7 v8(141.79,19.63) ; 141.91,18.46 141.91,17.29 141.56,16.94 RD70.1
  IN1 w0.114: v8(141.79,19.63) 142.27,19.63 142.86,20.23 142.86,22.36 142.68,22.54 142.68,24.64 141.92,25.39 141.81,25.39 140.7,26.5 140.7,27.39 140.5,27.6 140.5,27.6 140.49,27.61 140.49,28.21 138.83,29.87 136.83,29.87 135.71,30.99 133.99,30.99 130.55,34.42 128.78,34.42 125.87,37.33 123.39,37.33 121.3,39.43 120.26,39.43 119.51,40.18 119.27,40.18 119,40.45 119,42.85 117.03,44.81 114.68,44.81 112.92,46.58 112.92,49.77 112.21,50.48 107.3,50.48 106.57,49.74 106.57,49.34 v8(106.09,48.87)
  BOTTOM w0.152: v8(106.09,48.87) 106.11,48.87 UCPU1.AN55
DDR_B_CKE3: length 64.9
  TOP w0.152: UD43.K4 141.15,21.14 v8(141.15,21.24) ; RD72.1 142.7,16.43 143.07,16.8 v8(143.07,16.94)
  IN1 w0.114: v8(106.99,48.32) 107.08,48.32 107.46,48.7 107.46,49.82 107.71,50.07 111.77,50.07 112.08,49.77 112.08,46.18 113.82,44.44 116.87,44.44 118.5,42.82 118.5,38.87 119.14,38.24 119.86,38.24 121.33,36.77 125.77,36.77 128.63,33.91 130.58,33.91 133.88,30.6 135.53,30.6 136.76,29.37 138.89,29.37 140.14,28.12 140.14,27.55 140.33,27.36 140.33,26.41 140.55,26.19 140.97,25.77 141.79,24.95 141.83,24.95 142.23,24.54 142.23,23.04 141.92,22.73 141.92,22.01 v8(141.15,21.24)
  BOTTOM w0.152: v8(143.07,16.94) 143.07,17.02 141.9,18.19 141.9,19.03 142.93,20.06 142.93,20.65 142.76,20.82 141.56,20.82 v8(141.15,21.24) ; UCPU1.AP53 107.13,48.32 v8(106.99,48.32)
DDR_B_CLK0: length 64.7
  TOP w0.076: v8(125.57,19.63) 125.57,19.12 125.24,18.79 125.24,18.43 124.89,18.08 123.94,18.08 123.54,17.68 123.54,17.62 123.53,17.61
  TOP w0.14: RD76.1 121.11,16.4 121.11,16.58 121.24,16.71 122.62,16.71 123.53,17.61 ; v8(125.57,19.63) 125.57,19.7 UD44.J3
  IN1 w0.076: 110.37,45.96 110.37,45.97 110.34,46.01 110.34,46.25 110.3,46.29 110.3,49.11 110.46,49.26 110.82,49.26 111.03,49.06 111.03,48.96 111.29,48.69 111.36,48.69 111.61,48.44 v8(111.61,48.33)
  IN1 w0.114: 110.37,45.96 110.37,45.77 110.63,45.51 110.63,39.65 110.87,39.41 110.87,34.66 112.04,33.49 112.04,33.14 111.56,32.66 111.45,32.56 111.45,32.41 111.68,32.18 111.84,32.18 112.47,32.81 112.81,32.81 113.18,32.45 113.18,32.11 112.5,31.43 112.5,31.28 112.73,31.05 112.89,31.05 113.58,31.75 113.92,31.75 114.32,31.35 114.32,30.98 112.89,29.55 112.89,29.4 113.12,29.17 113.27,29.17 114.5,30.4 114.98,30.4 115.36,30.03 115.36,29.68 115.02,29.34 115.02,29.19 115.25,28.96 115.4,28.96 115.76,29.32 116.1,29.32 116.47,28.96 116.47,28.61 116.11,28.26 116.11,24.44 116.78,23.77 116.78,23.42 115.69,22.33 115.69,22.17 115.94,21.93 116.1,21.93 117.18,23.01 117.53,23.01 117.91,22.63 117.91,22.28 116.92,21.29 116.92,21.13 117.16,20.89 117.32,20.89 118.31,21.88 118.66,21.88 119.43,21.11 121.42,21.11 121.86,20.67 122.57,20.67 122.58,20.67 124.68,20.67 125.31,20.04 125.31,19.79 125.48,19.63 v8(125.57,19.63)
  BOTTOM w0.14: UCPU1.AP45 111.72,48.33 v8(111.61,48.33)
DDR_B_CLK1: length 59.5
  TOP w0.076: 140.56,17.56 140.56,17.58 140.6,17.62 140.6,17.83 140.49,17.93 v8(140.49,19.63)
  TOP w0.14: RD80.1 140.56,16.47 140.56,17.56 ; UD43.J3 140.49,19.7 v8(140.49,19.63)
  IN1 w0.076: v8(110.68,48.26) 110.68,48.45 110.79,48.55 110.94,48.55 111.07,48.42 111.07,46.01 111.04,45.97 111.04,45.96
  IN1 w0.114: v8(140.49,19.63) 140.62,19.63 140.76,19.76 140.76,19.91 140.3,20.36 140.3,22.31 140.02,22.59 139.61,23 139.61,27.09 139.51,27.19 139.51,27.86 138.63,28.74 136.33,28.74 135.2,29.87 133.58,29.87 132.57,30.88 130.19,33.26 128.36,33.26 125.63,36 124.95,36 124.84,35.88 124.84,35.69 124.59,35.44 124.06,35.44 123.81,35.69 123.81,35.88 123.69,36 122.31,36 122.2,35.88 122.2,35.69 121.95,35.44 121.42,35.44 121.17,35.69 121.17,35.88 121.06,36 120.82,36 119.76,37.06 119.18,37.06 117.38,38.86 117.38,40.22 117.26,40.34 116.67,40.34 116.42,40.59 116.42,41.12 116.67,41.37 117.26,41.37 117.38,41.48 117.38,43.02 116.62,43.78 112.94,43.78 112.7,44.03 112.53,44.03 112.15,43.65 111.8,43.65 111.43,44.02 111.43,44.37 111.81,44.75 111.81,44.91 111.04,45.68 111.04,45.96
  BOTTOM w0.14: UCPU1.AP46 110.73,48.26 v8(110.68,48.26)
DDR_B_CLK#0: length 64.3
  TOP w0.076: UD44.J2 125.24,19.12 125.07,18.94 125.07,18.5 124.82,18.25 123.87,18.25 123.42,17.79 123.37,17.79 123.35,17.78
  TOP w0.14: 123.35,17.78 122.52,16.95 121.14,16.95 120.87,16.68 120.87,16.44 RD78.1 ; UD44.J2 124.92,19.55 v8(124.92,19.63)
  IN1 w0.076: v8(111.61,48.94) 111.53,48.86 111.36,48.86 111.19,49.03 111.19,49.13 110.89,49.43 110.39,49.43 110.14,49.17 110.14,46.22 110.18,46.18 110.18,46.01 110.14,45.97 110.14,45.96
  IN1 w0.114: v8(124.92,19.63) 125.08,19.79 125.08,19.95 124.58,20.45 122.6,20.45 122.59,20.44 121.76,20.44 121.32,20.88 119.34,20.88 118.57,21.65 118.41,21.65 117.42,20.66 117.06,20.66 116.69,21.03 116.69,21.39 117.68,22.38 117.68,22.54 117.44,22.78 117.28,22.78 116.19,21.7 115.84,21.7 115.47,22.08 115.47,22.43 116.55,23.51 116.55,23.67 115.88,24.34 115.88,28.35 116.24,28.71 116.24,28.86 116.01,29.09 115.85,29.09 115.5,28.73 115.15,28.73 114.79,29.1 114.79,29.44 115.13,29.78 115.13,29.93 114.89,30.17 114.6,30.17 113.36,28.94 113.02,28.94 112.66,29.3 112.66,29.64 114.09,31.07 114.09,31.25 113.83,31.52 113.67,31.52 112.98,30.82 112.64,30.82 112.28,31.19 112.28,31.53 112.95,32.2 112.95,32.36 112.72,32.59 112.57,32.59 111.93,31.95 111.59,31.95 111.23,32.31 111.23,32.65 111.56,32.98 111.81,33.24 111.81,33.39 110.64,34.56 110.64,39.32 110.4,39.56 110.4,45.42 110.14,45.67 110.14,45.96
  BOTTOM w0.14: v8(111.61,48.94) 111.67,48.94 UCPU1.AN45
DDR_B_CLK#1: length 59.2
  TOP w0.076: 140.8,17.56 140.8,17.58 140.76,17.62 140.76,17.89 140.66,18 140.66,19.07 UD43.J2
  TOP w0.14: RD82.1 140.8,16.47 140.8,17.56 ; UD43.J2 141.14,19.55 v8(141.14,19.63)
  IN1 w0.076: v8(110.67,48.91) 110.67,48.89 110.84,48.72 111,48.72 111.23,48.49 111.23,46.01 111.27,45.97 111.27,45.96
  IN1 w0.114: 111.27,45.96 111.27,45.78 112.04,45.01 112.04,44.66 111.66,44.28 111.66,44.12 111.9,43.88 112.06,43.88 112.44,44.25 112.79,44.25 113.03,44.01 116.71,44.01 117.61,43.12 117.61,41.39 117.36,41.14 116.77,41.14 116.65,41.02 116.65,40.68 116.77,40.57 117.36,40.57 117.61,40.32 117.61,38.96 119.28,37.29 119.85,37.29 120.92,36.22 121.15,36.22 121.4,35.98 121.4,35.78 121.51,35.67 121.86,35.67 121.97,35.78 121.97,35.98 122.22,36.22 123.79,36.22 124.04,35.98 124.04,35.78 124.15,35.67 124.49,35.67 124.61,35.78 124.61,35.98 124.86,36.22 125.72,36.22 128.46,33.49 130.29,33.49 130.84,32.93 133.68,30.1 135.29,30.1 136.42,28.97 138.72,28.97 139.74,27.95 139.74,27.28 139.84,27.18 139.84,26.99 139.84,23.1 140.53,22.41 140.53,20.46 140.98,20 140.98,19.78 v8(141.14,19.63)
  BOTTOM w0.14: v8(110.67,48.91) 110.73,48.91 UCPU1.AN46
DDR_B_CS#0: length 74.7
  TOP w0.152: RD62.1 133.35,15.75 133.67,16.07 133.67,16.92 133.91,17.16 133.91,18.02 134.29,18.4 134.29,20.16 v8(134.44,20.31) ; v8(142.44,20.42) 142.44,20.34 142.12,20.02 UD43.L3
  TOP w0.173: UD44.L3 126.54,20.1 v8(126.87,20.43)
  IN1 w0.114: v9(114.42,40.49) 114.42,40.48 114.85,40.05 114.85,38.13 114.97,38.02 115.27,38.02 115.38,37.9 115.38,37.68 115.27,37.56 114.97,37.56 114.85,37.45 114.85,37.19 115.04,37 115.04,36.72 114.85,36.54 114.85,36.32 115.12,36.06 115.12,35.89 114.93,35.7 114.93,35.54 115.09,35.38 115.25,35.38 115.65,35.77 115.81,35.77 115.97,35.61 115.97,35.45 115.56,35.04 115.56,34.88 115.73,34.72 115.88,34.72 116.18,35.01 116.34,35.01 116.5,34.85 116.5,34.69 116.19,34.38 116.19,34.25 116.39,34.06 116.52,34.06 116.79,34.33 116.95,34.33 117.11,34.17 117.11,34.01 116.85,33.75 116.85,33.59 117.02,33.42 117.18,33.42 117.38,33.63 117.55,33.63 117.86,33.31 124.18,33.31 124.27,33.4 124.27,33.87 124.36,33.96 124.56,33.96 124.65,33.87 124.65,33.4 124.74,33.31 124.97,33.31 125.06,33.4 125.06,33.83 125.15,33.93 125.5,33.93 125.67,33.76 125.67,33.6 125.41,33.35 125.41,32.83 126.65,31.59 126.86,31.59 127.04,31.41 127.04,31.24 127.15,31.12 127.42,31.12 127.56,31.26 127.56,31.47 127.68,31.59 127.91,31.59 128.02,31.47 128.02,31.24 128.13,31.12 128.36,31.12 128.48,31.24 128.48,31.47 128.59,31.59 128.82,31.59 128.93,31.47 128.93,31.24 129.05,31.12 129.28,31.12 129.39,31.24 129.39,31.47 129.51,31.59 129.68,31.59 129.88,31.39 129.88,31.21 129.97,31.12 130.21,31.12 133.53,27.81 133.53,23.38 133.64,23.26 133.99,23.26 134.1,23.15 134.1,22.92 133.99,22.8 133.64,22.8 133.53,22.69 133.53,21.93 133.66,21.8 134.08,21.8 134.23,21.65 134.23,21.43 134.11,21.32 133.83,21.32 133.75,21.23 133.75,21 v8(134.44,20.31)
  GND1 w0.152: v3(114.1,40.72) 114.19,40.72 v9(114.42,40.49)
  IN3 w0.095: v8(126.87,20.43) 127.28,20.02 133.34,20.02 133.5,20.19 133.5,21.02 133.6,21.11 133.79,21.11 133.88,21.02 133.88,20.4 133.98,20.31 v8(134.44,20.31) 134.73,20.02 136.8,20.02 137.24,19.58 139.49,19.58 139.86,19.21 142.01,19.21 142.44,19.64 v8(142.44,20.42)
  GND3 w0.152: v3(114.1,40.72) 114.13,40.75 v4(114.44,40.75)
  BOTTOM w0.076: UCPU1.BB42 113.96,43.42 113.96,41.23 114.44,40.76 v4(114.44,40.75)
DDR_B_CS#1: length 75.7
  TOP w0.152: v8(141.79,20.42) 141.79,20.49 142.11,20.81 UD43.L4 ; RD64.1 132.81,15.69 132.81,16.57 133.57,17.33 133.57,18.17 133.9,18.5 133.9,20.78 134.31,21.2 v8(134.57,21.2)
  TOP w0.173: v8(126.85,21.22) 126.54,20.92 UD44.L4
  IN1 w0.114: v8(134.57,21.2) 134.57,21.99 135.04,22.46 135.95,22.46 136.11,22.62 136.11,22.86 135.95,23.02 135.4,23.02 135.04,23.37 135.04,23.65 134.87,23.82 134.42,23.82 134.18,24.06 134.18,28.09 130.01,32.26 128.03,32.26 127.66,32.63 127.5,32.63 127.1,32.24 126.94,32.24 126.78,32.4 126.78,32.56 127.17,32.95 127.17,33.12 127.01,33.28 126.85,33.28 126.44,32.87 126.28,32.87 126.12,33.03 126.12,33.19 126.53,33.6 126.53,33.76 125.71,34.58 122.06,34.58 121.96,34.48 121.96,34.17 121.86,34.08 121.67,34.08 121.58,34.17 121.58,34.45 121.48,34.54 121.29,34.54 121.2,34.45 121.2,34.15 121.1,34.06 120.91,34.06 120.82,34.15 120.82,34.46 120.72,34.56 120.53,34.56 120.43,34.46 120.43,34.15 120.34,34.05 119.81,34.05 119.69,34.16 119.69,34.33 120.02,34.66 120.02,34.79 119.88,34.92 119.75,34.92 119.33,34.5 119.19,34.5 119.06,34.64 119.06,34.77 119.48,35.19 119.48,35.33 119.35,35.46 119.21,35.46 118.79,35.04 118.65,35.04 118.52,35.17 118.52,35.31 118.94,35.73 118.94,35.87 118.81,36 118.67,36 118.25,35.58 118.11,35.58 117.98,35.71 117.98,35.85 118.4,36.27 118.4,36.41 118.27,36.54 118.13,36.54 117.77,36.18 117.71,36.12 117.57,36.12 117.44,36.25 117.44,36.39 117.77,36.72 117.86,36.81 117.86,36.95 117.73,37.08 117.59,37.08 117.17,36.66 117.04,36.66 115.99,37.7 115.99,39.77 115.08,40.69 115.08,41.7 v9(114.66,42.11)
  GND1 w0.152: v9(114.66,42.11) 114.48,42.11 v3(114.28,42.32)
  IN3 w0.095: v8(141.79,20.42) 141.38,20.83 140.89,20.83 140.08,21.63 139.45,21.63 138.63,20.82 136.61,20.82 136.23,21.2 v8(134.57,21.2) 134.15,21.62 127.01,21.62 126.85,21.46 v8(126.85,21.22)
  GND3 w0.152: v3(114.28,42.32) 114.59,42.32 v4(114.61,42.34)
  BOTTOM w0.076: v4(114.61,42.34) 114.46,42.34 114.29,42.51 114.29,43.11 114.56,43.37 114.56,43.83 114.39,43.99 114.39,44.56 114.14,44.81 UCPU1.AY42
DDR_B_D0: length 23.9
  TOP w0.076: v8(121.94,28.17) 122.2,28.42 122.6,28.42 122.85,28.17 122.85,27.75 122.68,27.58 122.52,27.58 122.34,27.4 122.34,26.91 122.64,26.6 UD44.E11
  IN2 w0.095: v3(115.26,38.24) 115.26,38.24 115.26,35.56 121.41,29.41 121.41,28.71 v8(121.94,28.17)
  GND3 w0.152: v4(115.26,37.89) 115.26,37.89 v3(115.26,38.24)
  BOTTOM w0.076: v4(115.26,37.89) 115.26,39.04 114.94,39.35 114.94,40.36 115.09,40.51 115.09,43.28 115,43.38 115,43.76 115.02,43.81 115.04,43.86 115.1,43.99 115.1,44.58 UCPU1.AY39
DDR_B_D1: length 26
  TOP w0.152: UD44.F10 122.95,25.97 v8(122.95,26.03)
  IN2 w0.095: v8(122.95,26.03) 120.8,28.18 120.8,29.52 114.87,35.44 114.87,39.65 115.2,39.98 115.2,41.96 115.21,41.96 115.21,42 115.77,42.57 116.02,42.57 116.51,43.06 v3(116.75,43.06)
  GND3 w0.152: v4(116.48,42.84) 116.53,42.84 v3(116.75,43.06)
  BOTTOM w0.076: v4(116.48,42.84) 116.3,43.02 116.3,43.66 116.37,43.87 116.37,43.96 116.34,44.07 116.34,44.07 116.3,44.21 116.3,44.35 116.33,44.44 116.33,45.39 116.17,45.54 UCPU1.AW39
DDR_B_D2: length 25
  TOP w0.152: v8(122.98,26.83) 122.98,26.74 UD44.F11
  IN2 w0.095: v3(116.87,42.46) 116.31,42.46 116.14,42.28 115.96,42.28 115.5,41.83 115.5,40.03 115.93,39.6 115.93,35.69 119.53,32.09 119.99,32.09 120.11,32.21 120.27,32.21 120.43,32.05 120.43,31.89 120.31,31.77 120.31,31.61 120.47,31.45 120.63,31.45 120.75,31.56 120.91,31.56 121.08,31.4 121.08,31.24 120.96,31.12 120.96,30.96 121.12,30.8 121.28,30.8 121.4,30.92 121.56,30.92 122.77,29.71 122.77,28.33 122.91,28.18 122.91,27.27 122.98,27.2 v8(122.98,26.83)
  GND3 w0.152: v3(116.87,42.46) 116.86,42.45 v4(116.53,42.45)
  BOTTOM w0.076: UCPU1.AY37 116.5,44.75 116.5,44.41 116.47,44.32 116.47,44.23 116.54,43.99 116.54,43.84 116.48,43.66 116.48,43.28 116.78,42.98 116.78,42.7 v4(116.53,42.45)
DDR_B_D3: length 29.4
  TOP w0.152: v8(122.32,24.43) 122.32,24.5 UD44.D9
  IN2 w0.095: v3(116.97,39.52) 117.99,38.51 117.99,36.17 119.99,34.17 120.69,34.17 125.34,29.53 125.48,29.53 126.02,28.99 126.02,26.55 125.77,26.3 125.77,25.85 123.95,24.04 122.71,24.04 v8(122.32,24.43)
  GND3 w0.152: v3(116.97,39.52) 117,39.56 117,39.92 v4(117.01,39.93)
  BOTTOM w0.076: v4(117.01,39.93) 117.34,40.26 117.34,40.57 117.24,40.67 v2(117.24,40.8) 117.24,42.18 117.3,42.24 117.3,43.15 117.17,43.28 117.17,43.8 117.08,43.89 117.08,44.38 116.93,44.53 116.93,45.07 116.64,45.36 UCPU1.AW37
DDR_B_D4: length 24.3
  TOP w0.152: UD44.F9 122.97,25.15 v8(122.97,25.23)
  IN2 w0.095: v8(122.97,25.23) 122.97,25.26 121.81,26.42 120.04,26.42 119.56,26.91 119.56,30.22 114.55,35.23 114.55,40 114.89,40.34 114.89,42.34 115.51,42.95 115.75,42.95 v3(115.76,42.95)
  GND3 w0.152: v3(115.76,42.95) 115.61,43.1 v4(115.61,43.26)
  BOTTOM w0.076: v4(115.61,43.26) 115.64,43.26 115.64,43.42 115.47,43.59 UCPU1.BB39
DDR_B_D5: length 22.2
  TOP w0.076: v8(121.94,28.8) 121.54,28.39 121.54,27.74 121.66,27.63 121.66,27.09 121.93,26.81 122.03,26.81 122.3,26.55 122.3,25.97 UD44.E10
  IN2 w0.095: v3(115.28,39.5) 115.64,39.15 115.64,35.58 121.77,29.46 121.77,28.97 v8(121.94,28.8)
  GND3 w0.152: v4(115.29,39.87) 115.29,39.51 v3(115.28,39.5)
  BOTTOM w0.076: UCPU1.BA39 115.27,44.1 115.27,43.95 115.19,43.79 115.16,43.73 115.16,43.44 115.28,43.33 115.28,39.89 v4(115.29,39.87)
DDR_B_D6: length 26.5
  TOP w0.152: UD44.F8 123.62,24.35 v8(123.62,24.43)
  IN2 w0.095: v8(123.62,24.43) 123.9,24.43 125.42,25.94 125.42,26.25 125.16,26.51 125.16,27.13 125.72,27.69 125.72,28.84 125.33,29.22 125.24,29.22 120.57,33.89 119.8,33.89 117.59,36.1 117.59,38.27 117.49,38.37 v3(116.97,38.37)
  GND3 w0.152: v4(116.7,38.57) 116.9,38.37 v3(116.97,38.37)
  BOTTOM w0.076: UCPU1.BA37 116.74,44 117.01,43.73 117.01,43.21 117.14,43.09 117.14,42.31 117.08,42.25 117.08,41.23 116.7,40.85 v2(116.7,39.61) v4(116.7,38.57)
DDR_B_D7: length 25.1
  TOP w0.152: UD44.E9 122.97,24.5 v8(122.97,24.43)
  IN2 w0.095: v8(122.97,24.43) 123.38,24.83 123.77,24.83 124.22,25.28 124.22,25.95 124.79,26.52 124.79,29.27 120.45,33.6 119.59,33.6 117.03,36.16 117.03,37.21 v3(116.96,37.27)
  GND3 w0.152: v3(116.96,37.27) 116.87,37.27 v4(116.68,37.46)
  BOTTOM w0.076: UCPU1.BB37 116.74,43.43 116.84,43.33 116.84,43.15 116.97,43.02 116.97,42.38 116.91,42.32 116.91,41.4 116.34,40.82 v2(116.34,38.26) 116.34,37.82 116.33,37.81 v4(116.68,37.46)
DDR_B_D8: length 30.3
  TOP w0.152: UD44.T11 130.12,26.75 v8(130.12,26.83)
  IN3 w0.095: v8(130.12,26.83) 130.12,26.83 129.58,27.36 129.58,27.5 127.97,29.12 126.23,29.12 126.14,29.02 126.14,28.8 126.04,28.71 125.85,28.71 125.75,28.8 125.75,29.02 125.66,29.12 124.97,29.12 124.85,28.99 124.85,27.84 124.72,27.71 124.53,27.71 124.43,27.81 124.43,28.71 124.31,28.83 123.63,28.83 123.19,29.27 123.19,29.63 123.02,29.8 122.51,30.32 121.82,30.32 117.63,34.51 117.63,39.8 117.63,39.8 117.63,40.33 v3(117.98,40.68)
  GND3 w0.152: v3(117.98,40.68) 117.98,40.91 v4(117.87,41.02)
  BOTTOM w0.076: UCPU1.AY35 117.87,44.75 117.99,44.63 117.99,44.43 118.03,44.33 118.03,44.18 118.03,44.18 117.99,44.04 117.99,44.03 117.98,43.98 117.98,43.84 118.06,43.6 118.28,43.09 118.28,41.42 v4(117.87,41.02)
DDR_B_D9: length 30.7
  TOP w0.152: v8(130.12,26.03) 130.12,25.95 UD44.T10
  IN3 w0.095: v8(130.12,26.03) 130.57,26.48 130.57,27.82 130.36,28.03 129.46,28.03 128.02,29.46 124.44,29.46 124.09,29.11 123.75,29.11 123.51,29.35 123.51,29.71 122.63,30.6 121.94,30.6 118.01,34.54 118.01,39.56 v3(118.03,39.58)
  GND3 w0.152: v4(118.04,39.2) 118.03,39.21 v3(118.03,39.58)
  BOTTOM w0.076: v4(118.04,39.2) 117.62,39.62 117.62,40.82 117.41,41.04 117.41,42.11 117.47,42.18 117.47,43.22 117.34,43.35 117.34,44.23 117.57,44.46 117.57,45.09 117.87,45.4 UCPU1.AW35
DDR_B_D10: length 32.9
  TOP w0.152: v8(131.26,24.04) 131.23,24.06 131,24.06 130.6,24.47 130.15,24.47 UD44.T9
  IN3 w0.095: v3(119.54,36.63) 119.54,35.7 123.99,31.25 124.65,31.25 125.11,30.79 129.55,30.79 132.32,28.02 132.32,25.1 v8(131.26,24.04)
  GND3 w0.152: v4(119.57,36.28) 119.54,36.31 v3(119.54,36.63)
  BOTTOM w0.076: v4(119.57,36.28) 119.57,36.89 120.18,37.5 120.18,37.89 120.11,37.96 120.11,39.18 119.83,39.46 119.83,42.25 119.33,42.75 119.33,43.14 119.53,43.34 119.53,43.74 119.45,43.9 119.37,43.98 119.37,44.62 UCPU1.AY33
DDR_B_D11: length 33.5
  TOP w0.152: UD44.R9 129.55,25.23 131.32,25.23 v8(131.43,25.12)
  IN3 w0.095: v8(131.43,25.12) 132.03,25.72 132.03,27.91 129.43,30.51 124.99,30.51 124.53,30.96 123.87,30.96 119.06,35.78 119.06,39.31 119.32,39.57 v3(119.49,39.59)
  GND3 w0.152: v4(119.18,39.75) 119.33,39.75 v3(119.49,39.59)
  BOTTOM w0.076: UCPU1.AW33 118.32,45.54 118.15,45.38 118.15,44.47 118.2,44.36 118.2,44.16 118.14,43.96 118.14,43.87 118.15,43.83 118.25,43.58 118.46,43.12 118.46,41.41 118.72,41.15 118.72,40.84 118.6,40.72 118.6,40.11 118.96,39.75 v4(119.18,39.75)
DDR_B_D12: length 29.8
  TOP w0.152: v8(129.47,26.83) 129.47,26.75 UD44.R11
  IN3 w0.095: v3(118.04,41.44) 117.79,41.44 117.34,41 117.34,39.69 117.35,39.68 117.35,34.39 117.57,34.16 117.57,34.16 121.71,30.03 121.94,30.03 122.39,30.03 122.74,29.68 122.74,29.68 122.85,29.57 122.85,28.24 123.03,28.06 123.39,28.06 123.47,28.13 123.79,28.13 124.02,27.91 124.02,27.74 124.5,27.26 126.18,27.26 126.28,27.36 126.28,27.63 126.18,27.73 125.92,27.73 125.82,27.82 125.82,28.01 125.92,28.11 126.18,28.11 126.28,28.2 126.28,28.41 126.37,28.51 126.56,28.51 126.66,28.41 126.66,27.36 126.75,27.26 129.04,27.26 v8(129.47,26.83)
  GND3 w0.152: v4(117.72,41.58) 117.86,41.44 v3(118.04,41.44)
  BOTTOM w0.076: v4(117.72,41.58) 118.07,41.93 118.07,43.16 117.77,43.46 UCPU1.BB35
DDR_B_D13: length 28.8
  TOP w0.152: UD44.R10 129.47,25.95 v8(129.47,26.03)
  IN3 w0.095: v8(129.47,26.03) 128.97,26.52 127.87,26.52 127.76,26.42 124.65,26.42 123.84,27.24 122.09,27.24 121.49,27.83 121.49,29.64 116.38,34.75 116.38,39.74 116.88,40.24 116.88,41.27 117.72,42.11 117.72,42.37 v3(117.91,42.56)
  GND3 w0.152: v4(117.76,42.89) 117.76,42.71 v3(117.91,42.56)
  BOTTOM w0.076: UCPU1.BA35 117.5,43.98 117.5,43.42 117.76,43.16 v4(117.76,42.89)
DDR_B_D14: length 33.3
  TOP w0.152: v8(129.47,24.45) 129.47,24.35 UD44.T8
  IN3 w0.095: v3(119.56,37.7) 119.94,37.37 119.94,35.73 120.18,35.5 124.14,31.53 124.77,31.53 124.94,31.37 125.23,31.08 129.67,31.08 132.61,28.14 132.61,24.75 131.33,23.48 130.69,23.48 129.71,24.45 v8(129.47,24.45)
  GND3 w0.152: v3(119.56,37.7) 119.73,37.71 v4(119.89,37.77)
  BOTTOM w0.076: v4(119.89,37.77) 119.89,39.1 119.66,39.33 119.66,42.17 119.17,42.66 119.17,42.75 119.17,42.89 119.17,43.24 119.24,43.31 119.36,43.44 119.36,43.67 119.31,43.79 119.18,43.91 119.18,44.16 UCPU1.BA33
DDR_B_D15: length 32.6
  TOP w0.152: v8(129.99,23.3) 129.99,23.35 129.71,23.63 129.69,23.63 129.3,24.03 UD44.R8
  IN3 w0.095: v8(129.99,23.3) 130.11,23.17 131.56,23.17 132.89,24.51 132.89,28.26 129.79,31.36 125.34,31.36 125.22,31.48 125.06,31.65 124.89,31.82 124.26,31.82 120.22,35.85 120.22,37.88 119.92,38.18 119.92,38.4 v3(119.53,38.79)
  GND3 w0.152: v4(119.4,39.11) 119.52,38.95 v3(119.53,38.79)
  BOTTOM w0.076: v4(119.4,39.11) 119.5,39.2 119.5,42.1 118.99,42.61 118.99,43.49 UCPU1.BB33
DDR_B_D16: length 27.3
  TOP w0.152: v8(120.36,25.23) 120.36,25.29 UD44.B10
  IN3 w0.095: v8(114.33,46.38) 114.33,45.07 112.53,43.28 112.53,34.68 117.06,30.15 117.06,30.15 117.08,30.13 117.08,26.98 119.03,25.03 120.03,25.03 120.22,25.23 v8(120.36,25.23)
  BOTTOM w0.152: UCPU1.AU40 114.45,46.38 v8(114.33,46.38)
DDR_B_D17: length 29.4
  TOP w0.152: v8(121.02,24.43) 121.02,24.5 UD44.B9
  IN3 w0.076: 113.93,45.95 113.93,46.49 114.35,46.91 v8(114.35,47.01)
  IN3 w0.095: v8(121.02,24.43) 120.65,24.8 120.2,24.8 120.09,24.68 118.97,24.68 116.78,26.87 116.78,30.03 112.25,34.56 112.25,43.41 113.93,45.1 113.93,45.95
  BOTTOM w0.152: v8(114.35,47.01) 114.44,47.01 UCPU1.AT40
DDR_B_D18: length 27.9
  TOP w0.152: UD44.C11 121.01,26.76 v8(121.01,26.83)
  IN3 w0.095: v8(121.01,26.83) 120.81,27.04 120.81,29.33 119.05,31.08 118.92,31.08 118.76,30.93 118.63,30.93 118.49,31.06 118.49,31.2 118.65,31.35 118.65,31.49 118.52,31.62 118.38,31.62 118.22,31.46 118.09,31.46 117.96,31.6 117.96,31.73 118.11,31.89 118.11,32.02 117.95,32.19 117.81,32.19 117.66,32.03 117.52,32.03 117.39,32.17 117.39,32.3 117.54,32.46 117.54,32.59 117.41,32.73 117.27,32.73 117.12,32.57 116.98,32.57 116.85,32.71 116.85,32.84 117.01,33 117.01,33.13 116.87,33.26 116.74,33.26 116.58,33.11 116.45,33.11 116.31,33.24 116.31,33.38 116.47,33.53 116.47,33.67 116.33,33.8 116.2,33.8 116.04,33.65 115.91,33.65 115.69,33.86 115.69,40.07 115.44,40.32 115.44,41.95 116.15,42.65 116.15,43.11 115.98,43.27 115.98,43.73 116.59,44.34 116.59,46.5 116.13,46.96 v8(116.13,47.01)
  BOTTOM w0.152: v8(116.13,47.01) 116.27,47.01 UCPU1.AT37
DDR_B_D19: length 27.5
  TOP w0.152: v8(120.37,26.81) 120.37,26.75 UD44.B11
  IN3 w0.095: v8(120.37,26.81) 120.05,26.81 119.78,27.08 119.78,27.82 119.68,27.91 118.91,27.91 118.81,28.01 118.81,28.2 118.91,28.3 119.68,28.3 119.78,28.39 119.78,28.58 119.68,28.68 118.75,28.68 118.66,28.77 118.66,28.96 118.75,29.06 119.68,29.06 119.78,29.15 119.78,29.37 115.19,33.96 115.19,37 114.83,37.36 114.83,38.98 114.9,39.06 114.9,39.98 115.16,40.23 115.16,42.07 115.35,42.26 115.35,43.1 115.3,43.15 115.3,43.79 116.24,44.73 116.24,46.28 v8(116.16,46.36)
  BOTTOM w0.152: UCPU1.AU37 116.27,46.36 v8(116.16,46.36)
DDR_B_D20: length 29.7
  TOP w0.152: UD44.B8 120.36,24.36 v8(120.36,24.41)
  IN3 w0.076: v8(114.33,47.65) 113.96,47.28 113.96,46.74 113.62,46.4
  IN3 w0.095: 113.62,46.4 113.62,45.21 111.96,43.55 111.96,34.42 116.48,29.91 116.48,26.77 118.86,24.39 120.35,24.39 v8(120.36,24.41)
  BOTTOM w0.152: v8(114.33,47.65) 114.42,47.65 UCPU1.AR40
DDR_B_D21: length 31.9
  TOP w0.152: v8(120.98,23.57) 120.98,23.66 UD44.C8
  IN3 w0.076: 113.3,46.34 113.79,46.83 113.79,47.34 113.82,47.37 113.82,47.78 v8(114.33,48.28)
  IN3 w0.095: v8(120.98,23.57) 120.47,23.57 120,24.04 118.81,24.04 116.18,26.66 116.18,29.78 111.97,34 111.97,34.02 111.84,34.14 111.68,34.31 111.68,43.69 113.3,45.31 113.3,46.34
  BOTTOM w0.152: UCPU1.AP40 114.41,48.28 v8(114.33,48.28)
DDR_B_D22: length 29.1
  TOP w0.152: v8(121.67,24.43) 121.67,24.5 UD44.C9
  IN3 w0.095: v8(121.67,24.43) 122.11,24.87 122.11,26.45 121.09,27.47 121.09,29.47 115.98,34.59 115.98,39.91 116.47,40.4 116.47,41.4 116.48,41.4 116.48,41.44 117.28,42.24 117.28,43.21 117.68,43.61 117.68,45.83 116.6,46.91 116.6,47.84 v8(116.16,48.28)
  BOTTOM w0.152: v8(116.16,48.28) 116.24,48.28 UCPU1.AP37
DDR_B_D23: length 28.7
  TOP w0.152: UD44.C10 121.02,25.95 v8(121.02,26.03)
  IN3 w0.095: v8(121.02,26.03) 120.65,26.4 119.83,26.4 119.25,26.97 119.25,27.11 119.4,27.25 119.4,27.38 119.26,27.52 119.13,27.52 118.98,27.37 118.85,27.37 118.23,27.99 118.23,29.34 118.33,29.43 118.89,29.43 118.99,29.53 118.99,29.72 118.89,29.82 118.33,29.82 118.23,29.91 118.23,30.49 114.87,33.86 114.87,36.92 114.54,37.24 114.54,39.1 114.62,39.17 114.62,40.42 114.87,40.67 114.87,42.19 115.06,42.38 115.06,42.98 114.97,43.07 114.97,43.91 115.89,44.83 115.89,45.9 115.72,46.08 115.72,47.21 v8(116.16,47.65)
  BOTTOM w0.152: v8(116.16,47.65) 116.25,47.65 UCPU1.AR37
DDR_B_D24: length 35.7
  TOP w0.152: UD44.N11 127.52,26.75 v8(127.52,26.83)
  IN2 w0.095: v8(127.52,26.83) 126.75,27.61 126.75,28.98 126.75,29.58 126.08,30.25 125.69,30.25 120.62,35.33 119.86,35.33 118.77,36.42 118.77,42.35 116.96,44.15 116.13,44.15 115.85,44.43 114.29,44.43 112.83,45.89 112.83,46.04 112.99,46.21 113.3,46.21 114.64,44.86 115.74,44.86 115.86,44.99 115.86,45.35 115.97,45.45 116.68,45.45 117.01,45.78 117.36,45.78 117.54,45.96 117.54,46.51 117.99,46.95 v8(117.99,47.01)
  BOTTOM w0.152: v8(117.99,47.01) 118.1,47.01 UCPU1.AT33
DDR_B_D25: length 34.1
  TOP w0.152: v8(127.53,25.23) 127.53,25.29 UD44.M10
  IN2 w0.095: v8(117.99,46.38) 118.07,46.29 118.07,45.06 117.93,44.92 116.28,44.92 116.19,44.84 116.19,44.61 116.31,44.49 117.96,44.49 118.07,44.38 118.07,43.46 119.07,42.46 119.07,36.52 119.88,35.71 120.66,35.71 125.47,30.9 126.2,30.9 127.44,29.66 127.44,29.5 127.16,29.21 127.16,29.05 127.32,28.89 127.48,28.89 127.77,29.18 127.93,29.18 128.51,28.59 128.51,28.33 128.03,27.85 127.79,27.85 127.67,27.73 127.67,27.46 127.74,27.39 128.55,27.39 128.67,27.27 128.67,27.03 128.54,26.91 128.14,26.91 127.5,26.26 127.5,25.26 v8(127.53,25.23)
  BOTTOM w0.152: UCPU1.AU33 118.11,46.38 v8(117.99,46.38)
DDR_B_D26: length 35.5
  TOP w0.076: UD44.N9 127.52,24.5 127.52,23.4 v8(127.51,23.39)
  IN2 w0.095: v8(119.85,46.36) 119.85,45.84 121.34,44.35 121.34,44.34 121.45,44.24 121.45,39.62 122.1,38.97 122.1,37.31 122.1,36.82 122.35,36.57 122.35,36.05 122.45,35.95 123.2,35.95 129.04,30.11 129.78,30.11 132.1,27.78 132.1,24.3 131.38,23.58 131.13,23.58 130.62,24.09 129.68,24.09 129.45,23.86 127.98,23.86 v8(127.51,23.39)
  BOTTOM w0.152: UCPU1.AU30 119.92,46.36 v8(119.85,46.36)
DDR_B_D27: length 35.3
  TOP w0.076: v8(129.31,23.32) 128.84,23.79 128.84,24.48 UD44.P9
  IN2 w0.095: v8(129.31,23.32) 129.85,23.86 130.19,23.86 130.42,23.63 130.42,23.2 130.49,23.12 131.54,23.12 132.43,24.01 132.43,27.89 129.89,30.43 129.15,30.43 122.39,37.2 122.39,39.08 121.73,39.74 121.73,44.38 120.35,45.77 120.35,46.44 119.94,46.85 119.84,46.94 v8(119.84,47.01)
  BOTTOM w0.152: UCPU1.AT30 119.92,47.01 v8(119.84,47.01)
DDR_B_D28: length 37.7
  TOP w0.152: v8(126.87,26.83) 126.87,26.75 UD44.M11
  IN2 w0.095: v8(117.99,47.65) 117.49,47.15 117.49,46.86 116.48,45.85 114.11,45.85 113.86,46.11 113.86,46.37 113.72,46.51 113.06,46.51 112.94,46.63 112.94,47.09 112.83,47.2 112.18,47.2 112.08,47.1 112.08,46.21 114.16,44.13 115.65,44.13 115.95,43.83 116.74,43.83 117.52,43.05 117.52,41.3 117.76,41.06 118.24,41.06 118.46,40.84 118.46,36.26 120.15,34.57 120.86,34.57 125.48,29.95 125.95,29.95 126.44,29.45 126.44,29.11 126.44,27.26 v8(126.87,26.83)
  BOTTOM w0.152: v8(117.99,47.65) 118.08,47.65 UCPU1.AR33
DDR_B_D29: length 36.1
  TOP w0.152: UD44.N10 128.18,25.29 v8(128.18,25.23)
  IN2 w0.095: v8(128.18,25.23) 127.76,25.64 127.76,26.17 128.06,26.47 128.89,26.47 129.01,26.59 129.01,27.25 129.12,27.36 129.59,27.36 129.71,27.48 129.71,27.65 129.61,27.74 129.12,27.74 129.01,27.86 129.01,28.01 129.17,28.18 129.17,28.36 126.05,31.49 125.91,31.49 125.7,31.28 125.52,31.28 125.35,31.45 125.35,31.59 125.59,31.83 125.59,31.96 125.46,32.1 125.32,32.1 125.08,31.86 124.95,31.86 124.76,32.04 124.76,32.18 124.99,32.4 124.99,32.54 124.85,32.67 124.72,32.67 124.49,32.45 124.36,32.45 124.23,32.58 124.23,32.72 124.45,32.94 124.45,33.08 124.32,33.21 124.18,33.21 123.96,32.98 123.82,32.98 123.69,33.12 123.69,33.25 123.91,33.48 123.91,33.61 123.78,33.75 123.64,33.75 123.42,33.52 123.28,33.52 123.15,33.66 123.15,33.79 123.37,34.02 123.37,34.15 123.24,34.29 123.1,34.29 122.88,34.06 122.74,34.06 120.33,36.47 120.33,37.4 120.08,37.65 120.08,39.06 119.91,39.22 119.91,42.17 119.12,42.96 119.12,43.6 118.95,43.77 118.55,43.77 118.43,43.88 118.43,47.88 118.03,48.28 v8(117.99,48.28)
  BOTTOM w0.152: UCPU1.AP33 118.07,48.28 v8(117.99,48.28)
DDR_B_D30: length 37.5
  TOP w0.152: v8(126.91,23.37) 126.91,23.6 127.19,23.88 UD44.M8
  IN2 w0.095: v8(126.91,23.37) 126.91,23.16 127.11,22.96 127.47,22.96 127.62,22.82 131.64,22.82 132.73,23.91 132.73,28.02 130.04,30.72 129.3,30.72 122.67,37.34 122.67,39.2 122.04,39.84 122.04,44.5 120.84,45.7 120.84,46.29 120.3,46.83 120.3,47.16 v8(119.82,47.65)
  BOTTOM w0.152: v8(119.82,47.65) 119.91,47.65 UCPU1.AR30
DDR_B_D31: length 41.3
  TOP w0.076: v8(126.25,23.55) 126.37,23.67 126.62,23.67 126.89,23.94 126.89,24.52 UD44.M9
  IN2 w0.095: v8(126.25,23.55) 126.25,23.32 126.46,23.1 126.9,22.66 127.35,22.66 127.51,22.49 131.81,22.49 133.04,23.73 133.04,28.14 130.16,31.02 129.43,31.02 122.96,37.49 122.96,39.39 122.82,39.53 122.82,39.92 122.83,39.92 122.83,43.16 122.34,43.65 122.34,44.62 121.17,45.79 121.17,47.82 120.93,48.06 120.03,48.06 v8(119.82,48.28)
  BOTTOM w0.152: UCPU1.AP30 119.89,48.28 v8(119.82,48.28)
DDR_B_D32: length 33.2
  TOP w0.152: UD43.E11 137.89,26.75 v8(137.89,26.83)
  IN3 w0.095: v8(137.89,26.83) 137.89,26.87 137.5,27.26 136.85,27.26 136.08,28.03 134.95,28.03 130.36,32.62 127.23,32.62 126.24,33.61 125.71,33.61 125.62,33.7 125.62,34.47 125.52,34.57 125.33,34.57 125.24,34.47 125.24,33.7 125.14,33.61 124.3,33.61 124.12,33.78 124.12,33.92 124.43,34.22 124.43,34.36 124.29,34.49 124.16,34.49 123.85,34.19 123.72,34.19 121.55,36.35 121.55,37.07 v3(121.7,37.21)
  GND3 w0.152: v4(121.51,37.5) 121.51,37.4 v3(121.7,37.21)
  BOTTOM w0.076: v4(121.51,37.5) 121.44,37.5 v2(120.91,38.02) 120.28,38.66 120.28,39.24 119.99,39.52 119.99,42.33 119.92,42.4 119.92,42.72 120.04,42.84 120.04,43.14 119.96,43.22 119.96,43.74 119.98,43.77 120.13,44.14 120.13,44.42 120.4,44.69 UCPU1.AY31
DDR_B_D33: length 38.1
  TOP w0.152: v8(139.19,24.43) 139.19,24.35 UD43.F8
  IN3 w0.095: v8(139.19,24.43) 139.44,24.43 140.03,25.01 140.03,25.36 140.38,25.7 140.38,27.86 136.71,31.53 134.37,31.53 131.38,34.52 128.78,34.52 125.96,37.34 124.13,37.34 123.63,37.84 123.63,39.34 123.63,39.62 123.73,39.73 123.73,43.01 123.55,43.19 121.63,43.19 121.32,42.88 v3(120.75,42.88)
  GND3 w0.152: v4(121.02,42.65) 120.79,42.88 v3(120.75,42.88)
  BOTTOM w0.076: UCPU1.AW31 121.08,45.54 121.31,45.31 121.31,44.42 121.3,44.41 121.28,44.35 121.28,44.18 121.35,43.97 121.35,43.85 121.29,43.69 121.29,43.33 121.02,43.06 v4(121.02,42.65)
DDR_B_D34: length 34.5
  TOP w0.152: v8(138.54,25.23) 138.54,25.15 UD43.F9
  IN3 w0.095: v3(120.35,41.62) 119.92,41.19 119.92,39.34 120.07,39.2 120.07,38.7 120.32,38.45 120.32,38.35 120.62,38.05 120.62,36.02 124.42,32.22 125.59,32.22 126.05,31.76 129.95,31.76 133.43,28.28 133.43,28.28 133.83,27.88 133.83,27.88 133.84,27.87 133.84,26.62 135.61,24.85 138.16,24.85 v8(138.54,25.23)
  GND3 w0.152: v4(121.02,41.46) 120.87,41.61 120.37,41.61 120.36,41.62 v3(120.35,41.62)
  BOTTOM w0.076: v4(121.02,41.46) 121.15,41.46 121.34,41.66 121.34,43.1 121.46,43.22 121.46,43.66 121.52,43.82 121.52,43.99 121.46,44.18 121.46,44.29 121.52,44.5 121.52,44.79 UCPU1.AY29
DDR_B_D35: length 34.5
  TOP w0.152: v8(138.54,24.43) 138.54,24.5 UD43.E9
  IN3 w0.095: v8(138.54,24.43) 138.94,24.82 139.43,24.82 139.61,25 139.61,25.42 140.03,25.84 140.03,27.78 136.58,31.24 134.25,31.24 131.25,34.23 128.66,34.23 126.3,36.59 124.48,36.59 123.34,37.73 123.34,39.16 122.43,40.07 v3(122.43,40.3)
  GND3 w0.152: v3(122.43,40.3) 122.26,40.46 v4(122.13,40.46)
  BOTTOM w0.076: UCPU1.AW29 121.62,45.33 121.96,44.99 121.96,44.77 121.96,44.77 121.96,44.41 122.15,44.22 122.15,43.3 122.25,43.21 122.25,42.99 122.43,42.8 122.43,40.99 122.13,40.69 v4(122.13,40.46)
DDR_B_D36: length 30.7
  TOP w0.152: v8(137.89,25.23) 137.89,25.15 UD43.D9
  IN3 w0.095: v8(137.89,25.23) 137.49,25.63 135.25,25.63 134.14,26.74 134.14,27.98 134.12,28 130.07,32.05 126.36,32.05 125.9,32.5 124.54,32.5 120.91,36.14 120.91,38.42 v3(120.53,38.81)
  GND3 w0.152: v4(120.77,39.06) 120.77,39.05 v3(120.53,38.81)
  BOTTOM w0.076: v4(120.77,39.06) 120.77,39.21 120.32,39.66 120.32,42.51 120.4,42.58 UCPU1.BB31
DDR_B_D37: length 31.3
  TOP w0.152: UD43.E10 137.89,25.95 v8(137.89,26.03)
  IN3 w0.095: v3(121.61,38.53) 121.2,38.12 121.2,36.26 124.66,32.79 126.16,32.79 126.62,32.33 130.19,32.33 130.93,31.6 134.41,28.12 134.85,27.67 135.17,27.67 135.45,27.39 135.45,26.7 135.72,26.42 137.49,26.42 v8(137.89,26.03)
  GND3 w0.152: v3(121.61,38.53) 121.61,38.56 121.39,38.77 121.38,38.77 121.37,38.78 v4(121.37,38.78)
  BOTTOM w0.076: v4(121.37,38.78) 121.36,38.77 120.65,38.77 120.64,38.78 120.64,38.78 120.44,38.98 120.44,39.31 120.16,39.59 120.16,42.4 120.09,42.47 120.09,42.65 120.21,42.77 120.21,43.21 120.13,43.28 120.13,43.7 120.26,43.95 120.4,44.09 UCPU1.BA31
DDR_B_D38: length 32.9
  TOP w0.152: v8(138.54,26.03) 138.54,25.95 UD43.F10
  IN3 w0.095: v3(122.42,41.39) 122.35,41.39 122.23,41.51 122.02,41.51 121.8,41.29 121.8,40.44 121.83,40.41 121.83,40.26 123.05,39.04 123.05,37.61 124.36,36.3 126.18,36.3 128.54,33.95 131.13,33.95 134.13,30.95 136.41,30.95 139.66,27.7 139.66,25.91 139.36,25.61 138.96,25.61 v8(138.54,26.03)
  GND3 w0.152: v3(122.42,41.39) 122.09,41.39 v4(122.06,41.42)
  BOTTOM w0.076: UCPU1.BA29 121.72,44.02 121.99,43.75 121.99,43.23 122.08,43.14 122.08,42.92 122.26,42.73 122.26,41.96 122.06,41.76 v4(122.06,41.42)
DDR_B_D39: length 30.2
  TOP w0.076: v8(138.39,28.09) 138.39,27.55 138.53,27.4 138.53,26.76 UD43.F11
  IN3 w0.095: v8(138.39,28.09) 138.39,28.55 136.27,30.66 134.01,30.66 131.02,33.66 128.42,33.66 126.07,36.02 124.24,36.02 122.77,37.49 122.77,38.92 121.55,40.14 121.55,40.29 121.51,40.32 121.51,42.58 121.74,42.8 122.16,42.8 v3(122.45,42.51)
  GND3 w0.152: v3(122.45,42.51) 122.04,42.51 121.98,42.45 v4(121.93,42.45)
  BOTTOM w0.076: UCPU1.BB29 121.72,42.65 121.92,42.45 v4(121.93,42.45)
DDR_B_D40: length 28.8
  TOP w0.152: UD43.B8 135.94,24.35 v8(135.94,24.43)
  IN2 w0.095: v3(123.29,40.87) 123.44,40.72 123.54,40.72 123.76,40.5 123.76,40.5 123.76,40.19 123.65,40.07 123.65,37.77 129.67,31.74 130.46,31.74 133.82,28.39 133.82,24.58 133.91,24.48 134.45,23.94 134.79,23.94 135.27,24.43 v8(135.94,24.43)
  GND3 w0.152: v3(123.29,40.87) 123.29,40.89 123.28,40.9 v4(123.28,41.2)
  BOTTOM w0.076: v4(123.28,41.2) 123.51,41.43 123.51,42.84 123.16,43.19 123.16,43.28 123.05,43.56 122.96,43.84 122.96,43.98 122.97,44.03 122.97,44.04 123.01,44.18 123.01,44.33 122.97,44.43 122.97,44.63 122.85,44.75 UCPU1.AY27
DDR_B_D41: length 30.5
  TOP w0.152: UD43.C8 136.59,23.7 v8(136.59,23.63)
  IN2 w0.095: v3(123.25,39.78) 123.36,39.67 123.36,37.65 129.57,31.44 130.34,31.44 133.46,28.32 133.46,24.25 134.08,23.63 v8(136.59,23.63)
  GND3 w0.152: v4(123.01,40.01) 123.08,39.95 v3(123.25,39.78)
  BOTTOM w0.076: UCPU1.AW27 122.85,45.4 122.57,45.12 122.57,44.59 122.32,44.34 122.32,43.37 122.41,43.28 122.41,43.09 122.59,42.91 122.59,40.43 v4(123.01,40.01)
DDR_B_D42: length 28.8
  TOP w0.152: v8(136.59,24.43) 136.59,24.5 UD43.B9
  IN2 w0.095: v8(136.59,24.43) 136.2,24.81 135.68,24.81 135.51,24.98 134.61,24.98 134.42,24.79 134.26,24.79 134.12,24.93 134.12,28.51 130.59,32.05 129.85,32.05 124.27,37.64 v3(124.27,37.75)
  GND3 w0.152: v3(124.27,37.75) 124.31,37.79 v4(124.61,37.79)
  BOTTOM w0.076: UCPU1.AY25 124.3,44.67 124.44,43.88 124.51,43.73 124.51,42.76 125,42.26 125,39.17 124.4,38.57 124.4,37.99 v4(124.61,37.79)
DDR_B_D43: length 29.7
  TOP w0.152: UD43.B10 135.94,25.3 v8(135.94,25.23)
  IN2 w0.095: v3(124.2,38.84) 124.21,38.84 124.65,38.4 124.65,37.68 129.98,32.35 130.72,32.35 134.04,29.03 134.48,29.03 134.65,28.85 134.65,28.66 134.43,28.44 134.43,28.31 134.54,28.19 134.72,28.19 134.84,28.08 134.84,27.85 134.72,27.74 134.54,27.74 134.43,27.62 134.43,26.49 134.82,26.1 134.82,25.94 134.53,25.65 134.53,25.49 134.69,25.33 134.85,25.33 135.26,25.74 135.57,25.74 135.94,25.37 v8(135.94,25.23)
  GND3 w0.152: v4(123.94,39.05) 124.01,39.03 v3(124.2,38.84)
  BOTTOM w0.076: v4(123.94,39.05) 123.94,39.59 123.68,39.85 123.68,42.93 123.41,43.2 123.23,43.58 123.13,43.83 123.12,43.87 123.12,43.96 123.18,44.16 123.18,44.4 123.16,44.42 123.16,45.26 123.44,45.54 UCPU1.AW25
DDR_B_D44: length 32.1
  TOP w0.152: UD43.C10 136.58,25.96 v8(136.58,26.03)
  IN2 w0.095: v3(123.33,41.69) 123.52,41.69 123.73,41.89 123.73,43.07 124,43.35 124.33,43.35 124.54,43.14 124.54,42.55 125.71,41.38 126.36,41.38 126.89,40.85 126.99,40.75 126.99,39.15 128.09,38.05 128.09,37.2 129.1,36.19 129.1,35.61 129.78,34.93 130.52,34.93 133.83,31.61 135.44,31.61 137.92,29.13 137.92,27.4 138.39,26.93 138.39,26.69 138.14,26.44 136.99,26.44 v8(136.58,26.03)
  GND3 w0.152: v3(123.33,41.69) 123.18,41.69 123.01,41.52 v4(122.98,41.52)
  BOTTOM w0.076: UCPU1.BB27 122.75,43.3 123.33,42.72 123.33,41.87 v4(122.98,41.52)
DDR_B_D45: length 33.6
  TOP w0.152: UD43.C9 137.24,24.5 v8(137.24,24.43)
  IN2 w0.095: v3(123.35,42.76) 123.35,43.1 123.88,43.63 123.89,43.63 123.9,43.64 124.74,43.64 125.52,42.86 125.52,42.62 127.31,40.83 127.31,39.76 128.4,38.67 128.4,37.32 129.38,36.34 129.38,35.73 129.88,35.23 130.67,35.23 133.99,31.91 135.54,31.91 139.41,28.05 139.41,27.21 139.6,27.02 139.6,25.11 139.31,24.81 137.63,24.81 v8(137.24,24.43)
  GND3 w0.152: v3(123.35,42.76) 123.18,42.76 123.03,42.61 v4(123.04,42.59)
  BOTTOM w0.076: UCPU1.BA27 122.48,43.98 122.48,43.44 122.58,43.35 122.58,43.21 123.03,42.75 v4(123.04,42.59)
DDR_B_D46: length 27.6
  TOP w0.152: v8(137.24,26.83) 137.24,26.75 UD43.C11
  IN2 w0.095: v8(137.24,26.83) 137.58,27.17 137.58,29 137.41,29.17 137.25,29.17 137,28.92 136.84,28.92 136.68,29.08 136.68,29.24 136.92,29.49 136.92,29.65 135.53,31.05 135.25,31.05 135.13,31.16 135.13,31.19 135.02,31.3 134.79,31.3 134.68,31.19 134.68,31.16 134.56,31.05 133.96,31.05 130.39,34.62 129.65,34.62 128.81,35.46 128.81,36.05 127.75,37.11 127.75,37.98 127.59,38.14 127.46,38.14 127.32,38.01 127.19,38.01 127.05,38.14 127.05,38.28 127.19,38.41 127.19,38.55 126.67,39.07 126.67,39.54 126.57,39.63 126.33,39.63 126.13,39.83 126.13,40.41 124.16,42.39 v3(124.15,42.39)
  GND3 w0.152: v3(124.15,42.39) 124.33,42.39 v4(124.5,42.21)
  BOTTOM w0.076: v4(124.5,42.21) 124.34,42.37 124.34,43.7 124.19,44.01 124.08,44.13 UCPU1.BA25
DDR_B_D47: length 27.3
  TOP w0.152: UD43.B11 135.94,26.75 v8(135.94,26.83)
  IN2 w0.095: v8(135.94,26.83) 136.36,27.25 136.36,27.49 136.48,27.6 136.6,27.6 136.72,27.72 136.72,27.95 136.6,28.06 136.48,28.06 136.36,28.17 136.36,29.78 135.4,30.74 134.63,30.74 134.33,30.44 134.14,30.44 131.16,33.42 130.42,33.42 130.25,33.59 130.25,33.75 130.45,33.95 130.45,34.11 130.29,34.27 130.13,34.27 129.93,34.08 129.77,34.08 128.53,35.32 128.53,35.93 127.47,36.99 127.47,37.32 126.85,37.94 126.76,37.94 126.51,38.19 126.51,38.32 126.69,38.5 126.69,38.64 126.53,38.79 126.39,38.79 126.09,38.49 125.95,38.49 125.82,38.62 125.82,38.76 126.11,39.05 126.11,39.19 125.85,39.45 125.85,40.29 124.34,41.8 v3(124.13,41.8)
  GND3 w0.152: v4(124.49,41.76) 124.45,41.8 v3(124.13,41.8)
  BOTTOM w0.076: UCPU1.BB25 124.08,43.39 124.17,43.3 124.17,42.08 v4(124.49,41.76)
DDR_B_D48: length 41.5
  TOP w0.152: v8(145.69,26.03) 145.69,25.95 UD43.T10
  IN3 w0.095: v8(121.63,46.32) 121.55,46.25 121.55,45.5 122.66,44.39 124.8,44.39 126.07,43.13 126.07,39.59 126.43,39.22 126.56,39.22 126.9,39.56 127.03,39.56 127.17,39.43 127.17,39.29 126.83,38.95 126.83,38.82 126.97,38.69 127.1,38.69 127.44,39.02 127.57,39.02 127.71,38.89 127.71,38.75 127.37,38.42 127.37,38.28 127.51,38.15 127.64,38.15 127.98,38.48 128.11,38.48 128.25,38.35 128.25,38.21 127.91,37.88 127.91,37.74 128.05,37.61 128.18,37.61 128.52,37.94 128.65,37.94 129.28,37.32 129.54,37.32 130.19,36.67 130.75,36.67 131.06,36.36 131.9,36.36 135.39,32.87 137.37,32.87 140.24,30 143.91,30 146.09,27.82 146.09,26.52 145.69,26.12 v8(145.69,26.03)
  BOTTOM w0.152: UCPU1.AU27 121.71,46.32 v8(121.63,46.32)
