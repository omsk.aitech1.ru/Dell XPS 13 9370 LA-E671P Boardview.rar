# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2C1_SCK: length 16.1
  BOTTOM w0.095: RH80.2 R114.1 167.48,4.94 168.15,5.62 169.09,5.62 170.03,4.68 MD2.3 170.68,3.69 170.97,3.4 v10(172.59,3.4) 173.09,3.4 175.15,5.47 176.31,5.47 177.72,6.88 177.72,7.52 177.58,7.66 JTP1.3
I2C1_SCK_TP: length 83.4
  IN2 w0.064: v3(172.57,7.72) 172.57,7.56 172.34,7.34 171.11,7.34 167.83,10.62 166.25,10.62 165.88,10.99 164.66,10.99 163.19,12.46 163.19,13.3 157.73,18.76 157.73,26.01 157.02,26.72 157.02,30.03 156.02,31.03 156.02,32.1 152.3,35.82 152.3,38.52 149.25,41.57 149.25,44.41 148.17,45.5 148.17,46.99 144.14,51.02 144.14,51.54 140.78,54.9 140.78,55.82 139.46,57.13 133,57.13 v3(132.64,57.5)
  GND3 w0.095: v4(132.88,57.17) 132.88,57.25 v3(132.64,57.5) ; v3(172.57,7.72) 172.57,7.37 v6(172.53,7.33)
  IN4 w0.076: v5(165.83,5.54) 165.97,5.68 168.31,5.68 169.07,6.44 171.58,6.44 172.48,7.33 v6(172.53,7.33)
  BOTTOM w0.095: RH80.1 165.93,4.03 165.75,4.21 165.75,5.46 v5(165.83,5.54)
I2C1_SDA: length 18.2
  BOTTOM w0.095: JTP1.2 178.08,7.66 177.94,7.52 177.94,6.79 176.4,5.25 175.24,5.25 173.18,3.18 172.84,3.18 172.83,3.18 172.36,3.18 172.35,3.18 170.88,3.18 169.38,4.68 MD2.2 168.75,2.31 168.2,1.76 v2(168.11,1.76) 167.63,1.76 R113.1 RH79.2
I2C1_SDA_TP: length 84.1
  IN2 w0.064: v3(133.21,57.53) 133.42,57.32 139.54,57.32 140.97,55.9 140.97,54.98 144.33,51.61 144.33,51.1 148.36,47.07 148.36,45.57 149.45,44.49 149.45,41.65 152.49,38.6 152.49,35.9 156.21,32.18 156.21,31.11 157.21,30.11 157.21,26.8 157.92,26.09 157.92,18.84 163.38,13.38 163.38,12.54 164.74,11.18 165.96,11.18 166.33,10.81 167.91,10.81 171.19,7.53 171.83,7.53 172,7.7 v3(172,7.73)
  GND3 w0.095: v4(133.17,56.84) 133.17,57.03 133.21,57.08 v3(133.21,57.53) ; v3(172,7.73) 171.91,7.64 v6(171.91,7.38)
  IN4 w0.076: v5(165.45,5.54) 165.45,5.59 165.74,5.88 168.22,5.88 168.98,6.64 171.49,6.64 171.98,7.12 171.98,7.23 171.91,7.3 v6(171.91,7.38)
  BOTTOM w0.076: UCPU1.U8 v4(133.17,56.84)
  BOTTOM w0.095: v5(165.45,5.54) 165.45,4.2 v2(165.29,4.05) 165.29,3.55 165.66,3.18 RH79.1
I2C2_IRQ_TS: length 137.7
  TOP w0.095: v8(134.56,59.74) 134.62,59.8 136.83,59.8 137.15,59.48 v7(138.15,59.48) 139.1,59.48 139.72,60.1 139.72,60.92 v2(139.99,61.2) RH83.2
  IN1 w0.076: v9(51.89,61.28) 51.89,61.54 51.19,62.24 45.49,62.24 44.18,63.55 44.18,66.08 44.36,66.26 44.36,67.44 43.74,68.06 43.51,68.06 42.8,68.77 42.8,70.45 43.76,71.41 45.12,71.41 45.61,70.92 51.58,70.92 51.78,71.12 57.69,71.12 58.14,71.57 77.81,71.57 79.49,69.89 84.63,69.89 86.71,71.97 90.39,71.97 93.18,69.17 93.18,68.44 94.13,67.49 97.59,67.49 97.94,67.85 99.45,67.85 99.87,67.42 105.2,67.42 105.5,67.73 110.31,67.73 111.78,66.26 111.78,65.55 112.38,64.94 116.95,64.94 117.28,65.27 121.29,65.27 122.25,64.31 122.49,64.31 123.97,62.83 123.97,61.49 124.46,60.99 124.46,58.88 124.41,58.83 124.41,58.25 125.22,57.44 126.93,57.44 127.78,56.6 130.6,56.6 130.91,56.9 132.69,56.9 133.17,57.39 136.21,57.39 138.15,59.32 v7(138.15,59.48)
  GND1 w0.095: v3(51.89,60.92) v9(51.89,61.28)
  GND3 w0.095: v4(52.14,60.67) v3(51.89,60.92)
  BOTTOM w0.095: v4(52.14,60.67) 52.14,60.14 52.45,59.82 RR17.1
  BOTTOM w0.112: v8(134.56,59.74) 134.83,60.01 UCPU1.L6
I2C2_SCK_EDP_PCH: length 102.4
  IN3 w0.064: v8(132.55,51.42) 132.75,51.62 132.75,52.26 132.28,52.74 130.81,52.74 130.4,53.15 130.4,53.59 129.3,54.69 127.91,54.69 127.05,55.56 125.18,55.56 123.17,57.56 120.54,57.56 119.99,57.01 118.72,57.01 118.36,56.65 118.36,55.2 117.97,54.81 113.81,54.81 113,54 111.3,54 108.12,57.17 104.38,57.17 102.42,59.13 94.97,59.13 93.77,57.93 83.27,57.93 78.65,62.54 77.81,62.54 77.45,62.91 76.84,62.91 75.48,64.27 70.23,64.27 69.78,63.81 62.61,63.81 62.28,63.48 62.28,61.28 59.61,58.61 49.02,58.61 48.25,57.84 47.82,57.84 47.59,58.08 v3(47.59,58.32)
  GND3 w0.095: v3(47.59,58.32) 47.46,58.45 v4(47.46,58.76)
  BOTTOM w0.076: UCPU1.AH10 132.23,51.73 v8(132.55,51.42)
  BOTTOM w0.095: RR19.1 47.33,58.63 v4(47.46,58.76)
I2C2_SDA_EDP_PCH: length 102.2
  IN3 w0.064: v3(48.15,58.33) 48.46,58.33 48.94,58.8 59.53,58.8 62.09,61.36 62.09,63.56 62.53,64 69.7,64 70.16,64.46 75.56,64.46 76.92,63.1 77.53,63.1 77.89,62.73 78.73,62.73 83.34,58.12 93.69,58.12 94.89,59.32 102.5,59.32 104.46,57.36 108.2,57.36 111.38,54.19 112.92,54.19 113.74,55 117.89,55 118.17,55.28 118.17,56.73 118.64,57.2 119.91,57.2 120.46,57.75 123.25,57.75 125.25,55.75 127.13,55.75 127.99,54.88 129.38,54.88 130.59,53.67 130.59,53.23 130.89,52.93 132.36,52.93 132.95,52.34 132.95,51.63 v8(133.19,51.39)
  GND3 w0.095: v3(48.15,58.33) 48.15,58.25 47.76,57.87 v4(47.46,57.87)
  BOTTOM w0.076: UCPU1.AH9 132.88,51.69 v8(133.19,51.39)
  BOTTOM w0.095: RR18.1 47.33,58 v4(47.46,57.87)
I2C_DAT1_PD3: length 2.4
  BOTTOM w0.095: R5771.2 283.64,13.94 U21.D1
I2C_EN: length 4
  TOP w0.095: R5807.1 271.95,18.78 271.95,19.15 R5834.2 R5802.2 271.72,20.9 C49.1 271.51,21.1 U30.17
I2C_IRQ1_PD3: length 4.3
  BOTTOM w0.095: R5773.2 281.95,13.44 283.5,13.44 284.89,14.82 U21.C1
I2C_SCL1_PD3: length 5.7
  IN4 w0.076: v5(284.3,15.26) 284.36,15.26 284.42,15.32 v5(285.52,15.32)
  BOTTOM w0.095: v5(284.3,15.26) 283.45,14.41 280.8,14.41 R5772.2
I_ADP: length 7.9
  TOP w0.095: v2(16.41,5.57) 16.05,5.93 PR341.2 15.36,5.97 14.95,6.38 14.83,6.38 14.67,6.53 14.67,8.24 14.51,8.4 14.51,8.96 15.03,9.48 15.85,9.48 16.35,9.97 16.35,10.46 UE3.B11
I_BATT: length 2.5
  BOTTOM w0.095: RE125.2 28.61,18.66 28.73,18.55 PR342.2 29.17,18.55 30.19,19.56 v2(30.27,19.56)
I_BATT_R: length 9.3
  TOP w0.095: v1(22.53,16.1) 22.3,16.33 UE3.J4
  GND1 w0.095: v3(21.9,16) 22,16.1 v1(22.53,16.1)
  GND3 w0.095: v6(21.99,16.36) 21.99,16.09 v3(21.9,16)
  IN4 w0.076: v5(26.31,18.65) 26.18,18.53 25.23,18.53 24.88,18.18 24.88,17.9 24,17.02 22.7,17.02 22.05,16.36 v6(21.99,16.36)
  BOTTOM w0.095: v5(26.31,18.65) 26.31,18.96 v2(26.41,19.06) 26.44,19.09 26.74,19.09 27.21,19.55 CE60.1 RE125.1
I_SYS: length 104.5
  TOP w0.095: PR1000.2 35.99,42.49 35.99,41.61 36.12,41.49 36.28,41.49 37.09,40.68 38.42,40.68 38.59,40.51 38.59,39.93 37.87,39.21 37.87,38.85 38.4,38.31 38.4,32.43 38.22,32.25 38.22,26.33 38.01,26.11 38.01,24.22 37.87,24.09 37.87,22.97 37.7,22.79 37.7,22.78 36.66,21.74 36.66,19.21 36.86,19.01 36.86,15.38 v7(36.54,15.07) ; v1(66.94,1.88) 66.99,1.88 67.81,2.71 v2(67.81,3.54) 67.47,3.88 PR329.2 PR333.1
  TOP w0.203: PU1000.1 38.97,44.69 38.76,44.48 37.94,44.48 36.51,43.06 PC1000.2
  TOP w0.254: PR1000.2 PC1000.2
  IN1 w0.076: v9(29.54,17.84) 29.95,17.43 30.39,17.43 32.75,15.07 v7(36.54,15.07)
  GND1 w0.095: v9(29.54,17.84) 29.54,17.73 v3(29.34,17.53) ; v1(66.94,1.88) 67.15,1.68 v3(67.45,1.68)
  IN3 w0.064: v3(29.34,17.53) 29.82,17.53 30.49,16.86 30.49,16.06 30.31,15.88 30.31,11.84 29.68,11.21 29.68,10.55 30.07,10.16 30.07,6.68 29.83,6.43 29.83,4.99 30.49,4.33 33.43,4.33 35.02,2.75 58.03,2.75 58.29,2.48 67.19,2.48 67.45,2.23 v3(67.45,1.68)
  GND3 w0.095: v3(29.34,17.53) 28.89,17.53 v4(28.69,17.33)
  BOTTOM w0.095: v4(28.69,17.33) 28.68,17.31 28.54,17.31 28.23,17.62 RE126.2
I_SYS_R: length 15.2
  TOP w0.095: UE3.J5 21.12,16.03 v8(21.11,16.03) ; v8(26.06,18.03) 26.25,17.84 28.46,17.84 28.61,17.99 28.61,19.11 29.07,19.57 29.07,20.14 CE61.1 ; RE159.1 29.4,22.1 v2(29.12,22.38)
  TOP w0.112: RE159.1 CE61.1
  IN4 w0.076: v8(21.11,16.03) 22.17,16.03 22.85,16.72 24.12,16.72 25.02,17.62 25.65,17.62 v8(26.06,18.03)
  BOTTOM w0.095: v8(26.06,18.03) 26.34,17.75 RE126.1
ILMT_1.0V: length 2.8
  BOTTOM w0.254: PU700.13 134.8,7.97 134.61,8.16 134.3,8.16 PR707.1 132.89,8.7 PR706.2
ILMT_DDR: length 6.6
  BOTTOM w0.095: PR604.2 v2(113.25,1.74)
  BOTTOM w0.254: PR604.2 114.27,2.74 PR606.1 114.27,2.92 114.62,3.27 115.36,3.27 115.93,3.84 117.08,3.84 117.47,4.23 PU600.17
IMVP_VR_ON: length 53.7
  TOP w0.095: v2(35.07,41.13) 34.56,41.64 PR1020.1 34.28,42.07 33.94,42.4 v7(33.51,42.4) ; RE10.2 7.24,25.48 v1(7.66,25.48) 8,25.14 8.83,25.14 9.03,25.34 UC8.2
  IN1 w0.076: v9(23.88,35.35) 24,35.35 24.4,35.76 25.48,35.76 26.31,36.59 26.31,39.21 29.11,42.02 33.12,42.02 v7(33.51,42.4)
  GND1 w0.095: v3(6.99,26.03) 7.54,25.48 v1(7.66,25.48) ; v3(23.46,35.34) 23.54,35.41 23.81,35.41 v9(23.88,35.35)
  GND3 w0.095: v4(6.52,26.57) 6.52,26.5 v3(6.99,26.03) ; v3(23.46,35.34) 23.46,35.11 v6(23.61,34.96)
  IN4 w0.076: v6(23.61,34.96) 23.56,34.91 8.07,34.91 v5(7.47,35.5)
  BOTTOM w0.095: v5(7.47,35.5) 7.15,35.19 5.68,35.19 4.32,33.83 4.32,32.76 4.51,32.57 4.51,29.52 3.55,28.56 RE188.1 3.55,27 3.71,26.83 UE6.4 5.02,26.83 5.63,27.44 6.24,27.44 6.52,27.17 v4(6.52,26.57)
IMVP_VR_ON_EC: length 27.7
  TOP w0.095: UE3.N7 19.9,20.15 19.39,20.66 19.39,21.39 v1(19.28,21.5) 18.87,21.92 RPE6.2
  GND1 w0.095: v1(19.28,21.5) 19.28,21.86 v3(19.31,21.88)
  GND3 w0.095: v3(19.31,21.88) 19.31,22.21 19.23,22.28 v6(19.23,22.58)
  IN4 w0.076: v6(19.23,22.58) 18.68,23.14 16.97,23.14 16.52,22.69 12.94,22.69 11.58,24.05 11.58,24.95 11.07,25.46 6.46,25.46 4.03,27.9 v5(2.63,27.9) 2.61,27.87 v5(2.61,25.53)
  BOTTOM w0.095: v2(3.43,28.96) 2.63,28.16 v5(2.63,27.9)
IMVP_VR_ON_P: length 87
  TOP w0.095: v1(10.14,35.67) 11.19,36.73 14.5,36.73 14.75,36.48 17.55,36.48 17.74,36.67 17.74,37.03 18.96,38.25 20.39,38.25 21.31,39.17 24.34,39.17 27.54,42.37 v2(29.08,42.37) 29.38,42.37 32.05,39.71 36.07,39.71 37.05,38.73 v1(37.05,38.36) ; UC8.4 8.38,24.29 8.13,24.54 6.2,24.54 5.84,24.9 RE10.1 RE9.1 3.65,25.88 3.43,26.1 v7(3.43,26.61)
  IN1 w0.076: v9(7.27,35.3) 6.95,34.97 6.95,30.47 6.43,29.95 6.43,29.46 5.64,28.67 5.26,28.67 3.43,26.84 v7(3.43,26.61)
  GND1 w0.095: v3(10.14,35.1) v1(10.14,35.67) ; v9(7.27,35.3) 7.5,35.3 v3(7.74,35.06) ; v1(37.05,38.36) 37.06,38.38 37.34,38.38 v3(37.54,38.18)
  IN2 w0.064: v3(57.61,38.04) 57.58,38.04 56.89,38.74 47.79,38.74 47.16,38.11 42.23,38.11 41.83,38.5 38.05,38.5 37.73,38.18 v3(37.54,38.18) ; v3(7.74,35.06) 8.43,35.06 8.59,35.21 10.02,35.21 v3(10.14,35.1)
  IN2 w0.254: v3(57.61,38.04) 58.67,36.98 60.42,36.98 62,38.56 65.9,38.56 66.79,37.66 67.46,37.66 v3(67.48,37.68)
  GND3 w0.254: v4(57.57,37.54) 57.57,38 v3(57.61,38.04) ; v4(67.85,37.71) 67.51,37.71 v3(67.48,37.68)
IMVP_VR_PG: length 161.2
  TOP w0.095: UC10.1 UC10.2 131.01,34.88 RC390.1 129.95,34.13 129.69,34.39 v1(129.69,35.17) ; v1(35.32,45.19) 34.84,44.71 34.43,44.71 33.69,43.97 v11(33.36,43.97)
  IN1 w0.076: v1(35.32,45.19) 37.86,45.19 38.69,44.37 v9(38.69,40.17)
  GND1 w0.095: v3(130.51,35.71) 129.97,35.17 v1(129.69,35.17) ; v9(38.69,40.17) 38.29,39.77 v3(38.26,39.77)
  IN2 w0.064: v8(76.67,22.18) 76.67,21.56 78.12,20.11 78.12,16.09 78.7,15.52 78.7,13.69 76.42,11.42 75.11,11.42 74.65,10.96 70.97,10.96 70.26,10.25 62.52,10.25 62.09,10.67 62.09,11.49 61.39,12.18 60.66,12.18 60.33,12.52 55.19,12.52 52.57,15.13 44.83,15.13 42.67,17.29 40.66,17.29 38.91,19.04 38.91,19.75 37.93,20.74 37.93,21.89 37.61,22.21 37.41,22.21 36.83,22.79 36.83,24.71 37.94,25.83 37.94,26.25 38.44,26.75 38.44,28.02 37.61,28.85 37.61,35.76 36.95,36.41 36.7,36.41 36.31,36.8 36.31,38.92 37.31,39.92 38.11,39.92 v3(38.26,39.77)
  GND3 w0.095: v3(130.51,35.71) v6(131.07,35.71)
  IN4 w0.076: v6(131.07,35.71) 131.07,34.61 130.22,33.76 106.43,33.76 106.15,34.05 102.45,34.05 101.86,33.45 83.65,33.45 80.59,30.39 80.59,30.09 80.07,29.57 80.07,25.69 78.12,23.74 78.12,23.48 76.81,22.18 v8(76.67,22.18)
IMVP_VR_PG_R: length 16.7
  TOP w0.095: UC10.4 131.12,35.53 130.63,35.05 RC390.2 130.27,35.38 130.38,35.49 v1(130.38,36.67) 130.38,36.71 v2(130.79,37.12)
  GND1 w0.095: v3(130.38,37.18) v1(130.38,36.67)
  GND3 w0.095: v6(131.07,37.1) 130.99,37.18 v3(130.38,37.18)
  IN4 w0.076: v6(131.07,37.1) 131.07,40.66 130.47,41.26 128.32,41.26 128.14,41.08 128.14,40.78 v5(128.08,40.72)
  BOTTOM w0.095: UCPU1.BA20 126.6,44.09 126.32,43.82 126.32,43.41 126.47,43.26 126.47,42.4 126.82,42.06 127.22,42.06 128.08,41.2 v5(128.08,40.72)
INTRUDER#: length 18.2
  TOP w0.095: v8(127.99,48.35) 128.49,48.86 v2(128.49,49.24) ; v1(133.82,38.33) 133.38,37.89 RC78.1
  GND1 w0.095: v1(133.82,38.33) 133.88,38.33 134.04,38.49 v3(134.04,38.61)
  GND3 w0.095: v6(133.62,38.45) 133.78,38.61 v3(134.04,38.61)
  IN4 w0.076: v8(127.99,48.35) 127.97,48.33 127.92,48.33 127.92,48.32 127.83,48.32 127.51,48 127.51,46.07 128.95,44.62 131.95,44.62 133.28,43.29 133.28,41.78 133.78,41.28 133.78,40.37 133.48,40.08 133.48,38.59 v6(133.62,38.45)
  BOTTOM w0.112: UCPU1.AP16 128.19,48.35 v8(127.99,48.35)
INV_PWM_R: length 19.4
  TOP w0.095: v8(46.93,62.94) v11(45.3,62.94) ; v8(46.93,62.94) 46.93,61.86 v11(46.61,61.54) ; v8(46.93,62.94) 46.93,63.9 v11(46.52,64.31)
  BOTTOM w0.095: D6.1 56.61,67.12 R16.2 MC1.1 55.1,66.86 52.8,66.86 52.03,66.09 52.03,64.41 50.55,62.94 v8(46.93,62.94) 46.86,62.94 46.58,62.65 JEDP1.10
ISEN1_GT: length 7.4
  TOP w0.095: v2(45.33,44.09) 45.65,43.77 PR1153.2
  TOP w0.203: PU1000.9 42.17,43.88 42.99,43.06 PC1029.2
  IN1 w0.254: v1(45.68,42.88) 45.21,43.35 43.41,43.35 v7(43.02,42.96)
  GND1 w0.254: v3(45.83,43.34) 45.83,43.03 v1(45.68,42.88)
  GND3 w0.254: v4(45.85,42.93) 45.85,43.33 v3(45.83,43.34)
ISEN1_VCORE: length 5.3
  TOP w0.203: PU1000.21 45.02,48.88 45.66,49.51 46.08,49.51 PC1028.1
  TOP w0.254: 46.08,49.51 46.61,48.98 47.4,48.98 PR1116.2 47.9,49.44 PR1104.2
ISEN2_GT: length 8.1
  TOP w0.203: v1(44.76,42.96) 43.89,42.96 PC1026.2 43.88,43.31 43.68,43.52 43.09,43.52 42.57,44.04 PU1000.10
  GND1 w0.254: v1(44.76,42.96) 44.76,42.54 v3(44.77,42.54)
  GND3 w0.254: v4(44.77,42.09) v3(44.77,42.54) 44.77,42.98 v4(44.17,43.58)
  BOTTOM w0.095: PR1117.2 43.52,44.9 v2(44.03,45.41)
  BOTTOM w0.254: v4(44.17,43.58) 43.52,44.23 PR1117.2
ISEN2_VCORE: length 10
  TOP w0.095: PR1113.2 47.44,53.74 v2(47.61,53.92)
  TOP w0.203: PR1107.2 48.03,52.36 47.47,52.92 PR1113.2 46.55,52.92 PR1050.1 46.42,52.89 45.56,52.03 45.56,50.94 PC1027.1 44.92,49.28 PU1000.22
ISUMN_GT: length 55.8
  TOP w0.095: v7(43.12,39.55) v2(43.63,39.55)
  TOP w0.254: PR1154.2 43.88,41.38 PC1026.1 43.02,42.04 PC1029.1 PR1036.1 v1(41.26,42.07) 41.54,41.8 41.54,40.1 42.18,39.46 PC1024.1 42.97,39.4 v7(43.12,39.55)
  IN1 w0.254: v8(72.09,38.82) 72.09,39.11 71.83,39.37 69.83,39.37 69.6,39.14 66.18,39.14 64.37,37.32 64.37,36.72 63.97,36.32 63.47,36.32 61.92,37.88 61.92,38.76 61.25,39.44 58.71,39.44 57.78,38.51 47.63,38.51 47.17,38.05 43.99,38.05 43.12,38.92 v7(43.12,39.55)
  GND1 w0.254: v1(41.26,42.07) v3(40.9,42.07)
  GND3 w0.254: v3(40.9,42.07) 40.43,42.07 v4(40.4,42.04)
  IN4 w0.254: v4(40.4,42.04) 40.75,42.04 41.84,43.13 45.3,43.13 45.49,43.33 46.48,43.33 v5(46.87,42.94)
  BOTTOM w0.254: PR1031.1 43.91,41.97 43.5,41.56 41.52,41.56 41.26,41.82 v1(41.26,42.07) 40.43,42.07 v4(40.4,42.04) ; v8(72.09,38.82) 72.09,38.7 72.26,38.52 PH1002.2
ISUMN_SA: length 37.1
  TOP w0.095: PR1159.2 v2(34.16,54.62)
  TOP w0.203: PR1021.2 39.68,54.53 PC1011.1
  TOP w0.254: PC1011.1 39.71,54.59 39.33,54.97 39.33,54.97 39.18,55.12 39.18,55.12 PR1024.2 38.47,55.12 38.47,55.12 38.32,54.97 38.32,54.97 37.94,54.59 PC1013.1 PC1012.1 PR1025.1 35.27,54.57 PR1159.2
  IN1 w0.254: v9(52,52.14) 51.95,52.08 51.95,50.55 51.4,50.01 49.49,50.01 49.05,49.56 47.54,49.56 47.09,50.01 46.37,50.01 45.22,51.15 45.22,54.01 44.67,54.57 36.24,54.57 v7(36.24,54.57)
  GND1 w0.254: v9(52,52.14) 52.1,52.14 v3(52.34,52.38)
  GND3 w0.254: v3(52.34,52.38) 52.34,52.38 52.34,52.53 52.56,52.75 v4(52.56,52.8)
  BOTTOM w0.254: v4(52.56,52.8) 52.59,52.83 52.59,57.57 53.37,58.35 54.22,58.35 54.73,58.86 PH1001.1
ISUMN_VCORE: length 40.8
  TOP w0.254: PR1106.2 47.82,52.04 v7(47.72,52.14) ; v1(46.99,49.54) 46.99,49.97 46.98,49.98 PC1027.2 46.98,50.55 v7(46.52,51.01) 46.05,51.48 PR1115.2
  IN1 w0.254: v7(46.52,51.01) 47.65,52.14 v7(47.72,52.14) 48.11,52.14 48.53,52.56 49.22,52.56 51.73,55.07 51.73,58.17 53.25,59.68 55.51,59.68 55.83,59.36 60.05,59.36 61.25,60.57 61.25,63.36 62.66,64.76 68.07,64.76 v9(68.16,64.68)
  GND1 w0.203: v3(68.4,64.38) 68.4,64.44 v9(68.16,64.68)
  GND1 w0.254: v1(46.99,49.54) 47.18,49.54 v3(47.41,49.77)
  GND3 w0.203: v3(68.4,64.38) 68.31,64.38 68.09,64.16 v4(68.09,64.03)
  GND3 w0.254: v3(47.41,49.77) 47.33,49.69 47.14,49.69 v4(46.98,49.53)
  BOTTOM w0.254: PC1030.1 48.81,48.05 PC1032.1 48.81,48.93 PR1038.1 48.8,49.82 PC1031.1 48.25,49.84 PR1039.2 47.85,49.53 PR1037.2 v4(46.98,49.53)
ISUMP_GT: length 18.5
  TOP w0.203: PU1000.7 41.37,43.32 41.26,43.21 v1(41.26,42.98)
  TOP w0.254: PR1152.2 50.56,41.57 50.56,42.18 50.27,42.47 48.08,42.47 47.41,41.8 v2(47.04,41.8) v7(46.6,41.8)
  IN1 w0.254: v1(41.26,42.98) 41.76,42.49 44.99,42.49 45.68,41.8 v7(46.6,41.8)
  GND1 w0.254: v1(41.26,42.98) 41.54,43.26 v3(41.64,43.26)
  GND3 w0.254: v4(42.03,43.52) 41.89,43.52 v3(41.64,43.26)
  BOTTOM w0.254: v4(42.03,43.52) 42.13,43.42 PR1030.1 v1(41.26,42.98) 40.43,42.98 PR1034.1 40.21,43.15 PR1112.2
ISUMP_SA: length 11.4
  TOP w0.095: PR1025.2 36.16,56.36 v2(36.27,56.47)
  TOP w0.203: PU1000.32 40.57,52.09 40.22,52.43 40.22,56.05
  TOP w0.254: 40.22,56.05 40.22,56.29 PR1158.2 39.41,56.34 PR1026.2 38.72,56.34 37.94,55.56 PC1013.2 PC1012.2 PR1025.2
ISUMP_VCORE: length 13.5
  TOP w0.203: v1(45.01,48.08) PU1000.19
  TOP w0.254: PR1114.2 51.4,52.89 51.4,51.33 v2(51.37,51.3) 50.7,51.3 v8(50.62,51.22) 50.59,51.22 50.37,51 PR1105.2
  GND1 w0.254: v1(45.01,48.08) 45.62,48.08 v3(45.63,48.09)
  IN2 w0.254: v3(45.63,48.09) 45.76,48.22 v3(49.19,48.22)
  GND3 w0.254: v3(49.19,48.22) 49.27,48.14 49.62,48.14 v4(49.71,48.05)
  BOTTOM w0.254: v8(50.62,51.22) 50.59,51.22 50.12,50.76 PR1040.2 PC1031.2 49.7,48.95 PR1038.2 49.72,48.06 PC1032.2
JACK_PLUG: length 24.6
  IN4 w0.076: v5(275.57,54.12) 275.85,53.83 285.93,53.83 286.99,54.89 287.59,54.89 289.69,56.99 289.69,59.67 290.11,60.09 v5(290.52,60.09)
  BOTTOM w0.095: JAUDIO1.1 291.82,61.87 v2(291.4,61.45) 290.52,60.57 v5(290.52,60.09) ; v5(275.57,54.12) 275.57,55.14 CA22.1 275.17,55.33 RA13.1
JTAG_CLK: length 20.5
  GND1 w0.095: v3(18.69,11.17) 19.1,11.58 v1(19.1,11.61)
  IN3 w0.064: v3(4.31,15.84) 4.31,15.1 5.27,14.14 8.84,14.14 10.4,12.58 11.96,12.58 12.52,12.02 15.24,12.02 15.63,11.63 17.09,11.63 17.55,11.17 v3(18.69,11.17)
  GND3 w0.095: v4(17.8,11.54) 18.17,11.17 v3(18.69,11.17) ; v4(4.68,15.84) v3(4.31,15.84)
  BOTTOM w0.095: v2(6.12,15.07) 5.36,15.84 v4(4.68,15.84)
JTAG_RST#: length 6.3
  TOP w0.095: JTAG2.1 10.05,13.49 RE156.1 CE63.1 RE164.1 13.14,13.49 14.49,14.84 15.08,14.84 UE3.G13
JTAG_TDI: length 19.7
  TOP w0.095: UE3.E9 18.29,13.21 17.92,12.84 v8(17.89,12.84)
  IN3 w0.064: v3(5.02,16.84) 5.05,16.84 5.48,16.42 5.48,15.06 5.79,14.75 9.04,14.75 10.6,13.19 12.17,13.19 12.29,13.32 14.72,13.32 14.84,13.19 17.54,13.19 v8(17.89,12.84)
  GND3 w0.095: v4(4.68,16.83) 5.01,16.83 v3(5.02,16.84)
  BOTTOM w0.095: v4(4.68,16.83) v2(4.68,18.12) ; v8(17.89,12.84) 17.42,12.38 16.91,12.38 16.8,12.27 JDEG1.2
JTAG_TDO: length 21.6
  TOP w0.095: v7(21.09,13.63) 20.71,14.01 UE3.F6
  IN1 w0.076: v7(21.09,13.63) 20.69,13.23 19.34,13.23 19.09,12.97 19.09,12.64 18.79,12.35 v9(18.72,12.35)
  GND1 w0.095: v3(18.33,12.02) 18.39,12.02 v9(18.72,12.35)
  IN3 w0.064: v3(5.1,15.34) 5.1,15.03 5.57,14.56 8.97,14.56 10.55,12.97 12.25,12.97 12.82,12.4 15.75,12.4 16.04,12.69 16.51,12.69 16.79,12.41 17.94,12.41 18.32,12.02 v3(18.33,12.02)
  GND3 w0.095: v4(4.68,15.34) v3(5.1,15.34) ; v3(18.33,12.02) 18.3,12 v4(18.3,11.54)
  BOTTOM w0.095: v4(4.68,15.34) 4.68,14.45 v2(4.27,14.04)
JTAG_TMS: length 23.4
  TOP w0.095: v8(21.85,11.21) 21.85,11.27 UE3.C5
  IN3 w0.064: v3(16.9,11.97) 16.84,11.97 16.81,11.94 16.03,11.94 15.76,12.21 12.68,12.21 12.11,12.78 10.48,12.78 8.92,14.33 5.42,14.33 4.69,15.06 4.69,16.02 v3(4.32,16.39)
  GND3 w0.095: v3(16.9,11.97) 16.9,11.94 v4(17.3,11.54) ; v4(4.68,16.33) 4.38,16.33 v3(4.32,16.39)
  BOTTOM w0.095: v4(4.68,16.33) 5.45,16.33 v2(6.02,16.91) ; v8(21.85,11.21) 21.33,11.21 20.98,10.87 17.48,10.87 17.3,11.04 v4(17.3,11.54)
K52: length 2.5
  GND1 w0.457: v3(108.32,60) 107.9,60.42 v1(107.75,60.42)
  GND3 w0.457: v4(107.89,60.2) 108.12,60.2 v3(108.32,60)
  BOTTOM w0.457: UCPU1.K52 108.39,60.7 v4(107.89,60.2)
KB_DET#: length 234.9
  TOP w0.095: v1(39.52,14.12) 39.03,13.63 39.03,12.86 36.6,10.43 36.6,9.42 36.1,8.93 36.1,6.49 35.43,5.81 35.43,4.72 32.81,2.11 30.34,2.11 v2(30.14,2.32) 29.45,2.32 29.34,2.2 25.62,2.2 v8(25.45,2.37)
  GND1 w0.095: v1(39.52,14.12) 39.2,14.45 v3(38.7,14.45)
  IN3 w0.064: v3(38.7,14.45) 38.7,14.2 40.26,12.65 47.19,12.65 48.98,10.86 60.2,10.86 61.07,9.99 72.19,9.99 72.78,10.58 73.84,10.58 76.75,13.48 80.78,13.48 81.91,14.62 81.91,19.95 v8(80.25,21.61)
  IN4 w0.076: v5(135.2,68.15) 135.2,67.7 134.34,66.84 134.34,65.68 134.76,65.26 135.4,65.26 136.13,65.99 136.13,66.97 136.76,67.6 141.75,67.6 144.46,64.89 147.88,64.89 148.6,64.17 148.6,56.66 149.14,56.13 149.14,55.54 151.92,52.76 151.92,51.21 151.78,51.07 151.78,49.72 153.13,48.37 153.13,43.43 v5(153.27,43.3)
  BOTTOM w0.076: UCPU1.C8 133.43,65.29 133.43,66.84 134.74,68.15 v5(135.2,68.15)
  BOTTOM w0.095: v8(25.45,2.37) 24.12,2.37 22.75,3.74 22.01,3.74 19.68,6.07 JKB1.4 ; v5(153.27,43.3) 152.91,43.65 150.79,43.65 150.17,43.02 150.17,41.37 148.12,39.33 147.99,39.33 147.87,39.2 147.74,39.2 147.11,38.56 145.2,38.56 ; RC41.2 143.63,38.87 143.93,38.56 145.2,38.56 ; 145.2,38.56 145.18,38.54 145.18,36.79 145.79,36.18 146.94,36.18 147.24,35.89 147.24,35.28 146.25,34.3 145.15,34.3 143.15,32.3 140.27,32.3 139.33,33.24 135.5,33.24 133.6,35.14 124.17,35.14 123.53,34.5 85.67,34.5 81.78,30.61 81.78,23.15 v8(80.25,21.61)
LAN_WAKE#: length 175.1
  TOP w0.095: UE3.L3 23.51,18.42 23.51,18.88 23.87,19.23 23.97,19.23 24.33,19.59 24.33,19.81 25.26,20.74 28.75,20.74 28.95,20.94 28.95,21.63 28.77,21.81 28.77,22.51 29,22.74 29.65,22.74 v7(29.71,22.67) ; RC74.2 134.34,40.96 132.29,43.01 132.29,44 130.76,45.54 130.76,45.91 130.24,46.43 130.24,48.51 130.11,48.64 129.6,48.64 129.39,48.85 129.39,49.3 v1(129.22,49.46)
  IN1 w0.076: v8(80.16,18.2) 80.16,15.64 76.3,11.77 74.22,11.77 72.54,10.09 69.87,10.09 69.68,10.28 66.89,10.28 65.57,11.6 65.57,12.29 65.43,12.43 62.52,12.43 62.42,12.32 55.2,12.32 50.4,17.12 43.41,17.12 42.3,18.23 38.13,18.23 37.25,19.11 37.25,19.37 33.81,22.82 29.85,22.82 v7(29.71,22.67)
  GND1 w0.095: v3(129.05,49.78) 129.05,49.63 v1(129.22,49.46)
  GND3 w0.095: v3(129.05,49.78) 129.23,49.96 v4(129.42,49.96)
  IN4 w0.076: v8(80.16,18.2) 80.68,18.2 81.3,18.83 81.3,23.76 81.62,24.08 81.62,28.75 84.7,31.83 102.53,31.83 103.13,32.43 105.32,32.43 106.33,31.41 130.79,31.41 133.59,34.22 133.59,37.93 133.91,38.25 133.91,38.57 133.71,38.77 133.71,40.07 134.42,40.78 134.42,41.02 134.2,41.24 134.2,42.98 132.35,44.83 129.29,44.83 128.3,45.82 128.3,46.17 128.36,46.23 128.36,48.23 128.45,48.32 128.45,49 v4(129.42,49.96)
  BOTTOM w0.095: v8(80.16,18.2) v2(79.61,18.2)
LCD_GPIO1: length 336.5
  TOP w0.095: v7(111.94,8.12) 111.67,8.39 111.67,12.97 v2(111.14,13.51) 110.81,13.84 110.81,15.87 v1(110.81,15.87)
  IN1 w0.076: v9(279.57,24.87) 278.85,24.15 278.85,20.11 277.05,18.3 277.05,15.85 275.76,14.56 274.85,14.56 273.49,13.2 264.47,13.2 260.63,9.36 258.44,9.36 257.36,8.29 257.36,7.49 256.25,6.38 255.68,6.38 254.94,5.65 253.1,5.65 252.52,5.07 229.18,5.07 228.65,5.6 227.39,5.6 224.53,8.46 218.11,8.46 215.53,11.04 212.97,11.04 208.61,6.68 185.55,6.68 183.64,8.59 169.54,8.59 168.07,10.07 165.21,10.07 164.53,10.74 161.75,10.74 160.76,11.73 159.04,11.73 158.23,10.93 158.23,8.67 157.88,8.32 153.24,8.32 152.76,8.79 152.76,10.71 152.12,11.34 145.24,11.34 144.35,12.24 139.04,12.24 138.3,11.5 129.93,11.5 129.43,10.99 118.01,10.99 115.79,8.77 112.99,8.77 112.34,8.12 v7(111.94,8.12)
  GND1 w0.095: v3(280.24,25.29) 279.82,24.87 v9(279.57,24.87) ; v3(110.85,16.2) 110.85,16.18 110.81,16.13 v1(110.81,15.87)
  GND3 w0.095: v4(279.99,25.07) 280.21,25.29 v3(280.24,25.29) ; v6(110.56,15.98) 110.74,16.16 110.82,16.16 v3(110.85,16.2)
  IN4 w0.076: v5(45.85,59.55) 44.75,59.55 43.81,58.61 43.81,56.65 43.47,56.31 43.47,55.86 38.37,50.75 38.37,47.92 38,47.55 38,40.29 39.24,39.05 39.24,32.95 39.73,32.46 39.73,25.98 38.67,24.92 37.49,24.92 37.33,24.76 37.33,24.23 37.83,23.73 37.83,19.93 37.65,19.75 37.65,16.07 39.71,14.01 47.87,14.01 48.67,13.21 52.53,13.21 53.28,12.46 61.07,12.46 62.16,11.37 65.55,11.37 66.22,10.7 67.41,10.7 67.52,10.59 72.44,10.59 74.06,12.2 77.14,12.2 78.07,13.13 79,13.13 80.41,14.54 81.65,14.54 82.8,15.68 84.38,15.68 110.26,15.68 v6(110.56,15.98)
  BOTTOM w0.095: JEDP1.7 48.08,60.49 47.74,60.15 46.47,60.15 45.87,59.55 v5(45.85,59.55) ; JCAM1.7 279.63,25.44 v4(279.99,25.07)
LCD_GPIO2: length 331.2
  TOP w0.095: v7(111.98,8.51) 111.98,13.55 111.47,14.07 v2(111.47,15.4) v1(111.47,15.87)
  IN1 w0.076: v7(111.98,8.51) 112.43,8.51 112.92,9 115.73,9 117.93,11.2 129.34,11.2 129.85,11.7 138.21,11.7 138.96,12.44 144.43,12.44 145.32,11.55 151.55,11.55 151.95,11.94 160.83,11.94 161.83,10.95 164.61,10.95 165.29,10.27 168.15,10.27 169.63,8.8 183.72,8.8 185.63,6.89 208.49,6.89 212.84,11.24 215.61,11.24 218.19,8.66 224.62,8.66 227.48,5.8 228.74,5.8 229.26,5.28 252.44,5.28 253.01,5.85 254.86,5.85 255.63,6.62 256.16,6.62 257.16,7.61 257.16,8.37 258.36,9.56 260.55,9.56 264.39,13.4 273.4,13.4 274.77,14.77 275.68,14.77 276.84,15.93 276.84,18.39 278.36,19.9 278.36,19.9 278.63,20.18 278.63,24.51 279.54,25.42 v9(279.54,25.66)
  GND1 w0.095: v3(111.5,16.21) 111.43,16.15 111.43,15.91 v1(111.47,15.87) ; v9(279.54,25.66) v3(279.54,25.33)
  GND3 w0.095: v6(111.26,15.94) 111.5,16.17 v3(111.5,16.21) ; v4(279.27,24.94) 279.54,25.21 v3(279.54,25.33)
  IN4 w0.076: v6(111.26,15.94) 110.8,15.48 84.3,15.48 82.88,15.48 81.74,14.33 81.46,14.33 80.5,14.33 79.09,12.92 78.16,12.92 77.23,12 74.14,12 72.53,10.38 67.44,10.38 67.32,10.49 64.97,10.49 64.97,10.5 64.18,10.5 64.18,10.49 63.85,10.49 63.85,10.5 63.07,10.5 63.06,10.49 62.74,10.49 62.73,10.5 62.65,10.5 60.89,12.26 53.2,12.26 52.45,13.01 48.59,13.01 47.78,13.81 39.63,13.81 37.45,15.98 37.45,19.84 37.62,20.01 37.62,23.65 37.11,24.15 37.11,24.9 37.34,25.12 38.59,25.12 39.53,26.07 39.53,32.38 39.04,32.87 39.04,38.93 37.8,40.18 37.8,45.89 37.39,46.3 37.39,46.87 37.8,47.28 37.8,47.64 38.17,48.01 38.17,50.84 43.25,55.92 43.25,56.44 43.58,56.76 43.58,58.72 44.81,59.96 v5(45.85,59.96)
  BOTTOM w0.095: v5(45.85,59.96) 45.86,59.96 46.28,60.38 47.12,60.38 47.58,60.84 JEDP1.8 ; JCAM1.8 v4(279.27,24.94)
LCD_TST: length 60.8
  TOP w0.095: UE3.M2 24.2,18.82 24.56,19.17 25.12,19.17 25.6,19.65 25.6,19.99 ; v8(25.6,20.03) 25.6,19.99 ; 25.6,19.99 26.06,19.54 26.41,19.54 RE160.1
  IN4 w0.076: v5(32.58,61.3) 31.74,60.46 31.74,59.53 32.58,58.69 32.58,56.61 33.63,55.56 33.63,54.9 35.97,52.56 35.97,40.96 v5(36,40.92) ; v4(34.7,19.62) 34.7,19.92 34.57,20.05 34.57,22.45 34.02,23 34.02,26.18 35.07,27.23 35.07,32.85 34.27,33.64 v5(34.27,34.29)
  BOTTOM w0.095: v5(34.27,34.29) 34.49,34.29 35.38,35.17 35.38,40.17 v2(35.62,40.42) 35.96,40.75 35.96,40.88 v5(36,40.92) ; v4(34.7,19.62) 34.7,19.29 34.52,19.11 33.48,19.11 32.83,19.76 31.62,19.76 31.15,20.23 26.73,20.23 26.64,20.13 26.64,19.84 26.44,19.64 25.82,19.64 25.6,19.86 v8(25.6,20.03)
LCD_VCC_TEST_EN: length 59.7
  TOP w0.095: UE3.E1 24.98,13.21 v1(25.39,12.8)
  IN1 w0.076: v9(29.48,25.63) 30.55,26.69 32.45,26.69 32.48,26.72 35.85,26.72 37.45,28.31 37.45,38.42 37.26,38.6 37.26,39 35.95,40.31 35.95,42.43 34.38,44 33.41,44 32.8,44.62 32.8,45.82 33.08,46.11 34.08,46.11 34.66,46.68 34.66,49.04 34.3,49.39 34.3,52.8 34.79,53.29 35.6,53.29 v9(35.7,53.39)
  GND1 w0.095: v9(35.7,53.39) 35.92,53.61 v3(35.98,53.61) ; v3(29.11,25.75) 29.35,25.75 v9(29.48,25.63) ; v1(25.39,12.8) 25.39,12.7 25.54,12.56 25.54,12.44 v3(25.57,12.41)
  IN3 w0.064: v3(25.57,12.41) 25.6,12.45 26.29,12.45 27.09,13.26 27.09,14.65 28.51,16.07 28.51,17.86 29.3,18.66 29.3,19.6 28.79,20.11 28.79,22.45 29.26,22.91 29.26,25.53 29.11,25.68 v3(29.11,25.75)
  GND3 w0.095: v4(36.01,53.07) 36.01,53.58 v3(35.98,53.61)
  BOTTOM w0.095: v4(36.01,53.07) 35.87,52.93 v2(35.87,52.3) 36.54,51.63 D13.2
LDO_1.0V: length 1.1
  BOTTOM w0.095: PC711.1 137.53,8.74 v2(137.76,8.97)
LDO_IN: length 13.3
  TOP w0.095: v2(40.12,1.87) 39.78,1.53 38.47,1.53 PR149.1
  TOP w0.508: v8(37.38,1.73) 37.63,1.99 PR149.1
  BOTTOM w0.508: v8(37.38,1.73) 36.87,2.24 PU101.1 36.8,2.47 PC128.1 35.36,2.49 PD103.1 33.51,4.22 PD106.1 33.59,4.31 33.59,5.91 ; 33.59,5.91 PD107.1 ; 33.59,5.91 33.59,6.13 33.21,6.51 33.21,7.42 PD111.1
LID_CL_SIO#: length 9.4
  IN1 w0.076: v7(16.7,19.62) 16.7,19.49 17.01,19.19 17.48,19.19 17.68,19.39 22.74,19.39 v9(22.82,19.47)
  GND1 w0.095: v9(22.82,19.47) 22.77,19.42 v3(22.77,19.01)
  GND3 w0.095: v3(22.77,19.01) 22.99,19.01 v4(23.17,18.83)
  BOTTOM w0.095: v4(23.17,18.83) 23.17,18.94 23.61,19.39 v2(23.74,19.39) 23.87,19.39 24.5,18.75 RE237.1
LINE1_L: length 2.9
  BOTTOM w0.254: 280.51,59.65 280.56,59.65 281.37,58.83 v2(281.37,58.52) 282.14,57.74 CA80.1
LINE1_L_C: length 1
  BOTTOM w0.254: RA57.1 284.46,57.68 284.4,57.74 CA80.2
LINE1_R: length 2.5
  BOTTOM w0.254: 280.43,60.1 280.44,60.11 280.85,60.11 v2(281.04,59.92) 281.95,59.01 CA81.1
LINE1_R_C: length 1.1
  BOTTOM w0.254: CA81.2 284.26,58.58 RA58.1
LPM_ZVM_N: length 66.8
  IN1 w0.076: v8(78.82,30.36) 79.36,29.83 81.08,29.83 84,32.75 86.04,32.75 91.65,38.36 91.81,38.36 95.74,42.29 95.74,42.66 95.78,42.69 95.78,44.19 99.29,47.71 99.29,49.15 99.51,49.36 102.53,49.36 103.15,49.98 104.48,49.98 104.72,49.74 104.72,49.74 104.77,49.69 104.77,48.07 v8(105.18,47.65)
  IN2 w0.254: v3(68.68,37.39) 68.67,37.41 68.67,37.78 67.48,38.97 61.48,38.97 59.95,37.44 58.99,37.44 v3(58.47,37.95)
  GND3 w0.254: v3(68.68,37.39) 68.68,37.48 68.73,37.53 v4(68.73,37.73) ; v3(58.47,37.95) 58.45,37.93 v4(58.45,37.52)
  IN4 w0.076: v4(68.73,37.73) 72.29,37.73 72.85,37.17 74.68,37.17 78.82,33.02 v8(78.82,30.36)
  BOTTOM w0.095: v8(105.18,47.65) 105.28,47.65 UCPU1.AR56
LX_1.0V: length 2.3
  TOP w0.102: v8(136.98,4.41) 136.98,3.84 v2(136.6,3.46)
  TOP w0.508: PR700.1 141.59,4.66 v8(141.72,4.78)
  vias: v8(132.46,4.71) v8(132.98,4.44) v8(136.39,4.39)
LX_1V_PRIM: length 1.2
  TOP w0.095: PR1516.1 v2(73.38,31.76)
  vias: v8(72.59,33.39)
LX_3V: length 4.3
  TOP w0.095: v8(52.6,30.16) 52.43,29.99 v2(51.92,29.99)
  IN2 w0.762: 52.14,29.35 52.14,25.86 52.21,25.8
  vias: v8(52.14,25.16) v8(52.09,24.54) v8(53.14,30.52)
LX_5V: length 10.2
  TOP w0.095: v2(41.92,33.06) 41.71,32.85 PR507.1
  IN1 w0.762: 42.56,31.82 41.56,30.82 41.56,27.64 40.84,26.92 40.84,25.03 41.44,24.42
  vias: v8(41.19,24.02) v8(41.82,24.02) v8(42.81,31.98) v8(43.47,31.95)
LX_DDR:
  vias: v2(120.94,5.51)
LX_PRIM: length 3.1
  BOTTOM w0.095: PL1403.1 152.83,71.64 151.96,70.77 v2(151.25,70.77)
LX_VCC_EDRAM: length 0.7
  TOP w0.095: v8(64.31,33.75) v2(64.31,34.44)
  vias: v8(63.72,33.75)
LX_VCCIO: length 1.2
  BOTTOM w0.095: v2(155.6,56.12) 156.34,55.38 156.47,55.38
ME_EN: length 5.4
  TOP w0.095: SW1.2 153.6,41.03 152.78,41.03 152.33,40.58 R1.1 152.33,39.63 RH73.1 151.88,39.17 151.35,39.17 v2(150.82,38.64)
ME_FWP_EC: length 171.2
  TOP w0.095: v1(140.54,36.09) 141.6,36.09 v2(142.38,36.87) 143.09,37.58 143.95,37.58 144.48,38.11 147.11,38.11 147.53,38.53 149.45,38.53 R1.2 151.42,40.54 SW1.3 ; UE3.G12 15.9,14.83 v8(16.31,15.23)
  GND1 w0.095: v3(140.43,36.45) 140.43,36.2 v1(140.54,36.09)
  GND3 w0.095: v3(140.43,36.45) 140.42,36.45 140.32,36.35 v6(140.32,36.1)
  IN4 w0.076: v6(140.32,36.1) 140.32,35.45 135.08,30.21 84.59,30.21 82.69,28.31 82.69,23.64 82.45,23.4 82.45,16.96 78.82,13.33 77.99,13.33 77.06,12.4 73.97,12.4 72.36,10.79 67.6,10.79 67.49,10.9 66.31,10.9 65.64,11.57 62.48,11.57 61.34,12.7 53.33,12.7 52.62,13.41 48.91,13.41 48.1,14.22 39.88,14.22 37.88,16.21 37.88,19.7 38.66,20.47 38.66,21.38 38.61,21.42 38.61,21.42 38.32,21.71 38.32,22.16 v5(38.12,22.36)
  BOTTOM w0.095: v8(16.31,15.23) 16.31,17.08 18.84,19.62 22.5,19.62 23.59,20.71 24.47,20.71 25.73,21.97 29.02,21.97 30.16,23.11 34.52,23.11 35.4,22.22 37.88,22.22 38.02,22.36 v5(38.12,22.36)
ME_SUS_PWR_ACK: length 184.8
  TOP w0.095: v8(14.06,11.01) 14.42,11.01 14.61,10.81 UE3.B13 ; v2(127.52,39.5) RC83.2 127.52,42.32 128.14,42.94 128.65,42.94 129.12,43.41 129.12,46.64 129.36,46.88 129.36,47.7 v8(129.87,48.21)
  IN4 w0.076: v5(38.15,22.75) 38.52,22.38 38.52,21.79 38.69,21.63 38.7,21.63 38.86,21.46 38.86,20.03 38.69,19.86 38.69,18.64 38.6,18.55 38.6,15.97 40.15,14.42 48.19,14.42 48.93,13.68 52.67,13.68 53.44,12.91 61.73,12.91 62.13,12.51 65.54,12.51 65.79,12.25 65.79,11.71 66.39,11.1 67.58,11.1 67.69,10.99 72.27,10.99 75.2,13.91 76.09,13.91 76.4,14.23 78.78,14.23 81.71,17.16 81.71,23.59 82.03,23.91 82.03,28.59 84.81,31.36 102.82,31.36 103.48,32.02 105.15,32.02 106.2,30.97 131.06,30.97 134.16,34.07 134.16,37.53 134.55,37.91 134.55,38.52 134.17,38.9 134.17,39.94 135.03,40.8 135.03,42.88 132.63,45.28 130.68,45.28 130.06,45.9 129.66,45.9 129.38,46.18 129.38,47.89 129.7,48.21 v8(129.87,48.21)
  BOTTOM w0.095: v5(38.15,22.75) 37.97,22.75 37.67,22.45 35.49,22.45 34.61,23.33 30.07,23.33 28.93,22.19 25.63,22.19 24.38,20.93 23.5,20.93 22.4,19.84 18.69,19.84 15.74,16.88 15.74,15.06 15.9,14.89 15.9,13.9 15.13,13.13 15.13,12.63 14.06,11.56 v8(14.06,11.01)
  BOTTOM w0.112: UCPU1.AR13 130.07,48.01 v8(129.87,48.21)
MEC_XTAL1: length 5
  TOP w0.095: YE2.1 24.8,5.7 v2(24.8,6.84) 24.8,7.68 CE66.1 UE3.A1
MEC_XTAL2: length 3
  TOP w0.095: YE2.2 22.74,5.84 CE67.1 RE178.2
MEC_XTAL2_R: length 2.3
  TOP w0.095: RE178.1 23.1,8.06 UE3.A3
MEDIACARD_IRQ#: length 225.7
  IN1 w0.076: v9(258.49,7.44) 258.49,7.17 256.63,5.31 256.05,5.31 254.65,3.92 227.29,3.92 225.54,5.67 223.5,5.67 221.76,7.41 217.69,7.41 215.94,5.67 185.13,5.67 183.22,7.58 169.12,7.58 167.74,8.96 v9(165.62,8.96)
  GND1 w0.095: v9(165.62,8.96) 165.61,8.96 v3(165.34,8.69) ; v3(258.89,7.54) 258.79,7.44 v9(258.49,7.44)
  IN2 w0.064: v8(291.35,32.15) 291.12,32.15 290.43,31.45 289.5,31.45 289.01,30.97 278.14,30.97 276,28.83 276,25.6 272.39,21.99 272.39,21.07 271.53,20.2 271.53,19.16 271.19,18.82 267.65,18.82 267.28,18.45 267.28,17.93 266.19,16.84 266.19,15.63 263.87,13.31 263.87,11.53 259.87,7.52 258.91,7.52 v3(258.89,7.54)
  IN3 w0.064: v3(165.34,8.69) 165.27,8.76 162.4,8.76 156.52,14.64 154.27,14.64 153.45,15.46 v3(152.68,15.46)
  GND3 w0.095: v6(152.93,16.12) 152.93,15.54 152.83,15.44 152.7,15.44 v3(152.68,15.46)
  IN4 w0.076: v5(139.12,59.74) 139.18,59.8 140.26,59.8 141.08,60.62 141.63,60.62 142.26,59.99 142.35,59.99 143.4,58.93 144.1,58.93 146.32,56.72 v5(146.77,56.72) 146.77,55.71 148.86,53.62 148.86,51.73 152.6,47.98 152.6,38.88 152.27,38.55 152.27,35.55 153.45,34.38 153.45,32.99 154.57,31.87 154.57,26.61 153.37,25.4 153.37,16.55 v6(152.93,16.12)
  BOTTOM w0.076: v5(139.12,59.74) 138.35,59.74 138.03,60.06 UCPU1.M1
  BOTTOM w0.095: v2(148.64,56.72) v5(146.77,56.72) 145.09,56.72 RC17.2 ; UR1.32 291.07,32.44 v8(291.35,32.15) 290.73,31.53 RR1.1
MEM_CONFIG0: length 7.1
  TOP w0.095: v2(138.28,49.14) 138.42,49 138.95,49 v8(139.39,48.57) 139.36,48.54 RH52.2 139.88,48.31 140.52,48.31 RH51.1
  BOTTOM w0.076: UCPU1.AP2 136.95,48.13 137.11,47.97 137.27,47.97 137.42,47.89 137.49,47.87 137.7,47.87
  BOTTOM w0.095: 137.7,47.87 138.69,47.87 v8(139.39,48.57)
MEM_CONFIG1: length 10
  TOP w0.095: RH53.1 141.06,47.96 140.03,47.96 139.86,47.79 139.86,46.55 139.51,46.21 139.13,46.21 138.9,45.98 138.9,45.78 138.6,45.48 138.27,45.48 v2(137.84,45.91) 137.84,47.15 RH54.2 138.55,47.87 138.55,48.47 138.65,48.56 v8(138.8,48.56)
  BOTTOM w0.095: UCPU1.AP1 138.61,48.13 138.8,48.31 v8(138.8,48.56)
MEM_CONFIG2: length 6.7
  TOP w0.095: v8(140.19,48.88) 140.19,48.94 141,49.74 RH55.1
  BOTTOM w0.076: 138.08,49.04 137.89,48.85 137.78,48.85 137.35,48.42 136.61,48.42 136.31,48.13 UCPU1.AP3
  BOTTOM w0.095: 138.08,49.04 140.03,49.04 v8(140.19,48.88) 140.71,48.88 RH56.2
MEM_CONFIG3: length 6.7
  TOP w0.095: v8(140.18,50.75) 140.18,51.51 RH58.2 RH57.1
  BOTTOM w0.076: UCPU1.AN3 136.01,48.79 136.34,49.12 137.07,49.12 137.15,49.2 137.71,49.2 138.2,49.69
  BOTTOM w0.095: v8(140.18,50.75) 140.17,50.75 v2(139.54,50.13) 139.11,49.69 138.2,49.69
MEM_CONFIG4: length 6.2
  TOP w0.095: RH59.1 140.61,50.18 140.61,49.76 140.31,49.46 v8(140.08,49.46)
  BOTTOM w0.076: 138.23,49.46 137.81,49.03 137.33,49.03 137.24,48.94 UCPU1.AN1
  BOTTOM w0.095: 138.23,49.46 v8(140.08,49.46) 140.74,50.12 RH60.2
MEM_SMBCLK: length 20.3
  TOP w0.095: v8(134.53,57.78) 134.61,57.78 135.2,58.38 136.26,58.38 136.51,58.12 v2(139.18,58.12) RC18.1 141.14,58.25 141.46,58.58 145.8,58.58 146.14,58.24 RC388.1 146.14,57.19 146.67,56.67 147.86,56.67 148.23,56.29 v8(148.23,55.64)
  BOTTOM w0.095: QC1.6 147.41,54.26 148.23,55.08 v8(148.23,55.64)
  BOTTOM w0.112: UCPU1.R7 134.18,58.13 v8(134.53,57.78)
MEM_SMBDATA: length 19.7
  TOP w0.095: v8(147.63,56.26) 147.59,56.3 146.32,56.3 146.01,55.99 RC387.1 145.33,55.84 144.91,56.25 142.12,56.25 RC20.1 140.63,57.74 136.95,57.74 136.61,57.41 134.25,57.41 133.92,57.73 v8(133.92,57.78)
  BOTTOM w0.095: QC1.3 144.91,55.56 145.71,56.36 147.52,56.36 v8(147.63,56.26)
  BOTTOM w0.127: v8(133.92,57.78) 133.86,57.84 133.81,57.84 133.53,58.12 UCPU1.R8
MIC2_VREFO_R:
  vias: v4(280.89,62.44) v4(281.09,62.59) v4(281.29,62.77) v4(282.26,61.7) v4(282.51,61.7)
MON_PDN#: length 5.1
  TOP w0.095: v7(170.22,19.54) 169.74,19.06 v2(169.74,17.6)
  IN1 w0.076: v7(170.22,19.54) 170.23,19.53 170.51,19.53 170.7,19.72 171.32,19.72 171.51,19.53 172.56,19.53 172.86,19.82 v7(172.86,19.83)
MON_SLOW: length 3.6
  TOP w0.095: RE240.1 174.46,18.57 174.46,18.26 v2(173.94,17.74)
  IN1 w0.076: v7(173.36,19.83) 174.28,18.91 v7(174.86,18.91)
MONO_IN: length 3.1
  TOP w0.095: v2(280.44,61.17) CA16.2 279.52,60.78 v1(279.67,60.62)
  GND1 w0.095: v3(279.98,60.47) 279.79,60.47 279.67,60.58 v1(279.67,60.62)
  GND3 w0.203: v3(279.98,60.47) 279.99,60.48 v4(280.41,60.48)
  BOTTOM w0.203: U5.34 v4(280.41,60.48)
MPHYP_PWR_EN: length 12.1
  TOP w0.095: v2(131.47,50.03) 131.75,49.75 v8(131.75,49.6)
  IN1 w0.076: v8(131.75,49.6) 132.03,49.6 132.4,49.97 133.66,49.97 134.07,49.56 134.51,49.56 136.57,47.5 140.91,47.5 v7(141.39,47.02)
  BOTTOM w0.112: UCPU1.AM10 132.11,49.96 v8(131.75,49.6)
MSCLK: length 16.5
  TOP w0.095: UE3.H10 17.5,15.63 17.9,16.02 v8(17.91,16.02)
  IN1 w0.076: v8(17.91,16.02) 15.71,16.02 13.83,14.14 11.98,14.14 v9(11.77,14.35)
  GND1 w0.095: v9(11.77,14.35) 11.77,14.38 v3(11.31,14.85)
  GND3 w0.095: v4(10.71,15.34) 11.2,14.85 v3(11.31,14.85)
  BOTTOM w0.095: v8(17.91,16.02) 18.3,15.63 18.3,12.61 18.8,12.11 JDEG1.6 ; RE209.1 11.94,14.38 11.93,14.37 RE201.2 11.76,14.37 10.92,15.21 10.83,15.21 v4(10.71,15.34)
MSDATA: length 14.7
  TOP w0.095: v8(18.71,15.23) 18.3,14.83 UE3.G9
  IN1 w0.076: v8(18.71,15.23) 18.34,15.6 17.72,15.6 17.5,15.39 17.5,14.99 17.38,14.87 16.23,14.87 15.94,14.57 15.94,14.34 15.26,13.66 14.58,13.66 14.15,13.23 13.66,13.23 v8(13.23,12.79)
  IN4 w0.076: v8(18.71,15.23) 19.12,14.83 19.12,12.5 v4(19.29,12.33)
  BOTTOM w0.095: v2(13.5,11.26) RE205.1 RE204.2 13.03,12.59 v8(13.23,12.79) ; v4(19.29,12.33) 19.29,12.25 19.3,12.24 JDEG1.7
MSM_N: length 55.6
  IN1 w0.076: v9(64.02,29.28) 64.08,29.22 69.75,29.22 70.29,29.76 73.78,29.76 74.92,30.91 v7(75.26,30.91) 81.87,30.91 83.92,32.96 85.96,32.96 91.56,38.56 91.73,38.56 95.54,42.37 95.54,44.38 99.09,47.92 99.09,49.27 99.42,49.61 102.43,49.61 103.02,50.2 105.49,50.2 105.66,50.03 105.66,48.77 v8(105.2,48.31)
  GND1 w0.095: v3(63.68,29.28) 63.68,29.28 v9(64.02,29.28)
  GND3 w0.095: v4(63.29,29.34) 63.61,29.34 v3(63.68,29.28)
  BOTTOM w0.076: UCPU1.AP56 105.6,48.66 105.25,48.31 v8(105.2,48.31)
MUX_C_AUX_N: length 5.5
  IN4 w0.095: v4(283.2,19.13) 283.2,19.48 283.34,19.62 283.73,19.62 v5(285.52,17.83)
  BOTTOM w0.102: v4(283.2,19.13) 283.2,19.37 283.04,19.53 282.03,19.53 R5814.2
MUX_C_AUX_P: length 5.5
  BOTTOM w0.102: R5815.2 282.01,19.76 283.07,19.76 283.2,19.89 C1117.2 283.4,20.15 283.67,19.88 283.67,18.71 284.56,17.83 U21.J1
MUX_C_CC1: length 38.8
  IN1 w0.508: 287.32,21.07 284.32,24.07 282.67,24.07 281.39,25.35 281.39,39.92 281.47,40 v7(281.47,42.7) 281.47,43.4 280.46,44.42 280.46,46.27 280.88,46.69 280.88,48.36 281.19,48.68 281.19,49.69 281.7,50.2 282.88,50.2 284.34,48.74 285.87,48.74 286.08,48.52 286.31,48.52
  vias: v3(289.3,20.87) v4(288.95,20.39) v4(289.07,20.63) v7(286.82,48.58) v7(287.11,48.6) v9(288.54,20.88) v9(288.54,20.61)
MUX_C_CC2: length 40.2
  TOP w0.095: v2(289.8,42.54) 289.69,42.65 v8(289.69,43.03)
  IN3 w0.508: v8(290.03,43.87) 290.34,44.18 291.6,44.18 292.7,45.28 292.7,50.14 291.73,51.1 JUSBC3.B5 ; v3(290.3,23.36) 290.17,23.49 290.17,25.83 294.57,30.24 294.57,35.6 290.26,39.92 290.26,42.46 v8(289.69,43.03)
  GND3 w0.508: v4(289.77,23.24) 290.18,23.24 v3(290.3,23.36)
  IN4 w0.508: v5(289.77,19.21) 289.77,19.25 290.36,19.84 290.36,21.15 290.15,21.37 290.15,22.86 v4(289.77,23.24)
  BOTTOM w0.254: v5(289.77,19.21) 289.52,18.96 U21.L10 U21.K10
MUX_C_PD_SBU1: length 2.7
  IN4 w0.076: v5(288.52,18.33) 288.52,18.93 288.64,19.05 288.64,19.9 288.23,20.31 v5(288.23,20.8)
MUX_C_PD_SBU2: length 2.6
  BOTTOM w0.095: U21.L8 288.63,18.94 288.63,20.12 288.33,20.43 287.97,20.43 287.67,20.74 R228.1
MUX_C_RESET_N: length 394.9
  TOP w0.095: v7(18.27,45.18) 18.15,45.3 18.15,48.51 v2(17.25,49.41) 15.5,51.15 15.5,53.98 16.65,55.12 19.77,55.12 20.84,54.06 RT12.1
  IN1 w0.076: v7(18.27,45.18) 18.19,45.18 17.73,44.72 17.73,41.81 18.19,41.35 18.95,41.35 19.45,40.86 19.45,38.44 17.62,36.61 15.93,36.61 15.79,36.47 13.58,36.47 13.46,36.59 12.28,36.59 12.02,36.85 12.02,38.23 10.73,39.52 9.71,39.52 9.3,39.11 9.3,37.18 8.44,36.32 8.44,33.28 10.27,31.45 10.27,30.81 11.75,29.32 11.75,27.74 10.82,26.8 9.68,26.8 9.11,27.38 8.43,27.38 7.09,26.03 6.51,26.03 5.67,25.19 5.67,23.37 2.61,20.31 2.61,18.18 3.08,17.72 3.08,13.68 6.16,10.59 6.16,6.51 4.72,5.06 4.72,3.73 5.18,3.27 29.38,3.27 30.01,3.9 32.28,3.9 33.19,2.99 41.63,2.99 42.29,2.34 53.55,2.34 53.56,2.33 61.82,2.33 62.9,1.25 77.67,1.25 81.58,5.16 117.22,5.16 118.23,6.17 118.23,8 119.06,8.83 144.79,8.83 145.04,9.07 148.91,9.07 153.88,4.11 159.35,4.11 160.76,5.51 163.94,5.51 165.11,6.69 166.5,6.69 168.47,4.71 183.27,4.71 184.31,3.68 224.71,3.68 226.68,1.7 265.9,1.7 265.9,1.7 267.71,1.7 268.57,2.56 272.57,2.56 273.79,3.78 274.96,3.78 275.36,4.18 278.49,4.18 278.9,3.78 279.19,3.78 279.2,3.77 288.6,3.77 290.59,5.76 290.59,9.61 289.74,10.46 289.74,11.81 289.27,12.28 289.27,14.96 v9(290.32,16.01)
  GND1 w0.095: v9(290.32,16.01) 290.57,16.26 v3(290.71,16.26)
  GND3 w0.095: v3(290.71,16.26) 290.64,16.32 v4(290.36,16.32)
  BOTTOM w0.095: U21.F11 290.36,16.33 v4(290.36,16.32)
MUX_C_SBU1: length 68
  TOP w0.076: 277.09,26.25 v1(277.24,26.25)
  TOP w0.095: 277.09,26.25 276.57,26.25 R46.2 ; v7(283.33,53.3) 283.33,53.3 283.67,52.97 284.05,52.97 284.25,53.17 284.25,53.32 285.53,54.6 285.92,54.6 286.07,54.45 286.07,53.75 285.97,53.65 285.3,53.65 285.21,53.55 285.21,53.36 285.3,53.27 285.54,53.27 285.64,53.17 285.64,52.98 285.54,52.89 285.3,52.89 285.21,52.79 285.21,52.6 285.3,52.51 285.54,52.51 285.64,52.41 285.64,52.22 285.54,52.13 285.3,52.13 285.21,52.03 285.21,51.92 285.1,51.82 284.29,51.82 284.19,51.72 284.19,51.54 284.29,51.44 285.1,51.44 285.21,51.34 285.21,50.97 285.3,50.87 285.49,50.87 285.59,50.97 285.59,51.61 285.72,51.74 285.92,51.74 286.03,51.63 286.03,51.44 286.17,51.3 286.63,51.3 286.74,51.19 287.92,51.19 288.06,51.05 JUSBC3.A8
  IN1 w0.076: v1(277.24,26.25) 277.54,25.95 277.79,25.95 278.02,26.18 278.02,26.72 278.02,26.72 278.02,26.89 278.72,27.59 278.72,31.75 278.17,32.29 278.17,36.19 277.01,37.34 277.01,49.86 280.09,52.93 283.53,52.93 283.66,53.06 283.66,53.17 283.64,53.19 283.64,53.27 283.53,53.38 283.41,53.38 v7(283.33,53.3)
  GND1 w0.095: v3(277.07,25.94) 277.07,26.07 v1(277.24,26.25)
  GND3 w0.095: v6(277.4,25.88) 277.34,25.94 v3(277.07,25.94)
  IN4 w0.076: v6(277.4,25.88) 277.48,25.8 278.42,25.8 278.56,25.94 280.18,25.94 280.82,26.58 284.53,26.58 284.74,26.37 287.58,26.37 288.54,25.41 288.54,22.52 288.28,22.26 v5(288.28,21.81)
  BOTTOM w0.095: v5(288.28,21.81) 288.28,21.43 R227.2
MUX_C_SBU2: length 68.1
  TOP w0.076: 277.09,25.57 277.15,25.57 v1(277.24,25.48)
  TOP w0.095: JUSBC3.B8 292.5,50.79 292.5,55.44 292.17,55.77 289.27,55.77 288.32,54.82 285.43,54.82 v10(284.66,54.05) v7(283.93,53.32) ; R47.2 276.63,25.57 277.09,25.57
  IN1 w0.076: v7(283.93,53.32) 283.86,53.25 283.86,52.98 283.61,52.73 283.61,52.72 283.44,52.72 283.44,52.73 280.17,52.73 277.22,49.77 277.22,37.43 278.37,36.27 278.37,32.38 278.92,31.83 278.92,27.5 278.22,26.8 278.22,26.1 277.87,25.75 277.51,25.75 v1(277.24,25.48)
  GND1 w0.095: v1(277.24,25.48) 277.24,25.29 v3(277.13,25.17)
  GND3 w0.095: v6(277.4,25.36) 277.31,25.36 v3(277.13,25.17)
  IN4 w0.076: v5(287.9,21.79) 287.9,22.19 288.33,22.63 288.33,25.33 287.53,26.13 284.66,26.13 284.42,26.37 280.9,26.37 280.26,25.73 278.64,25.73 278.51,25.6 277.51,25.6 277.4,25.5 v6(277.4,25.36)
  BOTTOM w0.095: R228.2 287.67,21.47 287.9,21.7 v5(287.9,21.79)
MUX_C_USB_OC2#: length 221.4
  IN2 w0.064: v3(171.88,9.81) 171.59,9.81 165.25,16.15 163.08,16.15 159.72,19.52 159.72,26.84 158.97,27.59 158.97,30.81 157.94,31.84 157.94,35.74 152.83,40.85 152.83,45.42 146.38,51.87 146.38,54.23 143.42,57.19 142.12,57.19 140.19,59.12 140.19,60.43 137.41,63.21 137.41,63.61 135.84,65.19 134.32,65.19 v3(134.03,65.47)
  GND3 w0.095: v3(171.88,9.81) 171.9,9.81 v6(172.14,9.58) ; v4(133.76,65.9) 133.76,65.74 v3(134.03,65.47)
  IN4 w0.076: v6(172.14,9.58) 172.98,9.58 175.52,7.04 184.33,7.04 185.85,5.53 196.59,5.53 196.76,5.7 200.9,5.7 202.61,7.41 203.77,7.41 204,7.65 207.06,7.65 209.25,9.84 209.52,9.84 212.43,12.74 216.41,12.74 218.75,10.4 222.93,10.4 225.42,7.91 250.22,7.91 250.92,8.6 255.37,8.6 257.14,10.38 261.34,10.38 265.1,14.13 266.4,14.13 267.32,13.21 271.71,13.21 271.87,13.06 273.71,13.06 275.83,15.18 276.81,15.18 277.34,14.65 279.46,14.65 282.1,12.01 282.1,11.48 282.82,10.76 292.2,10.76 292.88,11.44 292.88,12.29 294.82,14.23 294.82,14.48 295.18,14.84 v5(295.18,15.63)
  BOTTOM w0.076: UCPU1.D9 133.09,64.45 133.09,64.67 133.32,64.9 133.58,64.9 133.78,65.1 133.78,65.4
  BOTTOM w0.095: RC55.1 135.7,68.97 135.7,68.18 135.34,67.82 134.97,67.82 133.76,66.61 v4(133.76,65.9) 133.74,65.88 133.74,65.44 133.78,65.4
MUX_C_VBUS_L:
  vias: v2(291.8,15.64) v8(289.7,13.26) v8(290.28,13.24) v8(291.17,18.33) v8(291.16,17.7) v8(291.77,18.35)
MUX_FLIP_SEL: length 17.9
  GND1 w0.095: v1(275.4,20.78) 275.59,20.78 v3(275.76,20.62)
  IN3 w0.064: v3(275.76,20.62) 275.46,20.62 275.2,20.36 275.2,17.41 274.4,16.61 274,16.61 273.85,16.47 273.84,16.47 273.53,16.16 273.53,14.89 274.18,14.24 275.14,14.24 276.31,13.07 280.92,13.07 v3(281.47,12.52)
  GND3 w0.095: v3(281.47,12.52) 281.23,12.28 v4(281.23,12.17)
  BOTTOM w0.095: R5818.2 282,11.62 281.45,12.17 v4(281.23,12.17)
MUX_I2C_CLK_R: length 15.4
  TOP w0.095: U30.21 274.08,22.88 274.65,22.31 276.09,22.31 276.26,22.14 276.26,21.98 R57.1 276.32,21.32 R5811.1 276.62,20.47 276.62,20.33 v1(276.23,19.93)
  GND1 w0.095: v1(276.23,19.93) 276.62,19.93 v3(276.63,19.92)
  GND3 w0.095: v4(276.29,19.76) 276.42,19.88 276.6,19.88 v3(276.63,19.92)
  BOTTOM w0.095: QC2.1 277.72,14.83 277.27,14.83 276.78,15.32 275.19,15.32 275.01,15.49 275.01,17.15 275.43,17.57 276.11,17.57 276.6,18.05 276.6,19.1 276.68,19.18 276.68,19.51 276.43,19.76 v4(276.29,19.76)
MUX_I2C_DATA_R: length 14.9
  TOP w0.095: v1(277.1,19.95) 276.89,20.16 276.89,20.53 R5809.1 276.82,21.1 R58.1 276.49,22 276.49,22.22 276.18,22.53 274.74,22.53 274,23.28 U30.22
  GND1 w0.095: v3(276.75,19.4) 277.1,19.75 v1(277.1,19.95)
  GND3 w0.095: v3(276.75,19.4) 276.74,19.39 v4(276.37,19.39)
  BOTTOM w0.095: v4(276.37,19.39) 276.37,18.14 276.02,17.79 275.34,17.79 274.79,17.24 274.79,15.25 275.46,14.58 275.46,13.57 275.63,13.4 QC2.4
MUX_PD_SBU1: length 3.2
  TOP w0.095: R62.1 275.59,27.02 R46.1 275.45,26.31 274.42,25.28 U30.27
MUX_PD_SBU2: length 3
  TOP w0.095: U30.26 274.55,24.88 v2(274.69,25.02) 275.14,25.47 275.48,25.47 275.5,25.44 R47.1 R63.1
MUX_USB3_RX0_N: length 41
  TOP w0.102: v8(272.66,28.09) 272.2,27.63 272.2,27.09 271.91,26.81 U30.31
  IN2 w0.089: v8(288.97,45.01) 289.02,45.06 289.02,45.3 288.93,45.39 288.66,45.39 288.37,45.1 288.37,43.03 285.83,40.49 282.81,40.49 279.6,37.28 279.6,34.99 278.19,33.58 277.4,33.58 273.46,29.64 273.46,28.69 273.93,28.22 273.93,27.39 273.21,26.68 272.41,26.68 272.07,27.02 272.07,27.55 272.61,28.09 v8(272.66,28.09)
  BOTTOM w0.102: JUSBC3.B10 291.15,48.64 290.24,48.64 289.27,47.68 287.92,47.68 287.68,47.44 287.68,47.19 D59.1 287.71,46.68 287.71,46.44 288.59,45.55 289.1,45.55 289.27,45.38 289.27,45.12 289.15,45.01 v8(288.97,45.01)
MUX_USB3_RX0_P: length 41
  TOP w0.102: U30.30 272.31,26.88 272.45,27.02 272.97,27.02 273.07,27.12 273.07,27.29 272.87,27.48 v8(272.65,27.48)
  IN2 w0.089: v8(289.78,44.95) 289.78,44.86 289.67,44.75 289.51,44.75 289.39,44.87 289.39,45.44 289.08,45.75 288.51,45.75 288.01,45.25 288.01,43.17 285.68,40.84 282.66,40.84 279.25,37.43 279.25,35.14 278.04,33.94 277.25,33.94 273.1,29.79 273.1,28.54 273.57,28.07 273.57,27.54 273.07,27.03 272.56,27.03 272.42,27.17 272.42,27.41 272.51,27.49 272.64,27.49 v8(272.65,27.48)
  BOTTOM w0.102: v8(289.78,44.95) 289.68,44.95 289.5,45.13 289.5,45.47 289.19,45.78 288.69,45.78 287.94,46.53 287.94,46.68 D57.1 287.91,47.24 287.91,47.34 288.01,47.45 289.37,47.45 290.33,48.41 290.59,48.41 290.7,48.3 290.7,48 290.8,47.9 JUSBC3.B11
MUX_USB3_RX1_N: length 43.6
  TOP w0.102: U30.39 268.71,26.81 268.67,26.86 268.67,27.01 v8(268.91,27.25) ; JUSBC3.A10 288.59,52.05 288.44,52.2 288.28,52.2 288.04,52.45 288.04,52.64 287.93,52.75 287.78,52.75 D64.1 287.29,52.81 287.16,52.81 286.82,53.15 286.66,53.15 286.55,53.05 v8(286.55,52.85)
  IN2 w0.089: v8(286.55,52.85) 286.78,53.07 286.78,53.21 286.65,53.34 286.02,53.34 285.64,52.96 285.64,51.83 285.11,51.3 285.11,49.2 285.77,48.54 285.77,45.47 285.12,44.82 285.12,43.3 284.64,42.82 279.7,42.82 273.9,37.01 273.9,33.39 272.3,31.8 270.85,31.8 268.96,29.91 268.96,28.51 269.16,28.31 269.16,27.63 268.91,27.38 v8(268.91,27.25)
MUX_USB3_RX1_P: length 43.6
  TOP w0.102: v8(286.57,53.75) 286.57,53.51 286.7,53.38 286.91,53.38 287.25,53.04 287.39,53.04 D66.1 287.81,52.98 288.03,52.98 288.27,52.73 288.27,52.54 288.38,52.43 288.5,52.43 288.62,52.55 JUSBC3.A11 ; U30.40 268.31,26.79 268.44,26.92 268.44,27.1 v8(268.28,27.26)
  IN2 w0.089: v8(268.28,27.26) 268.8,27.78 268.8,28.16 268.61,28.36 268.61,30.06 270.7,32.15 272.15,32.15 273.54,33.54 273.54,37.16 279.56,43.17 284.49,43.17 284.76,43.44 284.76,44.96 285.42,45.62 285.42,48.39 284.75,49.05 284.75,51.45 285.28,51.98 285.28,53.1 285.87,53.69 286.51,53.69 v8(286.57,53.75)
MUX_USB3_TX0_N: length 31.7
  TOP w0.102: C57.2 271.02,28.53 271.24,28.75 v8(271.24,29.12) ; v8(286.62,43.64) 286.8,43.82 286.8,44.36 286.69,44.47 286.69,44.84 D58.1 286.58,45.13 286.58,45.89 286.84,46.14 287.4,46.14 287.82,46.56 287.82,48.18 288.19,48.55 JUSBC3.A3
  IN2 w0.089: v8(271.24,29.12) 271.24,29.21 271.22,29.24 271.22,30.2 271.62,30.61 272.86,30.61 276.44,34.19 276.44,36.17 281.87,41.61 285.28,41.61 286.83,43.16 286.83,43.54 286.72,43.64 v8(286.62,43.64)
