# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VBUS1_ECOK: length 55.1
  TOP w0.095: v7(50,12.87) 50.88,12.87 51.28,13.27 51.28,13.72 51.27,13.73 51.27,15.45 PR138.1 ; v7(34.2,15.88) 34.15,15.83 34.15,14.49 33.16,13.49 32.84,13.49 32.69,13.34 v2(32.69,13.29) 32.69,12.8 32.36,12.46 32.36,11.19 31.93,10.75 31.93,10.24 31.59,9.91 31.59,9.38 30.71,8.5 30.71,7.4 30.85,7.26 PR114.2 31.17,6.99 30.85,6.67 v1(30.85,5.35)
  IN1 w0.076: v7(34.2,15.88) 34.74,15.88 34.86,15.75 36.87,15.75 37.91,14.72 40.61,14.72 41.79,13.55 49.33,13.55 v7(50,12.87)
  GND1 w0.095: v3(15.07,13.61) 15.07,13.98 v1(15.1,14.01) ; v3(30.82,5.68) 30.85,5.66 v1(30.85,5.35)
  IN2 w0.064: v3(30.82,5.68) 30.82,5.69 30.08,5.69 27.95,7.82 25.64,7.82 24.53,8.94 22.83,8.94 22.49,9.28 19.92,9.28 19.65,9.55 16.79,9.55 15.15,11.19 15.15,13.37 15.07,13.45 v3(15.07,13.61)
VBUS2_ECOK: length 48.1
  TOP w0.095: UE3.C13 15.01,11.61 14.99,11.63 13.8,11.63 13.12,10.95 13.12,10.09 12.86,9.83 12.86,8.39 12.15,7.67 11.03,7.67 10.61,7.25 10.61,5.85 v2(10.25,5.49) 10.07,5.31 10.07,4.45 9.87,4.25 v7(9.77,4.25) ; v7(42.84,4.25) PR135.2 43.09,4.25 43.75,4.91 PR145.1
  IN1 w0.076: v7(9.77,4.25) 9.83,4.31 10.41,4.31 10.68,4.04 13.89,4.04 14.42,4.58 15.47,4.58 15.9,4.15 17.52,4.15 18.46,5.09 20.8,5.09 21.88,4 28.94,4 29.57,4.64 32.59,4.64 32.75,4.8 33.19,4.8 34.05,3.94 38.34,3.94 39.21,4.8 42.28,4.8 v7(42.84,4.25)
VBUS3_ECOK: length 219.6
  TOP w0.095: UE3.E12 16.25,12.87 16.25,11.47 16.05,11.27 14.91,11.27 14.77,11.41 13.89,11.41 13.35,10.86 13.35,9.99 13.09,9.73 13.09,8.29 12.24,7.45 11.12,7.45 10.85,7.18 10.85,5.6 10.29,5.04 10.29,3.88 10.21,3.8 v7(10.21,3.76) ; v1(180.74,11.39) 181.98,10.15 v2(181.98,8.01) v7(181.98,5.54) ; v7(69.76,1.59) v1(69.76,5.22)
  IN1 w0.076: v7(10.21,3.76) 10.24,3.76 10.36,3.64 17.63,3.64 18.49,4.5 20.81,4.5 21.71,3.6 29.11,3.6 29.74,4.23 32.48,4.23 33.38,3.33 41.86,3.33 42.52,2.67 53.69,2.67 53.69,2.66 61.96,2.66 63.04,1.58 69.75,1.58 v7(69.76,1.59) 69.76,1.58 77.54,1.58 81.44,5.49 115.61,5.49 116.6,6.47 116.6,6.99 118.76,9.16 144.51,9.16 144.76,9.4 149.05,9.4 154,4.45 159.21,4.45 160.6,5.84 163.8,5.84 164.98,7.02 166.72,7.02 168.69,5.04 181.48,5.04 v7(181.98,5.54)
  GND1 w0.095: v1(180.74,11.39) 180.74,11.81 v3(180.84,11.92) ; v1(69.76,5.22) 69.76,5.5 v3(69.85,5.6)
  GND3 w0.095: v3(69.85,5.6) 69.85,5.97 v4(69.59,6.23) ; v4(181.28,11.41) 181.28,11.48 v3(180.84,11.92)
  BOTTOM w0.095: PR195.1 65.65,10.65 69,10.65 69.25,10.4 69.25,6.57 v4(69.59,6.23) ; v4(181.28,11.41) 182.87,11.41 PR267.2
VBUSSENSE: length 2.8
  TOP w0.095: v8(135.46,51.55) 135.49,51.55 135.77,51.84 RC49.1 136.43,50.97 v2(136.55,50.84)
  BOTTOM w0.112: UCPU1.AG4 135.61,51.68 135.49,51.55 v8(135.46,51.55)
VCC0V9_LVR_OUT: length 5.7
  TOP w0.095: v2(18.2,44.77) 18.2,44.16 CT85.1
  IN2 w0.381: v3(21.58,48.08) 21.58,48.04 20.99,47.45 20.99,46.15 20.28,45.43 v3(20.28,44.68)
  GND3 w0.254: v3(20.28,44.68) 20.55,44.95 v4(20.59,44.95)
  vias: v1(19.72,45.04) v1(19.72,44.41) v1(21.63,47.15) v1(21.69,47.73) v4(21.24,48.2) v4(21.24,44.95) v4(21.89,48.2)
VCC0V9_SVR: length 4.3
  TOP w0.095: v8(17.65,58.88) 17.65,59.01 v2(17.2,59.47)
  GND3 w0.254: v4(22.54,48.85) 22.46,48.85 v3(22.22,48.6) ; v4(23.19,48.85) v3(22.91,48.57) ; v3(20.32,46.57) 20.59,46.29 v4(20.59,46.25)
  BOTTOM w0.203: UT2.F12 20.59,47.55 v8(20.27,47.87) UT2.F11 ; v8(20.27,47.22) 20.59,46.9 UT2.F13 ; v8(20.27,47.22) 19.94,47.55 UT2.E12 ; v8(20.27,47.22) 19.94,46.9 UT2.E13
  vias: v8(16.27,58.25) v8(16.27,57.61) v8(16.27,56.45) v8(16.27,55.84) v8(16.3,58.83) v8(16.3,57.03) v8(17.02,58.88)
VCC1V8A_TBT_LDO_A: length 4.6
  TOP w0.095: U19.K1 16.55,33.73 15.98,33.73 15.52,34.19 v2(15.21,34.19) 15.13,34.27 CT94.1 15.1,35.12 14.74,35.48 14.74,35.6 14.19,36.16 RT52.2
VCC1V8A_TBT_LDO_B: length 5.6
  TOP w0.095: U20.K1 28.83,36.24 28.52,36.24 27.68,37.08 CT97.1 27.65,37.43 27.29,37.79 27.29,37.9 RT58.2 25.85,39.34 v2(25.85,39.44)
VCC1V8A_TBT_LDO_C: length 4.4
  BOTTOM w0.305: U21.K1 284.84,18.33 284.07,19.1 v2(284.07,20.07) 283.17,20.96 CT100.1 283.17,21.03 RT64.2
VCC1V8D_TBT_LDO_A: length 1.8
  TOP w0.095: CT95.1 22.9,33.46 22.3,32.86 21.8,32.86 21.75,32.81 U19.A2
VCC1V8D_TBT_LDO_B: length 2.4
  TOP w0.095: CT98.1 34.65,36.76 34.65,35.66 U20.A2
VCC1V8D_TBT_LDO_C: length 12.5
  BOTTOM w0.095: U21.A2 287.27,12.07 289.59,12.07 291.11,10.55 292.77,10.55 v2(293.23,11) 294.58,12.35 CT101.1
VCC3V3_TBT_LDO_A: length 379.5
  TOP w0.254: RT45.1 19.43,65.8 RT46.1 RT47.1 16.07,63.96 v1(15.88,64.15) ; U19.G1 v8(18.48,34.05)
  TOP w0.381: v8(18.48,34.05) 18.48,34.15 18.66,34.33 C142.1 ; v1(12.82,67.01) 13.45,67.01 15.06,65.4 15.06,64.96 15.46,64.56 RT44.1 15.48,64.56 v1(15.88,64.15)
  TOP w0.508: 29.14,43.74 29.27,43.74 32.41,40.59 36.43,40.59 36.81,40.2 37.03,40.2 37.07,40.17 ; v7(73.84,35.4) 74.27,34.97 74.27,30.23 72.74,28.7 72.74,25.25 76.93,21.06 76.93,19.11 77.54,18.5 77.54,16.23 80.28,13.48 81.5,13.48 85.52,9.47 86.14,9.47 v2(86.42,9.19) 94.02,1.59 128.8,1.59 129.39,2.18 130.97,2.18 131.62,1.53 151.4,1.53 152.81,2.94 160.95,2.94 161.95,3.94 161.95,7.25 v8(161.5,7.7) ; v8(10.85,34.39) 10.85,33.97 11.05,33.77 12.37,33.77 ; R179.1 22.67,38.06 R177.1
  IN1 w0.508: v8(267.74,4.26) 266.29,2.8 226.95,2.8 225.11,4.64 184.7,4.64 182.79,6.55 168.69,6.55 167.4,7.84 161.9,7.84 161.76,7.7 v8(161.5,7.7) ; v8(285.29,6.56) 286.02,6.56 287.16,7.7 287.16,11.11 284.89,13.38 284.89,15.47 285.77,16.34 286.28,16.34 286.69,16.75 286.69,17.19 ; v8(18.48,34.05) 18.94,34.05 19.9,35.01 20.24,35.01 20.87,35.64 20.87,36.23 22.21,37.57 24.16,37.57 v7(24.47,37.88) 24.94,38.36 24.94,39.73 v7(29.14,43.93) ; v7(73.84,35.4) 73.84,35.61 71.9,37.55 69.53,37.55 68.75,36.77 68.75,35.34 68,34.58 66.73,34.58 66.43,34.88 66.1,34.88 65.85,35.12 63.3,35.12 62.88,35.54 62.88,35.55 61.91,36.52 61.91,36.52 60.88,37.55 49.31,37.55 48.2,36.45 46.78,36.45 46.12,37.1 42.74,37.1 42.06,37.78 40.83,37.78 39.41,39.2 38.9,39.2 38.12,39.98
  GND1 w0.381: v1(15.88,64.15) v3(15.45,64.15) ; v1(12.82,67.01) v3(12.57,66.76)
  IN2 w0.508: 10.59,35.69 10.25,35.69 9.48,36.47 9.48,38.11 10.12,38.75 10.12,39.97 10.64,40.49 10.64,43.79 10.55,43.88 10.55,44.87 10.7,45.02 10.7,49.89 10.31,50.27 v3(10.31,50.67)
  IN3 w0.381: v3(10.31,50.67) 11.52,51.87 11.52,59.61 10.82,60.31 10.82,62.7 11.47,63.35 11.47,63.7 12.24,64.47 15.13,64.47 v3(15.45,64.15)
  IN3 w0.508: v8(285.29,6.56) 284.27,5.53 277.39,5.53 276.46,4.6 271.39,4.6 271.04,4.26 v8(267.74,4.26)
  GND3 w0.095: v3(10.64,33.8) 10.59,33.8 10.55,33.84 10.5,33.84 10.07,34.28 v4(9.82,34.28)
  GND3 w0.381: v4(12.3,66.49) v3(12.57,66.76)
  BOTTOM w0.095: UT3.8 12.33,66.45 v4(12.3,66.49)
  vias: v7(24.12,37.91) v7(29.15,44.48) v7(37.95,40.22) v7(38.24,40.22) v7(286.68,18.08) v7(286.84,17.84)
VCC3V3_TBT_LDO_B: length 33.8
  TOP w0.254: v1(27.6,33.61) 27.6,33.71 27.34,33.96 26.04,33.96 R5762.1 ; v8(30.82,38.69) 30.65,38.52 30.65,37.68 C155.1 31.02,36.93 U20.G1
  TOP w0.381: R207.1 R205.1 27.75,40.24 28.03,40.24 R212.1 28.61,40.91 v7(29.03,41.33) v2(29.67,40.69) 30.33,40.03 30.33,39.18 v8(30.82,38.69)
  IN1 w0.381: v7(35.52,36.14) 35.52,36.42 35.52,36.42 35.52,38.69 32.88,41.33 v7(29.03,41.33)
  GND1 w0.254: v3(27.69,33.09) 27.69,33.14 27.6,33.24 v1(27.6,33.61)
  GND3 w0.254: v6(28,33.53) 27.69,33.22 v3(27.69,33.09)
  IN4 w0.254: v6(28,33.53) 30.6,33.53 30.65,33.58
  IN4 w0.508: 30.65,37.85 30.65,33.48 29.84,32.67 29.84,31.34
  vias: v4(29.67,30.79) v4(29.92,30.72)
VCC3V3_TBT_LDO_C: length 34.4
  TOP w0.095: R225.1 289.12,15.36 v2(289.31,15.17)
  TOP w0.33: C1088.1 289.13,18.58 288.87,18.85 286.34,18.85 286.09,19.09 283.81,19.09 283.28,19.63 UT6.8
  TOP w0.381: R223.1 289.13,18.05 C1088.1 ; R223.1 289.12,17.48 R226.1 ; R223.1 289.12,17.47 R224.1 R225.1
  IN2 w0.508: 281.83,21.03 281.57,21.29 281.57,26.46 v3(282.03,26.92) ; 281.83,21.03 286.51,21.03 287.42,21.94 v3(287.46,21.94) ; 281.83,21.03 281.32,20.52 v3(281.32,19.69) 281.32,19.04 281.97,18.39 281.97,17.83 283.23,16.57 v3(283.23,16.34)
  GND3 w0.254: v3(282.03,26.92) 282.11,26.99 v4(282.64,26.99)
  GND3 w0.305: v4(283.23,16.71) v3(283.23,16.34)
  GND3 w0.381: v3(287.46,21.94) 287.26,22.14 v4(287.26,22.25)
  BOTTOM w0.254: v4(282.64,26.99) 283.17,26.46 284.13,26.46 284.38,26.71 R233.1
  BOTTOM w0.305: U21.G1 284.17,16.83 284.05,16.71 v4(283.23,16.71)
  vias: v1(281.72,19.8) v1(281.72,19.53) v4(280.71,19.28) v4(280.71,19)
VCC3V3_TBT_SX_A: length 4.1
  TOP w0.076: U19.H2 17.73,33.05 17.33,33.05 17.23,33.16 17.23,33.55 17.13,33.65
  TOP w0.095: 17.13,33.65 16.87,33.65 16.62,33.9 16.11,33.9 15.62,34.4 15.62,34.8 C141.1
VCC3V3_TBT_SX_B: length 3.1
  IN1 w0.076: v7(28.72,37) 28.82,37 29.3,36.52 29.85,36.52 30.52,35.85 v7(30.52,35.04)
VCC3V3_TBT_SX_C: length 4.2
  IN4 w0.076: v5(285.92,17.96) 285.92,17.8 285.65,17.53 284.96,17.53 284,18.5 v5(283.16,18.5)
  BOTTOM w0.095: U21.H2 285.52,17.4 285.92,17.79 v5(285.92,17.96)
VCC_3V3_PCIE: length 0.4
  GND3 w0.254: v3(22.28,45.34) v4(22.54,45.6)
  vias: v1(22.26,45.93) v1(22.26,44.66)
VCC_3V3_USB2: length 0.6
  GND3 w0.254: v3(21.37,45.56) 21.41,45.56 21.45,45.52 21.81,45.52 v4(21.89,45.6)
  vias: v1(20.99,45.93) v1(20.99,45.3) v1(20.99,44.66)
VCC_EDRAM_SENSE: length 55.9
  IN1 w0.254: v8(101.91,54.12) 101.91,53.94 101.58,53.62 99.93,53.62 98.62,52.3 98.14,52.3 92.48,46.64 86.69,46.64 84.92,44.86 84.92,38.17 82.59,35.84 76.08,35.84 72.5,32.26 69.3,32.26 67.54,30.5 63.2,30.5 62.93,30.77 v9(61.4,30.77)
  GND1 w0.254: v3(61.37,30.31) 61.4,30.34 v9(61.4,30.77)
  GND3 w0.254: v3(61.37,30.31) 61.33,30.27 v4(61.33,29.9)
  BOTTOM w0.076: v8(101.91,54.12) 102.14,54.35 UCPU1.AC63
VCC_EOPIO_SENSE: length 43.1
  IN1 w0.254: v8(102.55,50.33) 102.25,50.02 99.16,50.02 97.41,48.27 97.41,47.16 96.72,46.47 96.25,46.47 95.85,46.08 95.85,45.86 94.54,44.55 94.54,42.41 85.69,33.56 76.49,33.56 73.25,30.31 70.55,30.31 v7(70.41,30.46)
  BOTTOM w0.254: v8(102.55,50.33) 102.54,50.32 102.39,50.32 UCPU1.AL63
VCC_SENSE: length 110
  TOP w0.254: v1(119.26,63.7) 119.33,63.77 119.43,63.77 v2(119.78,64.12) RC150.2
  GND1 w0.254: v3(118.93,63.57) 119.06,63.7 v1(119.26,63.7)
  GND3 w0.254: v4(119.36,63.5) 119,63.5 v3(118.93,63.57)
  IN4 w0.254: v5(46.88,47.58) 46.98,47.67 46.98,48.49 46.44,49.03 45.18,49.03 43.31,50.89 42.75,50.89 42.55,51.09 42.55,52.53 45.06,55.04 45.06,57.03 47.67,59.65 47.67,61.96 48.26,62.54 48.26,64.71 53.77,70.23 61.84,70.23 62.88,69.18 71.16,69.18 72.61,70.63 78.35,70.63 79.23,69.75 83.93,69.75 84.64,70.46 86.1,70.46 87.06,71.42 90.19,71.42 90.93,70.67 95.34,70.67 96.08,71.42 97.56,71.42 97.76,71.21 100.2,71.21 101.52,72.54 105.92,72.54 108.32,70.14 108.53,70.14 108.89,69.79 110.88,69.79 111.78,68.89 111.78,66.87 111.97,66.68 111.97,65.33 112.13,65.17 112.13,64.38 112.61,63.91 113.56,63.91 114.73,62.74 118.32,62.74 119.08,63.5 v4(119.36,63.5)
  BOTTOM w0.254: v5(46.88,47.58) 46.96,47.58 PR1046.2 47.06,47.48 PC1034.2
VCCGT_SENSE: length 83
  TOP w0.254: v1(39.2,40.25) 39.18,40.23 PC1009.1 ; RC160.2 94.33,61.58 v1(94.33,61.75)
  GND1 w0.254: v1(39.2,40.25) 39.2,40.47 39.44,40.71 v3(39.44,40.74) ; v3(94.58,62) v1(94.33,61.75)
  GND3 w0.254: v3(39.44,40.74) v6(39.44,41.22) ; v3(94.58,62) 94.58,62.51 v4(94.88,62.81)
  IN4 w0.254: v6(39.44,41.22) 39.78,41.56 39.78,43.53 40.29,44.04 41.18,44.04 42.27,45.13 47.77,45.13 48.65,46.01 48.65,49.96 49.57,50.87 49.57,52.12 52.37,54.92 52.37,58.58 53.35,59.56 56.1,59.56 56.36,59.31 59.3,59.31 60.68,60.69 60.68,63.76 61.71,64.79 77.68,64.79 80.46,62 92.69,62 93.54,62.85 94.85,62.85 v4(94.88,62.81)
  BOTTOM w0.076: UCPU1.J70 97.34,61.34 97.1,61.1 97.03,61.08 96.54,61.08
  BOTTOM w0.254: v4(94.88,62.81) 95.2,62.49 v2(95.2,62) 95.2,61.89 96.01,61.08 96.54,61.08
VCCHDA: length 3.3
  TOP w0.381: RA65.2 124.96,50.35 v1(124.96,50.88)
  GND1 w0.381: v1(124.96,50.88) v3(125.52,50.88)
  IN2 w0.381: v3(125.52,50.88) 125.77,51.14 v3(126.4,51.14)
  GND3 w0.254: v3(126.4,51.14) 126.83,51.56 v4(126.84,51.56)
VCCIO_SENSE: length 53.6
  TOP w0.254: v8(123.45,49.68) 123.4,49.73 123.2,49.73 122.84,50.1 RC163.2 ; v7(151.69,56.33) 155.02,56.33 v2(156.29,57.6) 156.82,58.13 v1(162.81,58.13)
  IN1 w0.254: v9(135.76,49.09) 136.77,48.08 140.08,48.08 141.04,49.03 144.23,49.03 144.68,48.59 146.97,48.59 147.79,49.41 148.54,49.41 151.69,52.56 151.69,56.32 151.69,56.32 v7(151.69,56.33)
  GND1 w0.254: v1(162.81,58.13) 163.16,58.13 v3(163.18,58.15) ; v9(135.76,49.09) 135.51,49.33 135.51,49.37 v3(135.42,49.46)
  GND3 w0.254: v6(135.53,49.91) 135.42,49.8 v3(135.42,49.46) ; v4(163.51,58.25) 163.28,58.25 v3(163.18,58.15)
  IN4 w0.254: v8(123.45,49.68) 123.52,49.68 123.63,49.57 126.08,49.57 126.69,50.18 127.01,50.18 127.72,50.89 127.72,52.18 128.18,52.64 134.12,52.64 134.94,51.81 134.94,51.27 135.62,50.6 135.62,50.23 135.53,50.14 v6(135.53,49.91)
  BOTTOM w0.254: UCPU1.AM23 123.87,49.96 123.63,49.73 123.49,49.73 v8(123.45,49.68)
VCCSA_SENSE: length 111.4
  TOP w0.254: RC166.2 125.38,61.92 v8(125.29,61.83) ; PR1029.2 41.78,52.83 v1(42.66,52.83)
  GND1 w0.254: v3(42.44,53.29) 42.44,53.05 v1(42.66,52.83)
  GND3 w0.254: v3(42.44,53.29) 43.09,53.29 43.76,52.62 v6(43.76,52.48)
  IN4 w0.254: v6(43.76,52.48) 44.3,52.48 45.69,53.87 45.69,56.56 46.45,57.32 47.58,57.32 48.37,58.11 48.37,60.14 49.07,60.84 49.07,64.53 53.92,69.38 61.79,69.38 62.62,68.55 71.43,68.55 72.87,70 78.08,70 78.99,69.09 84.55,69.09 85.23,69.78 86.35,69.78 87.35,70.78 89.94,70.78 90.71,70 95.62,70 96,70.37 100.56,70.37 102.09,71.91 105.46,71.91 106.66,70.71 106.66,64.32 107.62,63.36 107.9,63.36 108.87,62.39 108.87,62.08 109.22,61.72 111.67,61.72 111.78,61.6 118.53,61.6 118.78,61.86 120.19,61.86 120.34,62.01 122.98,62.01 123.5,61.48 125.14,61.48 125.29,61.62 v8(125.29,61.83)
  BOTTOM w0.254: v8(125.29,61.83) 125.27,61.82 125.27,61.38 125.48,61.17 126.29,61.17 UCPU1.H20
VCCST_EN: length 236
  TOP w0.095: UC6.4 10.81,30.55 RE7.1 ; RE7.1 v2(12.07,30.33) ; RE7.1 10.58,29.89 v1(9.84,29.89)
  GND1 w0.095: v1(141.34,71.16) 141.34,70.82 v3(141.62,70.54) ; v1(9.84,29.89) 9.9,29.89 10.29,29.5 v3(10.29,29.08)
  IN2 w0.064: v3(152.17,13.98) 151.75,13.56 145.62,13.56 145.12,14.06 136.69,14.06 136.24,13.61 121.82,13.61 121.55,13.34 116.96,13.34 116.56,12.95 110.57,12.95 110.12,12.5 109.05,12.5 106.76,10.2 79.21,10.2 76.57,7.56 71.53,7.56 71.39,7.42 54.51,7.42 51.87,10.06 44.39,10.06 42,12.46 37.4,12.46 34.2,15.66 34.2,16.35 32.51,18.03 31.57,18.03 30.47,19.13 29.26,19.13 28.4,20 27.43,20 26.91,20.52 26.91,21.72 23.77,24.86 17.82,24.86 17.14,24.19 16.44,24.19 14.75,25.87 11.84,25.87 10.3,27.41 10.3,28.05 10.17,28.18 10.17,28.96 v3(10.29,29.08)
  GND3 w0.095: v3(152.17,13.98) 152.17,14.3 v6(152.15,14.32) ; v6(142.47,70.06) 142.22,70.06 141.75,70.54 v3(141.62,70.54)
  IN4 w0.076: v6(142.47,70.06) 143.67,71.27 146.55,71.27 147.68,70.73 149.94,68.47 149.94,62.3 150.71,61.53 150.71,59.04 151.59,58.16 151.59,56.89 153.81,54.67 153.81,52.04 155.37,50.48 155.37,48.42 154.79,47.84 154.79,41.25 154.32,40.78 154.32,38.31 153.67,37.67 153.67,36.37 155.38,34.66 155.38,33.49 156.5,32.37 156.5,27.36 157.84,26.02 157.84,16.17 157.16,15.49 153.7,15.49 152.53,14.32 v6(152.15,14.32)
VCCST_PWRGD: length 11.5
  BOTTOM w0.076: RC86.2 95.57,71.97 v2(95.2,71.6) ; 99.51,67.89 99.64,67.89 100.66,66.87 100.66,66.62 100.44,66.4 100.44,66.07 100.7,65.82 UCPU1.B65
  BOTTOM w0.095: v2(95.2,71.6) 95.07,71.47 95.07,69.78 95.18,69.68 95.82,69.68 96.09,69.41 96.09,69.27 97.47,67.89 99.51,67.89
VCCSTG_EN: length 122.9
  TOP w0.095: v1(150.88,10.47) 149.67,11.68 149.67,12.75 151.09,14.17 151.09,19.95 149.88,21.16 149.88,22.82 150.18,23.12 150.18,24.95 149.52,25.61 149.52,29.2 149.15,29.57 146.33,29.57 146,29.9 146,30.9 145.07,31.83 143.81,31.83 143.18,32.45 140.82,32.45 140.33,31.97 v2(137.33,31.97) 137.23,31.86 129.53,31.86 125.2,36.19 RZ2.1
  GND1 w0.095: v3(150.88,10.01) v1(150.88,10.47)
  GND3 w0.095: v3(150.88,10.01) 150.88,9.77 v6(151.03,9.62)
  IN4 w0.076: v5(165.72,49.56) 165.76,49.53 165.76,47.37 166.41,46.72 166.41,38.04 168.61,35.84 168.61,26.89 170.24,25.27 170.24,23.61 171.73,22.11 171.73,19.01 169.54,16.82 168.33,16.82 165.41,13.9 v5(165.34,13.9) 164.74,13.3 162.4,13.3 161.11,12.01 161.11,11.37 160.81,11.07 158.3,11.07 158.13,10.9 158.13,8.53 157.42,7.82 154.04,7.82 153.49,8.37 153.49,9.17 153.04,9.62 v6(151.03,9.62) 150.99,9.57 145.46,9.57 145.23,9.8 v5(145.13,9.8)
  BOTTOM w0.095: RZ1.1 v5(165.34,13.9) 165.73,13.51 UC4.4 ; UZ4.4 147.13,10.91 146.7,10.48 145.82,10.48 v5(145.13,9.8) ; v5(165.72,49.56) 165.52,49.56 PR1401.1
VDD: length 15.7
  IN1 w0.508: v8(60.03,14.29) 60.03,17.46 62.2,19.63 66.85,19.63 67.21,19.27 v7(67.21,17.15)
  BOTTOM w0.508: PR319.1 60.03,13.09 v8(60.03,14.29)
  vias: v2(60.54,14.45)
VIN_1V_PRIM: length 0.6
  TOP w0.095: v8(67.48,33.81) v2(67.48,33.19)
  vias: v8(66.28,34.05) v8(66.88,33.8)
VIN_PRIM:
  vias: v2(159.76,70.11) v8(159.81,69.43) v8(160.36,69.78) v8(160.36,69.15) v8(160.44,70.36)
VIN_VCC_EDRAM: length 1.3
  TOP w0.095: PC1508.1 57.73,33.77 v2(57.91,33.59)
  vias: v8(55.37,33.13) v8(55.99,33.13) v8(56.71,33.15)
VIN_VCCIO:
  vias: v2(168.15,53.16)
VSS_EDRAM_SENSE: length 58.1
  IN1 w0.254: v9(60.78,30) 60.97,29.81 67.74,29.81 69.55,31.61 72.75,31.61 76.34,35.2 82.98,35.2 85.67,37.9 85.67,44.72 86.87,45.92 92.73,45.92 100.06,53.26 102.31,53.26 102.48,53.43 v8(103.15,53.43)
  GND1 w0.254: v3(60.44,30.14) 60.64,30.14 v9(60.78,30)
  GND3 w0.254: v4(60.44,29.78) v3(60.44,30.14)
  BOTTOM w0.112: v8(103.15,53.43) 102.91,53.67 UCPU1.AE63
VSS_EOPIO_SENSE: length 46.2
  IN1 w0.254: v9(103.33,51.4) 102.45,51.4 102.05,51.8 101.51,51.8 101.41,51.9 99.63,51.9 96.77,49.05 96.77,47.49 96.43,47.15 96,47.15 95,46.15 94.67,46.15 93.28,44.77 93.28,42.05 91.21,39.98 85.42,34.19 79.74,34.19 76.23,34.19 73.01,30.97 70.02,30.97 70.02,30.97 v7(69.51,30.45)
  GND1 w0.254: v9(103.33,51.4) 103.24,51.49 v3(102.99,51.49)
  GND3 w0.254: v3(102.99,51.49) 102.7,51.49 v4(102.6,51.39)
VSS_F65_G65: length 12.1
  BOTTOM w0.076: 93.09,65.88 94.05,65.88 95.04,66.87 96.01,66.87 96.46,66.42 96.46,65.17 96.87,64.76 97.23,64.76 98.41,63.58 98.9,63.58 99.25,63.23 100.29,63.23 100.61,62.91 UCPU1.F65 UCPU1.G65
  BOTTOM w0.095: RC391.2 92.47,66.43 93.02,65.88 93.09,65.88
VSS_SENSE: length 111.9
  TOP w0.254: PC1036.1 46.02,48.44 45.25,47.68 PU1000.18 ; RC151.1 121.69,64.56 121.36,64.23 v2(121.31,64.23) 121.16,64.23 121.05,64.35 120.61,64.35 119.63,63.37 v1(119.51,63.37)
  GND1 w0.254: v3(46.12,48.96) 46.12,48.59 v1(46.13,48.58) ; v1(119.51,63.37) 119.33,63.19 v3(119.33,63.03)
  GND3 w0.254: v4(118.44,63.5) 118.44,63.35 118.7,63.09 119.27,63.09 v3(119.33,63.03) ; v3(46.12,48.96) 46.12,48.8 v6(45.95,48.63)
  IN4 w0.254: v4(118.44,63.5) 118.44,63.4 118.16,63.12 114.89,63.12 113.72,64.29 112.77,64.29 112.51,64.54 112.51,65.33 112.35,65.49 112.35,66.84 112.16,67.03 112.16,69.05 111.04,70.17 109.05,70.17 108.69,70.52 108.48,70.52 106.08,72.92 101.37,72.92 100.04,71.59 97.92,71.59 97.72,71.8 95.92,71.8 95.18,71.06 91.09,71.06 90.35,71.8 86.9,71.8 85.94,70.84 84.48,70.84 83.77,70.13 79.39,70.13 78.51,71.01 72.45,71.01 71.01,69.56 63.04,69.56 62,70.61 53.61,70.61 47.88,64.87 47.88,62.7 47.29,62.12 47.29,59.8 44.68,57.18 44.68,55.2 42.17,52.69 42.17,50.93 42.59,50.51 43.15,50.51 45.02,48.65 45.93,48.65 v6(45.95,48.63)
VSSGT_SENSE: length 81.4
  TOP w0.254: v1(40.39,42.97) 40.39,43.15 40.97,43.73 PU1000.6
  GND1 w0.254: v1(40.39,42.97) 40.52,42.83 v3(40.77,42.83)
  GND3 w0.254: v3(40.77,42.83) v6(40.2,43.41)
  IN4 w0.254: v6(40.2,43.41) 41.09,43.41 42.43,44.75 47.93,44.75 49.03,45.85 49.03,49.8 49.95,50.71 49.95,51.96 52.76,54.77 52.76,58.42 53.51,59.18 55.95,59.18 56.2,58.93 59.46,58.93 61.06,60.53 61.06,63.61 61.86,64.41 77.52,64.41 80.31,61.62 92.85,61.62 93.69,62.47 v5(94.59,62.47)
  BOTTOM w0.076: 96.77,60.65 97,60.87 97.18,60.94 97.73,60.94 98.13,61.34 UCPU1.J69
  BOTTOM w0.254: 96.77,60.65 v2(95.21,60.65) 94.59,60.65 RC161.1 94.75,61.61 94.75,62.3 v5(94.59,62.47)
VSSIO_SENSE: length 1.3
  GND1 w0.254: v1(123.72,50.25) 124.33,50.25 v3(124.35,50.24)
  GND3 w0.254: v4(124.84,49.96) 124.6,49.96 124.35,50.22 v3(124.35,50.24)
VSSSA_SENSE: length 112
  TOP w0.254: RC164.1 125.5,61.18 v8(126.17,61.84) ; v1(40.74,52.84) 40.74,52.43 40.97,52.2
  GND1 w0.254: v1(40.74,52.84) 41.07,52.84 41.43,52.48 41.43,52.46 v3(41.46,52.43)
  GND3 w0.254: v3(41.46,52.43) 42.74,52.43 v6(43.24,51.93)
  IN4 w0.254: v8(126.17,61.84) 126.05,61.84 125.3,61.1 123.35,61.1 122.82,61.62 120.5,61.62 120.35,61.48 118.94,61.48 118.69,61.22 111.63,61.22 111.51,61.34 109.07,61.34 108.49,61.92 108.49,62.24 107.75,62.98 107.46,62.98 106.28,64.16 106.28,70.55 105.3,71.53 102.25,71.53 100.72,69.99 96.15,69.99 95.78,69.62 90.55,69.62 89.78,70.4 87.5,70.4 86.5,69.39 85.39,69.39 84.71,68.71 78.83,68.71 77.93,69.62 73.03,69.62 71.58,68.17 62.46,68.17 61.63,69 54.08,69 49.45,64.37 49.45,60.68 48.75,59.98 48.75,57.95 47.74,56.94 46.61,56.94 46.07,56.4 46.07,53.72 44.45,52.1 43.41,52.1 v6(43.24,51.93)
  BOTTOM w0.254: UCPU1.H21 125.87,61.55 v8(126.17,61.84)
32KHZ_OUT: length 2.8
  GND1 w0.095: v3(23.43,13.72) 23.36,13.8 23.29,13.8 23.1,13.99 v1(23.1,14.01)
  GND3 w0.095: v4(23.71,13.93) 23.64,13.93 v3(23.43,13.72)
  BOTTOM w0.095: v4(23.71,13.93) 23.79,13.93 CE57.1 24.4,14.31 24.74,13.96 v2(25.35,13.96)
+BAT_TABLET: length 19.6
  TOP w0.254: PR330.2 70.68,8.04 v7(70.68,8.47)
  IN1 w0.254: v9(84.6,13.84) 80.54,13.84 76.94,10.24 75.85,10.24 75.23,9.62 75.23,8.88 74.61,8.26 72.07,8.26 71.86,8.47 v7(70.68,8.47)
  GND1 w0.254: v3(84.6,13.42) v9(84.6,13.84)
  GND3 w0.254: v4(84.6,12.16) v3(84.6,13.42)
  vias: v2(87.21,16.03)
+BATT:
  vias: v8(87.1,13.8) v8(87.11,11.85) v8(87.69,13.8) v8(87.72,11.85) v8(88.27,13.8) v8(88.32,11.85) v8(88.86,13.8) v8(88.96,11.87) v8(92.26,13.18) v8(92.85,13.18) v8(93.43,13.18) v8(94.01,13.18) v8(94.6,13.18) v8(95.18,13.18) v8(95.77,13.18) v8(96.35,13.18) v8(96.94,13.18) v11(90.9,11.87) v11(93.21,9.61) v11(95.57,11.74)
+CHG_SRC_20V:
  vias: v8(57.88,19.03) v8(57.99,24.49) v8(57.99,23.65) v8(57.99,22.82) v8(58,21.93) v8(58,20.95) v8(58.97,19.01) v8(59.53,21.95) v8(60.02,18.99) v8(60.59,21.95) v8(61.66,22.31) v11(59.7,20.4)
+CHG_VIN_20V: length 34.3
  TOP w0.254: 53.79,10.52 53.76,10.5 53.76,9.1 54.14,8.72 v11(55.56,8.72) 57.27,8.72 58.12,9.58 PR305.1
  TOP w0.508: PR303.1 56.05,16.34 55.16,15.45 55.16,11.89 53.79,10.52 48,10.52 47.92,10.45
  IN4 w0.508: v4(30.57,9.33) 30.67,9.23 34.68,9.23 35.24,8.67 36.76,8.67 37.49,9.4 v8(38.36,9.4)
  BOTTOM w0.254: 181.65,6.43 180.87,7.21 PQ150.3
  BOTTOM w0.508: PD111.2 31.44,8.46 v4(30.57,9.33)
  vias: v3(180.11,3.08) v3(180.51,3.08) v3(180.93,3.07) v3(181.35,3.07) v3(181.77,3.08) v3(182.19,3.07) v4(180.25,2.75) v4(180.5,2.74) v4(180.77,2.74) v4(181.06,2.74) v4(181.34,2.73) v4(181.6,2.74) v4(181.87,2.74) v4(182.16,2.73) v4(182.44,2.75) v4(182.56,3.08) v4(182.72,2.75) v4(182.82,3.08) v8(38.95,9.4) v8(39.56,9.4) v8(40.17,9.4) v8(40.78,9.4) v8(41.39,9.4) v8(43.35,9.4) v8(44.01,9.4) v8(44.64,9.4) v8(45.3,9.4) v8(45.96,9.4) v8(46.6,9.4) v8(53.61,1.7) v8(54.22,1.7) v8(54.85,1.71) v8(55.45,1.71) v8(56.07,1.7) v8(56.69,1.71) v11(42.98,12.47) v11(46.5,11.61)
+EC_DEBUG_VCC: length 2.7
  BOTTOM w0.102: v2(11.98,7.96) 12.96,8.93 12.96,10.18 RE200.2
+INV_PWR_SRC: length 123.3
  TOP w0.102: U24.A2 172.12,19.33 171.93,19.52 171.93,19.84 v7(171.91,19.86)
  IN1 w0.095: v9(259.13,14.89) 259.07,14.83 258.68,14.83 258.17,14.32 254.54,14.32 253.01,12.79 250.79,12.79 248.72,10.72 231.68,10.72 228.2,14.2 228.18,14.22 227.07,14.22 225.33,15.96 210.7,15.96 210.01,15.39 205.56,10.94 187.22,10.94 185.25,12.92 183.83,12.92 181.9,14.85 181.42,14.85 175.25,21.02 172.58,21.02 171.89,20.33 171.89,19.88 v7(171.91,19.86)
  GND1 w0.102: v9(259.13,14.89) 259.42,14.89 259.55,14.77 259.85,14.77 v3(259.87,14.75) ; v1(278.33,16.55) v3(278.33,17.22)
  GND3 w0.102: v6(278.33,17.6) 278.33,17.6 v3(278.33,17.22) ; v3(259.87,14.75) 259.87,15.07 v6(259.78,15.15)
  IN4 w0.095: v6(278.33,17.6) 277.74,18.2 276.13,18.2 272.83,14.91 269.42,14.91 268.5,15.82 264.4,15.82 262.6,14.03 260.5,14.03 259.85,14.68 259.85,15.09 v6(259.78,15.15)
  vias: v1(279.82,27.29) v1(279.82,26.98) v1(279.82,26.68) v1(280.1,27.13) v1(280.1,26.83) v1(280.1,26.52) v3(280.47,27.5) v3(280.47,26.97) v3(280.48,26.46) v4(279.79,27.5) v4(279.79,27.25) v4(279.79,26.99) v4(279.79,26.74) v4(279.79,26.48) v4(279.79,26.23) v11(279.36,22.28)
+INV_PWR_SRC_IN+: length 123.2
  TOP w0.102: v2(279.44,15.01) 279.74,15.31 280.13,15.31
  IN1 w0.095: v7(172.36,19.83) 172.36,20.28 172.74,20.66 175.1,20.66 181.27,14.49 181.75,14.49 183.69,12.56 185.1,12.56 187.08,10.59 205.71,10.59 210.24,15.12 210.83,15.6 225.18,15.6 226.92,13.86 228.04,13.86 231.54,10.36 248.87,10.36 250.94,12.43 253.16,12.43 254.69,13.96 258.32,13.96 258.83,14.47 v9(259.12,14.47)
  GND1 w0.102: v9(259.12,14.47) 259.27,14.47 v3(259.43,14.32) ; v1(279.58,16.55) v3(279.58,16.93)
  GND3 w0.102: v3(279.58,16.93) 279.58,17.3 v6(279.61,17.33) ; v6(259.36,14.66) 259.43,14.59 v3(259.43,14.32)
  IN4 w0.095: v6(279.61,17.33) 279.44,17.16 277.87,17.16 277.29,17.74 276.17,17.74 272.98,14.55 267.87,14.55 266.96,15.47 264.55,15.47 262.75,13.67 260.35,13.67 v6(259.36,14.66)
+LCDVDD: length 188.4
  TOP w0.102: v7(149.13,16.43) 148.76,16.43 148.15,15.82 148.15,14.44 146.16,12.45 145.08,12.45 144.26,13.27 139.55,13.27 138.68,12.39 132.74,12.39 132.09,11.75 132.09,8.41 131.64,7.96 130.73,7.96 129.78,7.01 129.78,4.1 128.39,2.7 94.42,2.7 81.56,15.56 80.29,15.56 78.46,17.38 78.46,19.34 77.42,20.39 77.42,22.13 80.26,24.97 80.55,26.08 80.62,26.3 80.63,26.3 80.63,30.33 80.19,30.77 76.67,30.77 75.02,32.42 75.02,35.36 72.78,37.6 65.58,37.6 64.46,38.72 63.44,38.72 62.46,39.7 53.62,39.7 51.98,41.34 51.98,43.58 50.87,44.69 49.84,44.69 49.35,45.17 49.35,47.68 50.59,48.92 50.59,50.41 51.05,50.87 51.6,50.87 51.86,51.13 51.86,54.1 51.1,54.86 v11(49.32,54.86) 47.55,54.86 v1(47.22,55.19) ; RR21.1 31.92,60.84 31.92,60.18 v11(32.17,59.93) 33.21,59.93 v11(34.24,60.95)
  IN1 w0.095: v7(172.86,18.83) 172.86,18.76 172.57,18.47 170.57,18.47 170.18,18.86 169.88,18.86 169.72,19.02 158.07,19.02 157.26,18.21 154.45,18.21 152.59,16.35 149.2,16.35 v7(149.13,16.43)
  GND1 w0.102: v1(47.22,55.19) 46.93,55.48 v3(46.93,55.58)
  GND3 w0.102: v3(46.93,55.58) 46.93,55.66 46.62,55.96 v4(46.46,55.96)
  vias: v3(42.78,59.29) v4(42.77,58.95) v7(32.02,61.22) v7(32.3,61.22) v9(42.58,59.02)
+LCDVDD_IN+: length 184.5
  TOP w0.102: v1(48.17,55.28) 51.01,55.28 52.09,54.2 52.09,51.04 51.69,50.64 51.14,50.64 50.81,50.31 50.81,48.82 49.58,47.58 49.58,45.27 49.93,44.91 50.97,44.91 52.21,43.67 52.21,41.43 53.71,39.93 62.55,39.93 63.53,38.95 64.56,38.95 65.67,37.83 72.87,37.83 75.25,35.46 75.25,32.51 76.77,30.99 80.28,30.99 80.85,30.43 80.85,26.26 80.84,26.22 80.77,26.02 80.77,26.02 80.46,24.86 77.65,22.04 77.65,20.48 78.69,19.43 78.69,17.48 80.39,15.79 81.66,15.79 94.51,2.93 128.29,2.93 129.55,4.19 129.55,7.11 130.64,8.19 131.55,8.19 131.87,8.51 131.87,11.84 132.64,12.62 138.58,12.62 139.46,13.5 144.36,13.5 145.18,12.68 146.06,12.68 147.92,14.54 147.92,16.06 v2(147.97,16.11) 148.7,16.83 v7(149.12,16.83)
  IN1 w0.095: v7(149.12,16.83) 149.25,16.83 149.37,16.71 152.44,16.71 154.3,18.57 157.11,18.57 157.92,19.37 169.86,19.37 170.02,19.21 170.33,19.21 170.71,18.83 v7(172.36,18.83)
  GND1 w0.102: v1(48.17,55.28) 48.27,55.38 48.27,55.93 v3(48.19,56.01)
  GND3 w0.102: v3(48.19,56.01) 48.06,55.88 v4(48.06,55.09)
  BOTTOM w0.102: v4(48.06,55.09) 47.86,55.29 R97.1
+ODR_PWR:
  vias: v1(280.15,33.71) v1(280.16,33.4) v2(281.12,32.29) v3(280.48,33.54) v3(280.49,33.12) v3(285.05,33.24) v3(285.6,33.24) v4(284.9,33.56) v4(285.16,33.57) v4(285.46,33.56) v4(285.73,33.56)
+PECI_VREF: length 5.4
  TOP w0.102: RE147.2 11.05,18.37 v2(10.68,18.74)
  GND1 w0.254: v3(16.38,16.76) 16.7,16.44 v1(16.7,16.42)
  GND3 w0.254: v6(16.03,16.74) 16.36,16.74 v3(16.38,16.76)
  IN4 w0.508: v6(16.03,16.74) 15.37,16.74 v8(13.57,18.55)
+RTC_CELL_VBAT: length 0.6
  TOP w0.203: UE3.A2 23.9,10.07 v8(23.52,10.45)
+RTCBATT: length 1.4
  BOTTOM w0.102: JRTC1.1 252.88,4.65 v2(253.25,4.27)
+RTCVCC: length 407.7
  TOP w0.305: v8(21.43,5.22) 21.46,5.25 21.46,6.7 21.54,6.77 RE137.2
  TOP w0.508: v8(21.43,5.22) 21.43,3.93 21.77,3.59 23.24,3.59 25.1,1.73 26.09,1.73 v8(26.11,1.71) 26.48,1.71 26.54,1.65 32.96,1.65 35.85,4.55 35.85,5.63 36.53,6.31 36.53,8.75 41.68,13.9 47.43,13.9 49.62,11.71 52.14,11.71 54.29,13.85 v7(54.29,14.22) ; RC68.2 RC78.2 v2(134.51,36.75) 135.08,36.75 v8(135.13,36.81)
  IN1 w0.508: v9(134.91,40.19) 134.64,39.91 134.64,39.79 134.61,39.77 134.61,39.34 134.64,39.32 134.64,38.05 135.15,37.54 135.15,36.82 v8(135.13,36.81) ; v8(77.54,19.36) 77.54,17.81 76.85,17.13 71.97,17.13 71.08,16.24 71.08,14.11 68.37,11.4 66.67,11.4 66.22,11.85 66.22,12.98 65.43,13.76 62.48,13.76 61.66,12.95 55.71,12.95 54.44,14.22 v7(54.29,14.22) ; v9(168.02,17.13) 161.47,17.13 161.24,16.91 156.39,16.91 156.22,16.73 156.22,16.73 156.11,16.63 v8(156.02,16.63)
  GND1 w0.508: v9(168.02,17.13) 168.02,16.86 v3(168.27,16.61) ; v3(135.84,40.41) 135.14,40.41 v9(134.91,40.19) ; v1(278.63,62.49) v3(277.97,62.49)
  IN2 w0.508: v8(265.43,40.73) 265.69,40.98 265.69,46.21 270.63,51.16 272.58,51.16 273.09,51.67 273.09,57.31 277.43,61.65 277.43,61.96 v3(277.97,62.49) ; v3(143.21,37.21) 143.21,37.64 140.77,40.09 140.72,40.09 140.45,40.35 135.89,40.35 v3(135.84,40.41) 135.63,40.62 135.63,41.4 133.24,43.79 132.32,43.79 v3(132.26,43.73)
  IN3 w0.508: v8(21.43,5.22) 21.43,4.57 22.02,3.98 25.8,3.98 26.1,4.27 26.1,9.03 26.74,9.66 26.74,10.98 v3(26.58,11.13)
  GND3 w0.254: v3(126.58,50.44) 126.58,50.44 126.84,50.7 v4(126.84,50.73)
  GND3 w0.508: v3(168.27,16.61) 168.53,16.5 v6(168.57,16.4)
  IN4 w0.508: 143.66,36.27 145.87,36.27 146.38,36.78 146.38,38 ; v6(168.57,16.4) 168.78,16.19 170.55,16.19 170.97,16.61 170.97,17.66 171.25,17.94 171.74,17.94 172.78,16.9 174.11,16.9 174.49,17.28 177.01,17.28 181.4,12.89 182.55,12.89 184,11.44 185.27,11.44 187.92,8.79 195.24,8.79 195.41,8.96 199.53,8.96 201.31,10.75 203.22,11.25 205.67,11.25 207.41,12.99 208.57,12.99 210.95,15.37 219.61,15.37 219.93,15.05 v5(220.42,15.05) 224.57,15.05 227.57,12.05 230.85,12.05 232.58,10.32 245.74,10.32 246.25,10.83 247.5,10.83 247.75,11.08 252.36,11.08 v5(252.71,11.42) 253.58,12.29 253.77,12.29 258.64,17.16 260.52,17.16 263.49,20.14 263.49,24.06 265.12,25.69 265.12,26.85 265.69,27.42 265.69,28.28 267.11,29.7 267.11,30.92 265.4,32.63 265.4,40.7 v8(265.43,40.73)
  BOTTOM w0.178: UCPU1.BB14 129.38,43.72 v8(129.38,43.11)
  BOTTOM w0.381: v8(26.11,1.71) 26.11,6.32 25.63,6.8 RE184.1
  BOTTOM w0.508: 24.96,12.4 RE142.2 ; 145.37,30.42 145.38,30.43 145.38,32.2 ; 145.37,30.42 147.28,30.42 148.15,29.55 148.15,28.32 151.42,25.04 151.42,17.85 151.93,17.34 153.08,17.34 154.53,15.89 155.45,15.89 156,16.44 156,16.6 v8(156.02,16.63) ; 145.37,30.42 140.16,30.42 138.62,31.95 134.48,31.95 133.11,33.32 85.1,33.32 82.23,30.45 82.23,22.21 79.38,19.36 v8(77.54,19.36) ; v5(252.71,11.42) 253.53,10.6 253.53,9.18 253.02,8.67 RTCR2.2 253.25,8.2 253.68,8.2 253.89,8 RTCR1.1 ; CH3.1 219.87,14.5 v5(220.42,15.05)
  vias: v1(131.67,43.7) v1(131.67,43.43) v4(25.96,11.24) v4(26.07,11.01) v5(145.28,32.86) v5(145.49,32.66) v5(145.66,38.21) v5(146.18,38.21) v6(143.06,36.89) v6(143.34,36.87) v9(126.03,50.27) v9(126.29,50.27)
+SD_VDD2: length 2.3
  BOTTOM w0.102: v2(293.92,32.18) 293.73,32.37 v4(293.73,34.41)
  vias: v3(284.63,34.07) v3(285.08,34.32) v3(293.82,35.22) v3(293.79,34.77) v4(284.95,34.01) v4(285.21,34.02) v4(285.47,34) v4(285.73,34.01) v4(294.16,35.69) v4(294.16,35.42) v4(294.16,35.15) v8(295.18,34.21) v8(295.19,33.6)
+TPM_LPM: length 1.8
  IN4 w0.508: v5(164.42,15.72) 165.79,15.72 v5(166.11,16.03)
  vias: v2(168.14,16.33)
+TPM_VSB: length 4.9
  BOTTOM w0.095: C1081.1 167.83,12.57 v2(168.04,12.77)
  BOTTOM w0.254: C1081.1 168.54,11.91 168.77,12.14 U7.1
  BOTTOM w0.508: RC382.2 167.43,10.81 166.94,11.3 C1082.1 167.12,11.53 167.5,11.91 C1081.1
+V_DDR_REF_CA: length 10.9
  TOP w0.508: v7(100.47,38.2) 99.9,37.63 CD79.1 99.9,36.4 RD10.1
  IN1 w0.508: v8(99.7,45.75) 100.47,44.98 v7(100.47,38.2)
  BOTTOM w0.254: v8(99.7,45.75) 99.7,45.41 99.66,45.37 99.66,45.21 UCPU1.AY67
+V_DDR_REFA_R: length 15.5
  TOP w0.508: v7(89.44,34.87) RD15.1 89.33,34.85 CD80.1
  IN1 w0.508: v7(89.44,34.87) 90.93,36.35 91.25,36.35 96.58,41.67 96.58,42.05 97.47,42.94 97.47,43.49 97.7,43.73 97.7,44.52 98.08,44.9 v8(98.08,44.91)
  BOTTOM w0.254: v8(98.08,44.91) 98.36,44.64 UCPU1.AY68
+V_DDR_REFB_R: length 15
  TOP w0.102: RD16.1 v2(93.15,34.9)
  TOP w0.508: v7(91.17,34.9) 92.07,34.9 RD16.1
  IN1 w0.508: v8(98.72,44.1) 98.72,43.31 98.48,43.07 98.48,42.39 98.11,42.02 97.91,41.82 97.59,41.5 97.59,41.25 91.23,34.9 v7(91.17,34.9)
  BOTTOM w0.254: v8(98.72,44.1) 98.86,44.24 UCPU1.BA67
+VR_CAP: length 15.9
  TOP w0.254: v8(25.67,16.49) 25.59,16.42 UE3.J1
  TOP w0.508: CE64.1 27.05,16.78 26.76,16.49 v8(25.67,16.49)
  GND1 w0.254: v1(17.5,11.61) 17.44,11.68 v3(17.44,12)
  GND3 w0.254: v6(17.79,11.94) 17.49,11.94 v3(17.44,12)
  IN4 w0.254: v6(17.79,11.94) 18.53,11.94 19.13,11.35 20.07,11.35 20.09,11.36 20.29,11.36 20.77,11.84 20.77,13.65 22.16,15.04 22.47,15.04 22.87,15.45 23.88,15.45 24.72,16.29 25.47,16.29 v8(25.67,16.49)
  BOTTOM w0.102: v8(25.67,16.49) 25.64,16.49 v2(25.07,15.91)
+VREFCA: length 104.8
  TOP w0.254: UD43.H4 140.16,20.9 v8(139.84,21.23) ; v8(124.92,21.23) 124.59,20.9 UD44.H4 ; UD42.H4 89.16,20.89 v8(88.83,21.22) ; v8(105.01,21.23) 104.68,20.9 UD41.H4
  TOP w0.508: v8(89.17,16.52) 88.98,16.33 CD78.1 ; RD10.2 98.97,36.36 RD9.2 RD11.1 100.23,35.53 102.91,32.85 114.88,32.85 115.36,32.37 115.36,28.53 114.97,28.15 114.21,28.15 112.5,26.44 112.5,24.91 111.55,23.96 111.55,19.9 111.16,19.51 111.16,17.51 v8(109.75,16.09) 110,15.85 CD76.1
  BOTTOM w0.508: 105.43,17.06 105.43,17.64 104.68,18.39 104.68,20.69 104.97,20.97 104.97,21.12 105.01,21.16 v8(105.01,21.23) ; 105.43,17.06 105.5,16.98 108.86,16.98 v8(109.75,16.09) 110.31,15.54 114.06,15.54 114.66,16.13 v2(116.93,16.13) 118.7,16.13 120.87,18.3 121.97,18.3 122.34,17.93 124.25,17.93 ; 105.43,17.06 105.34,16.97 103.47,16.97 103.42,17.02 103.4,17.02 103.37,17.05 91.92,17.05 91.65,17.32 91.56,17.41 89.68,17.41 89.17,16.9 v8(89.17,16.52) ; 138.53,19.45 137.48,19.45 136.41,18.38 130.24,18.38 129.07,17.22 126.97,17.22 126.72,16.97 ; 138.53,19.45 139.8,19.45 140.74,18.51 140.74,16 140.66,15.92 ; 138.53,19.45 138.53,20.74 139.02,21.23 v8(139.84,21.23)
+VREFDQ_A: length 33.5
  TOP w0.254: v8(105.01,26.03) 105.33,26.35 UD41.J11 ; v8(89.49,26.83) 89.49,26.75 UD42.J11
  TOP w0.381: v8(89.82,29.1) 90.08,29.36 90.08,30.08 CD37.1
  TOP w0.508: v8(104.79,30.98) 105.2,30.57 CD35.1 ; RD15.2 89.34,33.01 RD13.2 88.51,33 RD17.1 88.46,32.04 v2(89.01,31.49) 89.81,31.49 90.32,30.98 CD37.1
  IN1 w0.508: v8(105.01,26.03) 105.01,27.41 104.79,27.63 v8(104.79,30.98)
  BOTTOM w0.381: v8(89.49,26.83) 89.84,26.83 90.5,27.49 90.5,28.69 90.09,29.1 v8(89.82,29.1)
  BOTTOM w0.508: v8(104.79,30.98) 91.32,30.98 89.82,29.47 v8(89.82,29.1)
+VREFDQ_B: length 66.1
  TOP w0.254: UD44.J11 125.24,26.5 v8(125.57,26.83) ; UD43.J11 140.81,26.5 v8(141.14,26.83)
  TOP w0.508: v8(140.81,28.84) CD75.1 ; RD18.1 93.26,33.12 95.06,34.92 97.77,34.92 v8(98.19,35.34) ; RD18.1 RD14.2 ; RD18.1 RD16.2 ; v8(125.28,28.71) 125.24,28.75 CD77.1 125.24,31.44 v2(124.04,32.64) 122.97,33.71 v8(122.97,35.53)
  BOTTOM w0.508: v8(122.97,35.53) 122.78,35.34 v8(98.19,35.34) ; v8(125.57,26.83) 126.01,27.26 126.01,28.2 125.5,28.71 v8(125.28,28.71) 125.28,29.24 126.36,30.32 137.23,30.32 138.72,28.82 140.8,28.82 v8(140.81,28.84) 141.58,28.08 141.58,27.46 141.14,27.02 v8(141.14,26.83)
AC1_DISC#: length 71.9
  TOP w0.095: v1(50.41,12.32) 50.7,12.32 51.7,13.33 PR201.1 ; v7(41.77,13.21) 41.6,13.21 37.23,8.84 v2(37.23,8.66) PR123.1
  TOP w0.127: U19.G11 18.48,27.9 18.14,27.56 18.14,25.8 v1(18.45,25.48)
  IN1 w0.076: v1(50.41,12.32) 50.2,12.53 49.93,12.53 49.36,13.1 41.88,13.1 v7(41.77,13.21) 41.41,13.21 40.16,14.47 37.73,14.47 36.64,15.55 v9(34.56,15.55)
  GND1 w0.095: v3(34.56,16.19) v9(34.56,15.55) ; v1(18.45,25.48) v3(18.71,25.74) ; v1(50.41,12.32) v3(51.21,12.32)
  IN2 w0.064: v3(34.56,16.19) 34.56,16.26 32.58,18.23 31.65,18.23 30.54,19.34 29.43,19.34 28.58,20.19 27.61,20.19 27.1,20.69 27.1,21.8 23.67,25.24 19.21,25.24 v3(18.71,25.74)
  GND3 w0.095: v3(51.21,12.32) 51.25,12.32 v6(51.54,12.03)
  IN4 w0.076: v6(51.54,12.03) 51.54,11.77 52.32,10.99 59.7,10.99 v5(59.81,11.09)
  BOTTOM w0.095: PR321.1 58.74,3.82 58.74,4.22 58.9,4.39 59.82,4.39 60.09,4.66 60.09,5.23 59.09,6.22 59.09,10.26 59.81,10.98 v5(59.81,11.09)
AC2_DISC#: length 61.4
  TOP w0.095: v1(30.97,28.67) 30.55,28.67 30.27,28.95 30.27,29.65 31.02,30.41 U20.G11 ; v7(48.27,4.77) 48.27,4.85 PR136.1 PR144.1 50.2,5.29 50.58,4.91 v2(51.11,4.91) 54.76,4.91 57.71,1.96 v1(57.72,1.96)
  IN1 w0.076: v9(32.98,4.51) 33.75,3.74 38.5,3.74 39.27,4.51 42.04,4.51 42.6,3.96 43.25,3.96 44.59,5.29 47.75,5.29 v7(48.27,4.77)
  GND1 w0.095: v3(58.05,1.49) 58.03,1.51 58.03,1.66 v1(57.72,1.96) ; v3(33.22,5.05) 32.98,4.81 v9(32.98,4.51) ; v1(30.97,28.67) 30.85,28.55 30.85,28.53 v3(30.72,28.4)
  IN3 w0.064: v3(33.22,5.05) 32.32,5.95 32.32,7.42 30.82,8.92 30.82,9.68 31.19,10.04 31.19,11.2 30.82,11.57 30.82,14.67 31.39,15.24 31.39,17.81 31.15,18.05 31.15,20.08 29.68,21.55 29.68,25.53 30.72,26.57 v3(30.72,28.4)
  GND3 w0.095: v4(57.7,2.49) 57.7,2.01 58.03,1.68 58.03,1.51 v3(58.05,1.49)
  BOTTOM w0.095: PR343.1 57.7,3.61 v4(57.7,2.49)
AC3_DISC#: length 270.6
  TOP w0.095: v1(70.15,5.22) 70.15,5.06 70.15,4.48 72.76,1.87 v7(74.74,1.87)
  IN1 w0.076: v7(74.74,1.87) 77.54,1.87 81.41,5.75 114.76,5.75 116.04,7.02 116.35,7.02 118.68,9.36 138.46,9.36 139.1,10 144.23,10 144.63,9.61 149.14,9.61 154.04,4.71 159.06,4.71 160.4,6.05 163.72,6.05 164.89,7.22 166.97,7.22 168.36,5.84 v9(175.91,5.84) 182.62,5.84 184.45,4.01 224.85,4.01 226.82,2.03 266.03,2.03 266.2,2.03 266.2,2.03 267.5,2.03 268.35,2.89 272.44,2.89 273.66,4.11 274.82,4.11 275.25,4.54 278.9,4.54 279.33,4.1 286.87,4.1 288.81,6.04 288.81,8.52 289.09,8.8 289.09,9.8 289.32,10.03 289.32,11.57 288.03,12.86 288.03,14.28 v9(290.3,16.55)
  GND1 w0.095: v3(70.46,5.59) 70.15,5.28 v1(70.15,5.22) ; v9(290.3,16.55) 290.57,16.82 v3(290.7,16.82) ; v9(175.91,5.84) 175.91,5.56 v3(175.76,5.42)
  GND3 w0.095: v4(290.37,16.94) 290.42,16.89 290.43,16.89 290.5,16.83 290.69,16.83 v3(290.7,16.82) ; v4(70.59,6.23) 70.59,5.72 v3(70.46,5.59) ; v4(175.71,4.94) 175.71,5.37 v3(175.76,5.42)
  BOTTOM w0.095: PR196.1 67.23,10.43 68.89,10.43 69.03,10.29 69.03,7.2 PR344.1 68.75,6.48 68.82,6.48 69.39,5.91 70.27,5.91 v4(70.59,6.23) ; v4(290.37,16.94) 290.26,16.83 U21.G11 ; v4(175.71,4.94) 178.3,4.94 178.99,5.63 178.99,11.47 178.7,11.76 178.7,13.27 179,13.57 179.33,13.57 179.69,13.93 v2(180.41,13.93) 180.71,13.93 181.19,13.44 PR278.1
AC_DIS: length 58.5
  TOP w0.095: v7(35.17,6.88) 35.25,6.96 35.25,10.41 38.08,13.25 38.08,14.15 38.71,14.78 v1(38.71,15.56)
  IN1 w0.076: v7(35.17,6.88) 34.67,6.38 33.24,6.38 32.71,6.92 31.29,6.92 30.17,8.03 27.66,8.03 27.39,8.3 26.35,8.3 26.04,8.62 26.04,9.33 26.4,9.69 26.4,9.98 26.19,10.19 25.39,10.19 25.24,10.04 22.39,10.04 21.38,11.06 21.1,11.06 20.7,11.45 v7(20.7,11.61)
  GND1 w0.095: v3(38.71,14.98) v1(38.71,15.56)
  IN3 w0.064: v3(38.71,14.98) 39.19,14.5 39.19,13.98 40.33,12.84 47.27,12.84 49.05,11.05 53.8,11.05 56.2,13.45 60.36,13.45 60.61,13.7 v3(60.61,14.29)
  GND3 w0.095: v4(60.48,14.6) 60.48,14.6 60.48,14.42 v3(60.61,14.29)
  BOTTOM w0.095: PR340.1 60.86,17.69 v2(61.04,17.86)
  BOTTOM w0.254: v4(60.48,14.6) 60.48,14.6 PQ300.2 60.48,16.41 PR340.1
AC_DIS#: length 24.6
  TOP w0.095: v2(50.79,13.26) 50.98,13.45 v7(50.98,13.69) 51.02,13.73 51.02,16.02 51.74,16.75 52.67,16.75 PR192.2 PR202.1 v1(52.69,17.66) PR230.2
  IN1 w0.076: v9(51.93,12.71) 51.93,12.74 v7(50.98,13.69)
  GND1 w0.095: v9(51.93,12.71) 52.03,12.61 v3(52.03,12.33) ; v3(52.36,17.53) 52.39,17.53 52.52,17.66 v1(52.69,17.66)
  GND3 w0.095: v6(52.36,12.3) 52.06,12.3 v3(52.03,12.33) ; v3(52.36,17.53) 52.39,17.51 v4(52.71,17.51)
  IN4 w0.076: v5(61.87,10.43) 61.09,11.2 60.57,11.2 60.38,11.39 59.4,11.39 59.21,11.2 53.46,11.2 v6(52.36,12.3)
  BOTTOM w0.095: v4(52.71,17.51) 52.05,17.51 51.63,17.93 PC140.1 51.6,18.34 51.55,18.39 PR174.2 ; PR200.2 63.24,9.99 PR170.2 62.78,10.44 61.88,10.44 v5(61.87,10.43)
AC_DISC#: length 51.3
  TOP w0.095: v8(14.71,12.82) UE3.E13
  IN1 w0.076: v7(53.62,18.59) 53.29,18.92 39.57,18.92 38.99,19.5 38.99,19.98 37.57,21.39 37.57,24.06 37.06,24.57 32.23,24.57 32.15,24.65 v9(31.96,24.65)
  GND1 w0.095: v3(31.61,24.63) 31.94,24.63 v9(31.96,24.65)
  GND3 w0.095: v4(31.59,24.26) 31.59,24.29 31.65,24.35 31.65,24.59 v3(31.61,24.63)
  BOTTOM w0.095: v4(31.59,24.26) 31.59,24.04 31.32,23.77 29.73,23.77 v2(29.03,23.06) 28.6,22.64 27.07,22.64 26.76,22.94 26.07,22.94 24.29,21.16 22.34,21.16 21.24,20.06 18.6,20.06 14.95,16.41 14.95,13.55 14.71,13.3 v8(14.71,12.82)
AC_DISC_OUT#: length 22.1
  TOP w0.095: PR332.1 62.33,7.15 61.94,7.54 61.94,8.97 v7(61.85,9.06) ; PR208.2 52.2,18.94 52.2,18.12 51.73,17.65 v2(51.73,17.47) 51.73,17.08 50.79,16.14 50.79,13.95 50.56,13.72 v7(50.56,13.62)
  IN1 w0.076: v7(50.56,13.62) 50.61,13.62 51.26,12.97 51.26,12.97 53.35,10.88 59.64,10.88 61.12,9.4 61.51,9.4 v7(61.85,9.06)
AC_PRESENT: length 159.2
  TOP w0.095: v1(129.91,41.93) 129.93,41.93 130.35,41.51 RC82.1 ; UE3.K8 19.1,17.23 19.51,17.63 19.51,20.1 19.09,20.52 v7(19.09,21.17)
  IN1 w0.076: v7(19.09,21.17) 19.13,21.21 19.4,21.21 19.62,21.42 27.32,21.42 v9(27.72,21.82)
  GND1 w0.095: v9(27.72,21.82) 28.21,21.82 v3(28.35,21.69) ; v1(129.91,41.93) 129.78,42.07 v3(129.58,42.07)
  IN2 w0.064: v3(28.35,21.69) 28.35,22.17 29.08,22.9 31.85,22.9 32.29,23.34 35.08,23.34 36.21,22.22 36.21,20.05 39.78,16.48 42.53,16.48 45.27,13.74 52.69,13.74 55.27,11.16 57.23,11.16 57.64,10.75 59.36,10.75 60.44,9.68 70.5,9.68 71.21,10.39 74.89,10.39 75.35,10.85 76.66,10.85 79.27,13.46 79.27,20.55 78.53,21.29 78.12,21.29 v8(78.05,21.23)
  GND3 w0.095: v3(129.58,42.07) 129.46,42.19 v4(129.22,42.19)
  IN4 w0.076: v8(78.05,21.23) 78.32,21.5 78.32,23.65 80.28,25.61 80.28,29.49 80.79,30 80.79,30.3 83.74,33.25 101.94,33.25 102.54,33.85 106.06,33.85 106.35,33.56 130.3,33.56 131.38,34.64 131.38,40.63 130.43,41.58 129.83,41.58 v4(129.22,42.19)
  BOTTOM w0.076: UCPU1.AY15 128.96,44.67 128.6,44.31 128.6,42.88 129.22,42.25 v4(129.22,42.19)
ACAV_IN: length 63.7
  GND1 w0.095: v1(19.9,11.61) 19.9,11.44 v3(19.72,11.26)
  GND3 w0.095: v6(20.23,11.01) 19.98,11.26 v3(19.72,11.26)
  IN4 w0.076: v6(20.23,11.01) 20.23,10.8 20.39,10.65 21.8,10.65 22.26,11.11 22.26,11.26 22.56,11.56 23.07,11.56 23.59,11.04 23.7,11.04 24.17,10.58 24.17,9.56 24.5,9.23 26.32,9.23 26.95,8.6 34.42,8.6 35.15,7.88 38.83,7.88 39.55,8.6 46.2,8.6 46.9,7.9 49.68,7.9 51.02,6.56 58.82,6.56 58.89,6.63 65,6.63 65.72,5.91 66.48,5.91 66.88,5.51 69.12,5.51 v5(69.14,5.53)
  BOTTOM w0.095: v5(69.14,5.53) 68.82,5.21 68.82,3.11 68.71,2.99 PR345.2 68.18,2.8 67.1,2.8 66.92,2.62 66.92,2.17 66.52,1.77 63.79,1.77 PR331.1
ACAV_IN1: length 20.7
  TOP w0.203: v1(61.51,10.14) 61.51,10.4 61.71,10.61 PU300.24
  GND1 w0.203: v3(61.41,10.82) 61.55,10.69 61.55,10.21 61.51,10.17 v1(61.51,10.14)
  GND3 w0.203: v4(60.74,11.49) v3(61.41,10.82)
  IN4 w0.229: v5(66.09,5.44) 65.95,5.58 64.96,5.58 64.41,6.14 59.68,6.14 v5(59.64,6.1)
  BOTTOM w0.203: v4(60.74,11.49) 60.75,11.49 PR319.2 61.65,13.2 PQ300.1
  BOTTOM w0.254: v5(59.64,6.1) 59.64,6.95 v2(59.61,6.98) 59.43,7.16 59.43,10.17 60.74,11.48 v4(60.74,11.49) ; v5(66.09,5.44) 66.46,5.07 68.03,5.07 PR346.1
ACAV_IN_NB: length 1.8
  TOP w0.095: UE3.N6 20.7,20.61 21.06,20.96 T52.1
ADDR: length 8.7
  TOP w0.095: v2(264.54,21.06) 264.02,21.58 264.02,21.88 R48.2
  TOP w0.203: 266.58,24.94 266.65,24.88 U30.3
  TOP w0.381: 266.58,24.94 266.37,25.15 264.54,25.15 263.56,24.17 R53.1 263.34,24.09 263.05,23.8 262.96,23.59 262.96,22.6 263.23,22.33 R48.2
AK52: length 1.4
  GND1 w0.305: v3(107.86,51.47) 108.06,51.68 v1(108.06,51.92)
  GND3 w0.305: v3(107.86,51.47) 108.05,51.28 v4(108.24,51.28)
  BOTTOM w0.305: v4(108.24,51.28) 108.24,51.05 UCPU1.AK52
ALW_PWRGD_3V_5V: length 62
  TOP w0.508: v8(38.99,23.11) 38.68,22.8 38.36,22.8 v11(38.06,22.51) 37.09,21.53 37.09,19.5 37.34,19.24 37.34,15.05 36.67,14.38 36.67,13.34 34.18,10.85 34.18,7.56 33.85,7.23 v8(33.85,6.92) ; v8(43.98,3.64) 44.38,4.04 51.53,4.04 PR151.1
  IN2 w0.508: v8(38.99,23.11) 38.99,23.06 39.5,22.55 39.5,21.53 39.99,21.04 42.91,21.04 44.63,22.76 44.63,23.44 45.52,24.33 45.52,25.31 46.32,26.12 50.15,26.12 50.41,25.86 v3(50.68,25.86)
  GND3 w0.508: v4(50.29,25.23) 50.29,25.47 v3(50.68,25.86)
  IN4 w0.254: v5(46.85,27.7) 46.85,26.8 47.3,26.36 49.42,26.36 50.29,25.49 v4(50.29,25.23)
  BOTTOM w0.254: v8(38.99,23.11) 38.99,23.04 38.66,22.71 PR506.1
  BOTTOM w0.508: v8(43.98,3.64) 43.27,4.35 PQ126.2 42.04,4.35 41.22,5.18 35.5,5.18 34.83,5.85 34.83,6.45 34.36,6.92 v8(33.85,6.92)
ALWON: length 40.6
  GND1 w0.095: v1(21.5,10.01) 21.5,9.96 v3(21.2,9.66)
  IN3 w0.064: v3(21.2,9.66) 21.47,9.94 21.47,11.6 22.86,12.99 24.13,12.99 24.91,13.76 24.91,14.38 26.46,15.94 26.46,18.34 25.1,19.7 25.1,20.92 25.29,21.11 26.08,21.11 v3(26.38,21.41)
  GND3 w0.095: v4(26.71,22.56) 26.71,21.91 26.38,21.58 v3(26.38,21.41)
  IN4 w0.076: v5(46.73,25.17) 46.59,25.17 46.14,24.72 45.25,24.72 44.36,23.83 43.73,23.83 43.27,23.37 39.62,23.37 38.79,24.2 37.78,24.2 v5(37.72,24.26)
  BOTTOM w0.095: v4(26.71,22.56) 26.86,22.41 28.84,22.41 29.98,23.55 31.42,23.55 31.93,24.06 v2(32.04,24.06) 34.56,24.06 35.48,24.98 PR510.1 35.96,24.95 36.39,24.52 37.46,24.52 v5(37.72,24.26)
AMP_ADDR_SEL: length 6.4
  TOP w0.095: U6.18 267.22,10.25 267.04,10.42 v2(267.04,12.52) 267.04,13.34 RA38.1 268.31,14.61 RA30.2
AMP_I2C_CLK: length 58.9
  TOP w0.095: v1(271.39,14.95) 271.38,14.94 RA33.2
  GND1 w0.095: v3(271.83,15.18) 271.77,15.12 271.67,15.12 271.5,14.95 v1(271.39,14.95)
  GND3 w0.095: v3(271.83,15.18) 272.24,15.59 v6(272.28,15.59)
  IN4 w0.076: v4(270.79,62.53) 270.59,62.33 270.07,62.33 267.4,59.65 267.4,55.28 267.4,55.27 267.4,55.08 268.2,54.27 268.2,49.92 267.42,49.14 267.42,42.01 273.23,36.2 273.23,33.77 275.68,31.32 275.68,25.16 274.97,24.44 274.97,18 273.3,16.33 272.65,16.33 272.34,16.02 272.34,15.65 v6(272.28,15.59)
  BOTTOM w0.095: U5.7 273.02,62.08 272.93,61.99 272.52,61.99 272.32,62.2 v10(271.9,62.2) 271.12,62.2 v4(270.79,62.53)
AMP_I2C_CLK_R: length 29.6
  TOP w0.095: U6.8 271.94,13.35 RA33.1 271.45,13.91 271.93,14.4 RA26.1
  GND1 w0.095: v3(274.13,15.37) 274.01,15.49 273.25,15.49 273.12,15.63 v1(272.07,15.63) ; v1(289.19,6.47) v3(289.19,6.93)
  IN3 w0.064: v3(289.19,6.93) 289.4,6.93 289.5,7.03 289.5,7.37 289.75,7.63 290.25,7.63 290.65,8.03 290.65,10.29 287.72,13.22 284.6,13.22 284.01,13.81 276.62,13.81 274.87,15.56 274.32,15.56 v3(274.13,15.37)
AMP_I2C_DAT: length 59.1
  TOP w0.095: RA27.2 272.84,14.86 v1(272.79,14.9)
  GND1 w0.095: v3(272.96,15.18) 272.96,15.07 v1(272.79,14.9)
  GND3 w0.095: v6(272.82,15.63) 272.84,15.62 272.84,15.31 v3(272.96,15.18)
  IN4 w0.076: v6(272.82,15.63) 272.62,15.63 272.55,15.71 272.55,15.94 272.74,16.13 273.39,16.13 275.17,17.91 275.17,24.36 275.89,25.07 275.89,31.4 273.44,33.85 273.44,36.28 267.62,42.1 267.62,49.05 268.4,49.83 268.4,54.36 267.6,55.16 267.6,55.36 267.6,59.57 270.16,62.12 270.85,62.12 271.03,61.94 271.03,61.73 270.94,61.64 v5(270.79,61.64)
  BOTTOM w0.095: U5.6 273.02,61.68 272.93,61.77 272.43,61.77 272.22,61.97 271.12,61.97 v5(270.79,61.64)
AMP_I2C_DAT_R: length 29.4
  TOP w0.095: U6.7 272.34,13.41 RA27.1 272.72,13.91 272.35,14.28 272.35,15.27 RA25.1 272.88,15.8 273.27,15.8 v1(273.34,15.87)
  GND1 w0.095: v1(273.34,15.87) 273.42,15.8 274,15.8 v3(274.13,15.93) ; v1(290.07,6.47) v3(290.07,6.88)
  IN3 w0.064: v3(274.13,15.93) 274.3,15.75 274.95,15.75 276.7,14 284.09,14 284.68,13.41 287.8,13.41 290.84,10.37 290.84,7.95 290.33,7.44 289.83,7.44 289.69,7.29 289.69,7.06 289.87,6.88 v3(290.07,6.88)
AMP_I2S_BCLK: length 3.6
  BOTTOM w0.095: U5.10 272.99,63.28 272.16,64.1 v2(272.16,64.66) 272.16,64.7 271.58,65.28 RA19.1
AMP_I2S_BCLK_R: length 66
  TOP w0.095: v1(270.3,16.17) 270.3,16.14 270.28,16.12 v2(270.28,14.33) 270.28,13.85 271.14,13 U6.10
  GND1 w0.095: v1(270.3,16.17) 269.85,16.62 v3(269.77,16.62)
  GND3 w0.095: v6(270.09,17.11) 269.77,16.79 v3(269.77,16.62)
  IN4 w0.076: v6(270.09,17.11) 270.83,17.85 271.29,17.85 271.63,18.2 271.63,21.36 271.88,21.61 271.88,25.81 273.59,27.51 273.59,30.88 272.79,31.68 267.54,31.68 266.02,33.2 266.02,38.72 266.69,39.39 266.69,40.43 265.34,41.77 265.34,62.63 268.32,65.6 269.02,65.6 v5(269.33,65.28)
  BOTTOM w0.095: RA19.2 v5(269.33,65.28)
AMP_I2S_IN: length 5.1
  BOTTOM w0.095: U5.8 272.84,62.48 271.82,63.49 CA33.1 270.71,63.02 269.81,63.02 RA17.1
AMP_I2S_IN_R: length 64.5
  TOP w0.095: v1(269.42,15.8) 269.18,15.56 269.18,14.95 269.51,14.62 269.51,13.67 v2(269.32,13.48) 269.54,13.26 U6.14
  GND1 w0.095: v3(269.55,15.38) 269.55,15.67 v1(269.42,15.8)
  GND3 w0.095: v6(269.79,15.61) v3(269.55,15.38)
  IN4 w0.076: v6(269.79,15.61) 269.88,15.71 270.9,15.71 272.07,16.87 273.19,16.87 274.21,17.89 274.21,20.76 274.45,21.01 274.45,24.91 275.23,25.69 275.23,30.92 273.34,32.8 268.21,32.8 267.14,33.87 267.14,38.13 267.81,38.8 267.81,40.89 266.86,41.84 266.86,49.38 267.74,50.27 267.74,53.25 266.94,54.05 266.94,55.09 266.94,55.09 266.94,59.89 266.94,59.89 266.94,62.2 268.23,63.49 v5(268.43,63.49)
AMP_I2S_LRCK: length 5
  BOTTOM w0.095: U5.12 273.18,64.08 272.99,64.27 272.99,66.37 v2(272.14,67.22) 271.32,67.22 RA21.1
AMP_I2S_LRCK_R: length 69.4
  TOP w0.095: U6.11 270.74,12.72 270.74,13.08 269.95,13.86 269.95,14.92 v1(269.89,14.98)
  GND1 w0.095: v1(269.89,14.98) 269.19,14.98 v3(269.17,15)
  GND3 w0.095: v6(269.08,16.15) 269.08,15.09 v3(269.17,15)
  IN4 w0.076: v5(269.33,67.06) 268.92,66.66 268.49,66.66 265.14,63.31 265.14,41.69 266.48,40.35 266.48,39.47 265.82,38.8 265.82,33.12 267.46,31.48 272.67,31.48 273.37,30.77 273.37,29.5 271.68,27.8 271.68,23.05 269.67,21.04 269.09,21.04 267.59,19.53 267.59,17.29 268.04,16.85 268.71,16.85 268.92,16.63 268.92,16.3 v6(269.08,16.15)
  BOTTOM w0.095: RA21.2 v5(269.33,67.06)
AMP_I2S_MCLK: length 4.3
  BOTTOM w0.095: U5.11 273.14,63.68 272.51,64.3 272.51,65.71 v2(272.28,65.94) 272.05,66.17 RA20.1
AMP_I2S_MCLK_R: length 66.4
  TOP w0.095: U6.9 271.54,12.95 270.77,13.71 v2(270.77,15.74) v1(270.77,16.16)
  GND1 w0.095: v1(270.77,16.16) 270.77,16.84 v3(270.94,17.01)
  GND3 w0.095: v6(271.15,17.4) 270.94,17.19 v3(270.94,17.01)
  IN4 w0.076: v6(271.15,17.4) 271.6,17.4 272.09,17.88 272.09,21.17 272.65,21.73 272.65,22.37 273.33,23.05 273.33,24.92 274.26,25.85 274.26,27.54 274.46,27.74 274.46,30.72 273.04,32.14 267.73,32.14 266.48,33.39 266.48,38.53 267.15,39.2 267.15,40.62 265.87,41.9 265.87,62.24 268.37,64.74 269.35,64.74 269.74,65.12 269.74,65.77 v5(269.33,66.17)
  BOTTOM w0.095: RA20.2 v5(269.33,66.17)
