# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D24: length 39.9
  TOP w0.076: v8(87.27,27.79) 87.54,27.52 87.54,26.74 UD42.F11
  IN2 w0.095: v3(94.3,53.17) 93.93,53.55 91.17,53.55 89.98,52.36 89.98,51.66 82.92,44.59 82.92,32.38 86.81,28.5 86.81,28.25 v8(87.27,27.79)
  GND3 w0.152: v3(94.3,53.17) 94.37,53.1 94.37,52.77 v4(94.37,52.77)
  BOTTOM w0.076: UCPU1.AF70 97.45,53.07 97.14,53.38 94.98,53.38 v4(94.37,52.77)
DDR_A_D25: length 42.6
  TOP w0.152: v8(87.54,26.03) 87.54,25.95 UD42.F10
  IN2 w0.095: v8(87.54,26.03) 87.75,26.23 87.75,27.08 88.28,27.61 88.28,28.54 87.75,29.06 86.92,29.06 83.25,32.73 83.25,44.52 90.27,51.54 90.27,52.24 91.2,53.17 v3(93.07,53.17)
  GND3 w0.152: v3(93.07,53.17) v4(93.07,52.75)
  BOTTOM w0.076: UCPU1.AF68 98.56,53.3 97.77,53.3 97.45,53.61 v2(94.68,53.61) 94.32,53.61 93.46,52.75 v4(93.07,52.75)
DDR_A_D26: length 40.5
  TOP w0.152: UD42.D9 86.89,24.49 v8(86.89,24.42)
  IN2 w0.095: v8(86.89,24.42) 87.95,25.48 88.28,25.48 88.53,25.74 89.16,25.74 89.96,26.53 89.96,27.22 90.35,27.62 90.35,29.2 84.65,34.91 84.65,44.41 92.02,51.78 92.11,51.78 v3(92.11,51.79)
  GND3 w0.152: v4(92.47,51.77) 92.46,51.78 92.13,51.78 v3(92.11,51.79)
  BOTTOM w0.076: v4(92.47,51.77) 92.76,51.48 95.5,51.48 95.86,51.84 96.59,51.84 96.69,51.74 UCPU1.AH71
DDR_A_D27: length 44.4
  TOP w0.152: v8(87.92,23.5) 87.92,23.97 UD42.F8
  IN2 w0.095: v3(92.94,51.79) 93.2,51.53 93.2,50.39 90.9,48.09 89.63,48.09 85.66,44.13 85.66,35.44 91.26,29.84 91.26,27.24 90.95,26.92 90.95,25.42 89.49,23.96 88.38,23.96 v8(87.92,23.5)
  GND3 w0.152: v4(93.28,51.77) 93.26,51.79 92.95,51.79 v3(92.94,51.79)
  BOTTOM w0.076: UCPU1.AH68 98.88,52.51 98.72,52.68 97.81,52.68 97.7,52.64 97.5,52.64 97.3,52.7 97.21,52.7 97.17,52.68 96.92,52.59 96.62,52.45 93.92,52.45 v2(93.8,52.33) 93.28,51.82 v4(93.28,51.77)
DDR_A_D28: length 41.5
  TOP w0.152: v8(86.89,25.24) 86.89,25.31 UD42.E10
  IN2 w0.095: v3(94.91,53.17) 94.24,53.85 91.07,53.85 89.69,52.48 89.69,51.77 82.49,44.57 82.49,32.38 86.35,28.52 86.35,28.02 87.34,27.03 87.34,26.47 86.9,26.04 86.9,25.25 v8(86.89,25.24)
  GND3 w0.152: v4(95.04,52.76) 94.91,52.88 v3(94.91,53.17)
  BOTTOM w0.076: v4(95.04,52.76) 95.35,53.07 UCPU1.AF71
DDR_A_D29: length 42
  TOP w0.152: v8(86.89,26.83) 86.89,26.75 UD42.E11
  IN2 w0.095: v8(86.89,26.83) 86.89,26.93 86.55,27.26 85.69,27.26 85.43,27.52 85.43,28.34 82.18,31.59 82.18,44.69 89.41,51.91 89.41,52.6 89.42,52.61 89.42,52.62 90.94,54.15 94.38,54.15 94.9,53.63 95.55,53.63 v3(96.01,53.17)
  GND3 w0.152: v3(96.01,53.17) 96.3,52.87 v4(96.3,52.76)
  BOTTOM w0.076: UCPU1.AF69 98.11,52.85 97.77,52.85 97.67,52.81 97.52,52.81 97.38,52.85 97.37,52.85 97.32,52.86 97.18,52.86 97.15,52.85 97.14,52.85 96.93,52.78 96.32,52.78 v4(96.3,52.76)
DDR_A_D30: length 40.8
  TOP w0.152: UD42.E9 87.53,24.51 v8(87.53,24.42)
  IN2 w0.095: v3(91.94,50.55) 91.38,49.99 90.67,49.99 84.98,44.3 84.98,35.01 90.65,29.33 90.65,27.49 90.26,27.1 90.26,26.41 89.33,25.48 89.33,25.47 89.31,25.45 89.31,25.09 88.97,24.75 88.57,24.75 88.38,24.94 87.84,24.94 87.53,24.63 v8(87.53,24.42)
  GND3 w0.152: v3(91.94,50.55) 92.27,50.55 v4(92.29,50.57)
  BOTTOM w0.076: UCPU1.AH70 97.34,51.74 97.11,51.51 97.02,51.49 96.66,51.49 96.47,51.68 95.94,51.68 95.57,51.31 93.02,51.31 v4(92.29,50.57)
DDR_A_D31: length 40.7
  TOP w0.152: v8(88.19,24.42) 88.19,24.5 UD42.F9
  IN2 w0.095: v8(88.19,24.42) 88.25,24.37 89.18,24.37 89.65,24.84 89.65,25.37 90.57,26.28 90.57,26.97 90.96,27.36 90.96,29.51 85.28,35.19 85.28,44.18 89.57,48.47 90.71,48.47 92.77,50.52 v3(92.77,50.53)
  GND3 w0.152: v4(93.12,50.53) 93.12,50.54 92.77,50.54 v3(92.77,50.53)
  BOTTOM w0.076: v4(93.12,50.53) 93.72,51.13 95.63,51.13 96.02,51.51 96.34,51.51 96.53,51.32 97.1,51.32 97.11,51.33 97.64,51.33 98.05,51.74 UCPU1.AH69
DDR_A_D32: length 22.9
  TOP w0.152: UD41.B9 100.46,24.5 v8(100.46,24.43)
  IN3 w0.095: v8(100.46,24.43) 99.72,24.43 98.9,25.25 98.9,25.97 98.46,26.4 98.01,26.4 97.5,26.91 97.5,39.05 v8(98.39,39.95)
  BOTTOM w0.076: v8(98.39,39.95) 98.88,40.44 98.88,41.11 100.59,42.82 100.59,43.49 UCPU1.BB65
DDR_A_D33: length 24.6
  TOP w0.152: UD41.C11 101.75,26.74 v8(101.75,26.82)
  IN3 w0.095: v8(101.75,26.82) 101.21,27.36 101.21,29.27 101.45,29.51 101.45,34.66 101.35,34.75 100.91,34.75 100.82,34.85 100.82,35.04 100.91,35.13 101.35,35.13 101.45,35.23 101.45,35.42 101.35,35.51 100.91,35.51 100.82,35.61 100.82,35.8 100.91,35.9 101.35,35.9 101.45,35.99 101.45,36.18 101.35,36.28 100.87,36.28 100.78,36.37 100.78,36.56 100.87,36.66 101.35,36.66 101.45,36.75 101.45,36.94 101.35,37.04 100.91,37.04 100.82,37.13 100.82,38.16 v3(100.81,38.16)
  GND3 w0.152: v3(100.81,38.16) 100.81,38.49 v4(100.8,38.5)
  BOTTOM w0.076: UCPU1.AW65 101.32,45.54 101.61,45.26 101.61,44.44 101.58,44.35 101.58,44.21 101.61,44.07 101.61,44.07 101.65,43.96 101.65,43.87 101.54,43.55 101.12,43.13 101.12,42.6 100.73,42.21 100.73,40.51 100.58,40.36 v2(100.58,39) 100.58,38.74 v4(100.8,38.5)
DDR_A_D34: length 25.5
  TOP w0.152: v8(101.11,26.83) 101.11,26.75 UD41.B11
  IN3 w0.095: v3(100.84,39.5) 100.62,39.5 100.42,39.3 100.42,34.41 100.52,34.32 101.07,34.32 101.16,34.22 101.16,34.03 101.07,33.93 100.52,33.93 100.42,33.84 100.42,33.65 100.52,33.55 101.07,33.55 101.16,33.46 101.16,33.27 101.07,33.17 100.52,33.17 100.42,33.08 100.42,32.89 100.52,32.79 101.07,32.79 101.16,32.7 101.16,32.51 101.07,32.41 100.52,32.41 100.42,32.32 100.42,32.12 100.52,32.03 101.07,32.03 101.16,31.93 101.16,31.74 101.07,31.65 100.92,31.65 100.83,31.55 100.83,31.36 100.92,31.27 101.07,31.27 101.16,31.17 101.16,29.71 100.92,29.46 100.92,27.01 v8(101.11,26.83)
  GND3 w0.152: v3(100.84,39.5) 101.06,39.71 v4(101.06,39.76)
  BOTTOM w0.076: v4(101.06,39.76) 101.15,39.77 v2(101.65,40.26) 102.07,40.68 102.07,42.81 102.45,43.19 102.45,44.25 102.2,44.5 102.2,45.07 101.92,45.35 UCPU1.AW63
DDR_A_D35: length 24.8
  TOP w0.152: v8(101.13,23.29) 101.13,23.72 UD41.C8
  IN3 w0.095: v3(100.89,42.36) 101.58,41.66 101.58,40.13 101.67,40.05 101.67,39.22 102.02,38.87 102.02,30.21 102.57,29.67 102.57,24.66 101.93,24.02 101.47,24.02 101.12,23.67 101.12,23.29 v8(101.13,23.29)
  GND3 w0.152: v4(101.21,42.22) 101.07,42.36 v3(100.89,42.36)
  BOTTOM w0.076: UCPU1.AY63 101.77,44.75 101.77,44.41 101.74,44.32 101.74,44.23 101.81,43.99 101.81,43.84 101.71,43.52 101.71,43.39 101.37,43.05 101.37,42.38 v4(101.21,42.22)
DDR_A_D36: length 24.5
  TOP w0.152: UD41.B8 100.21,23.45 v8(100.15,23.45)
  IN3 w0.095: v8(100.15,23.45) 97.17,26.44 97.17,39.99 v8(98.4,41.22)
  BOTTOM w0.076: v8(98.4,41.22) 99.01,41.83 99.31,41.83 100.42,42.95 100.42,43.7 100.55,43.95 100.69,44.09 UCPU1.BA65
DDR_A_D37: length 24.5
  TOP w0.152: UD41.B10 100.78,25.59 100.46,25.27 v8(100.46,25.2)
  IN3 w0.095: v8(100.46,25.2) 100.4,25.2 98.99,26.61 98.99,35.75 98.29,36.46 97.95,36.46 97.86,36.55 97.86,36.85 97.95,36.95 98.52,36.95 98.61,37.04 98.61,37.24 98.52,37.33 98.11,37.33 98.01,37.43 98.01,38.98 v8(98.39,39.36)
  BOTTOM w0.076: UCPU1.AY65 100.69,44.69 100.42,44.42 100.42,44.14 100.37,44.01 100.37,43.97 100.26,43.74 100.26,43.04 99.33,42.1 98.7,42.1 98.01,41.41 98.01,39.75 v8(98.39,39.36)
DDR_A_D38: length 24.4
  TOP w0.152: v8(101.12,26.03) 101.12,25.94 UD41.C10
  IN3 w0.095: v3(100.85,41.24) 100.76,41.24 100.42,40.89 100.42,40.18 100.07,39.83 100.07,31.67 100.16,31.57 100.45,31.57 100.54,31.48 100.54,31.28 100.45,31.19 100.16,31.19 100.07,31.09 100.07,30.9 100.16,30.81 100.76,30.81 100.85,30.71 100.85,30.52 100.76,30.43 100.16,30.43 100.07,30.33 100.07,30.14 100.16,30.05 100.48,30.05 100.57,29.95 100.57,29.76 100.48,29.67 100.16,29.67 100.07,29.57 100.07,29.3 100.16,29.21 100.5,29.21 100.6,29.11 100.6,28.92 100.5,28.83 100.16,28.83 100.07,28.73 100.07,27.26 101.12,26.21 v8(101.12,26.03)
  GND3 w0.152: v3(100.85,41.24) 100.95,41.24 101.01,41.18 101.22,41.18 v4(101.24,41.2)
  BOTTOM w0.076: UCPU1.BA63 102.02,44.16 102.28,43.9 102.28,43.32 101.88,42.91 101.88,41.53 101.54,41.2 v4(101.24,41.2)
DDR_A_D39: length 23.2
  TOP w0.152: v8(101.76,24.43) 101.76,24.5 UD41.C9
  IN3 w0.095: v8(101.76,24.43) 102.17,24.84 102.17,27.1 101.54,27.74 101.54,29.19 101.74,29.39 101.74,37.33 101.64,37.43 101.22,37.43 101.13,37.52 101.13,37.71 101.22,37.81 101.64,37.81 101.74,37.91 101.74,38.2 101.64,38.3 101.23,38.3 101.13,38.39 101.13,38.55 101.23,38.65 101.41,38.65 101.51,38.74 101.51,38.91 101.38,39.04 101.38,39.93 101.3,40.01 101.3,40.24 101.22,40.32 101.22,40.32 100.99,40.54 100.99,40.54 v3(100.83,40.7)
  GND3 w0.152: v3(100.83,40.7) 101.16,40.7 v4(101.21,40.66)
  BOTTOM w0.076: v4(101.21,40.66) 100.95,40.92 100.95,41.54 101.67,42.26 101.67,43.05 102.02,43.4 UCPU1.BB63
DDR_A_D40: length 27.2
  TOP w0.152: UD41.T9 110.21,24.5 v8(110.21,24.43)
  IN2 w0.095: v3(102.04,41.13) 102.43,41.13 103.04,40.52 103.04,33.01 103.66,32.39 105.13,32.39 105.65,31.88 105.65,30.47 106.42,29.71 106.42,29.22 106.67,28.96 106.67,27.56 106.96,27.27 106.96,25.66 106.85,25.54 106.85,24.95 107.37,24.43 v8(110.21,24.43)
  GND3 w0.152: v4(102.41,41.13) 102.05,41.13 v3(102.04,41.13)
  BOTTOM w0.076: UCPU1.BA61 102.78,43.98 102.78,42.49 102.68,42.39 102.68,41.41 v4(102.41,41.13)
DDR_A_D41: length 28.9
  TOP w0.152: v8(109.56,25.23) 109.56,25.15 UD41.R9
  IN2 w0.095: v3(102.11,42.44) 103.34,41.21 103.34,33.14 103.78,32.7 105.26,32.7 106.72,31.24 106.72,30.94 106.61,30.83 106.38,30.83 106.26,30.71 106.26,30.48 106.38,30.37 106.61,30.37 106.72,30.26 106.72,29.34 107.19,28.88 107.33,28.88 107.58,28.62 107.58,27.4 107.2,27.02 107.2,27 107.2,27 107.2,26.66 107.2,26.66 107.2,26.2 107.2,26.2 107.2,25.86 107.2,25.85 107.2,25.4 107.15,25.35 107.15,25.08 107.42,24.81 109.19,24.81 109.56,25.17 v8(109.56,25.23)
  GND3 w0.152: v3(102.11,42.44) 102.11,42.37 v4(102.38,42.1)
  BOTTOM w0.076: UCPU1.AW61 103.14,45.38 102.87,45.1 102.87,44.59 102.61,44.34 102.61,43.01 102.38,42.78 102.38,42.15 102.38,42.15 v4(102.38,42.1)
DDR_A_D42: length 27.2
  TOP w0.152: v8(110.21,26.03) 110.21,26.1 UD41.T11
  IN2 w0.095: v3(104.07,43.06) 104.34,42.8 105.39,42.8 106.04,42.14 106.04,37.94 106.59,37.39 106.59,36.66 106.42,36.49 106.42,36.09 106.64,35.87 106.64,35.38 106.42,35.16 106.42,35.09 106.31,34.98 105.18,34.98 105.07,34.86 105.07,34.64 105.18,34.52 106.63,34.52 106.75,34.41 106.75,34.12 106.87,33.99 107.12,33.99 109.64,31.47 109.64,30.18 109.76,30.06 110.24,30.06 110.35,29.95 110.35,29.72 110.24,29.61 109.76,29.61 109.64,29.49 109.64,28.2 109.8,28.04 110.46,28.04 110.71,27.79 110.71,27.41 110.35,27.05 110.35,26.39 110.21,26.25 v8(110.21,26.03)
  GND3 w0.152: v4(104.18,42.67) 104.07,42.79 104.07,43.05 v3(104.07,43.06)
  BOTTOM w0.076: v4(104.18,42.67) 104.37,42.86 UCPU1.BB59
DDR_A_D43: length 29.6
  TOP w0.152: UD41.T10 110.21,25.3 v8(110.21,25.23)
  IN2 w0.095: v3(103.42,43.51) 103.93,44.03 105.69,44.03 106.45,43.27 106.45,42.65 106.33,42.53 106.33,38.18 107.05,37.46 107.05,35.82 107.16,35.71 107.41,35.71 107.52,35.6 107.52,35.37 107.41,35.25 107.16,35.25 107.05,35.14 107.05,34.91 107.16,34.8 107.38,34.8 107.48,34.7 107.48,34.04 110.25,31.26 110.25,31.04 110.16,30.94 110.07,30.94 109.95,30.82 109.95,30.59 110.07,30.46 110.58,30.46 110.71,30.33 110.71,28.34 111.06,27.99 111.06,27.14 110.69,26.77 110.69,25.86 110.21,25.38 v8(110.21,25.23)
  GND3 w0.152: v3(103.42,43.51) 103.42,43.43 v4(103.63,43.21)
  BOTTOM w0.076: v4(103.63,43.21) 103.53,43.32 103.53,43.58 103.52,43.61 103.43,43.83 103.42,43.87 103.42,43.96 103.45,44.07 103.46,44.12 103.47,44.14 103.47,44.36 103.46,44.39 103.43,44.47 103.43,45.38 103.6,45.54 UCPU1.AW59
DDR_A_D44: length 26.7
  TOP w0.152: UD41.R8 109.56,23.7 v8(109.56,23.63)
  IN2 w0.095: v3(102.02,40.58) 102.37,40.58 102.73,40.21 102.73,32.88 103.66,31.96 104.36,31.96 104.48,32.09 105,32.09 105.34,31.75 105.34,30.35 106.04,29.65 106.04,29.16 106.31,28.89 106.31,28.48 106.31,27.43 106.69,27.05 106.69,25.81 106.47,25.58 106.47,24.8 107.18,24.09 109.13,24.09 109.56,23.66 v8(109.56,23.63)
  GND3 w0.152: v3(102.02,40.58) 102.16,40.72 v4(102.41,40.72)
  BOTTOM w0.076: UCPU1.BB61 102.94,43.49 102.94,42.42 102.87,42.35 102.87,41.18 v4(102.41,40.72)
DDR_A_D45: length 28.2
  TOP w0.152: UD41.T8 110.21,23.7 v8(110.21,23.63)
  IN2 w0.095: v8(110.21,23.63) 109.8,23.22 107.46,23.22 105.87,24.8 105.87,27.3 106.01,27.43 106.01,28.73 105.7,29.04 105.7,29.48 102.41,32.78 102.41,39.05 v3(102.06,39.45)
  GND3 w0.152: v3(102.06,39.45) 102.24,39.44 v4(102.4,39.61)
  BOTTOM w0.076: UCPU1.AY61 103.26,44.77 103.26,44.43 103.31,44.33 103.31,44.18 103.31,44.18 103.25,43.99 103.25,43.84 103.27,43.8 103.34,43.59 103.34,43.41 103.11,43.18 103.11,42.14 103.04,42.07 103.04,40.24 v2(102.96,40.16) v4(102.4,39.61)
DDR_A_D46: length 26.8
  TOP w0.152: UD41.R10 109.56,25.95 v8(109.56,26.03)
  IN2 w0.095: v8(109.56,26.03) 110.04,26.51 110.04,27 109.34,27.71 109.34,31.33 108.86,31.81 108.86,31.81 106.98,33.69 106.21,33.69 105.78,34.12 104.92,34.12 104.75,34.28 104.75,35.38 104.87,35.49 105.17,35.49 105.26,35.4 106.22,35.4 106.34,35.51 106.34,35.74 106.22,35.85 105.34,35.85 105.22,35.97 105.22,36.2 105.34,36.31 105.99,36.31 106.11,36.43 106.11,36.6 106.29,36.79 106.29,37.27 105.74,37.82 105.74,39.69 105.04,40.39 105.04,40.8 104.21,41.63 v3(104.1,41.63)
  GND3 w0.152: v4(104.39,41.83) 104.3,41.83 v3(104.1,41.63)
  BOTTOM w0.076: v4(104.39,41.83) 104.64,42.08 104.64,43.7 104.55,43.91 104.37,44.09 UCPU1.BA59
DDR_A_D47: length 27
  TOP w0.152: UD41.R11 109.58,26.77 v8(109.58,26.83)
  IN2 w0.095: v3(104.16,41.05) 104.24,41.05 104.75,40.54 104.75,40.27 105.45,39.57 105.45,38.33 105.3,38.18 105.3,38.18 104.74,37.61 104.74,37.37 104.85,37.26 105.87,37.26 105.98,37.14 105.98,36.91 105.87,36.8 104.56,36.8 104.45,36.68 104.45,36.46 104.56,36.34 104.8,36.34 104.92,36.23 104.92,36 104.8,35.88 104.56,35.88 104.45,35.77 104.45,33.98 104.66,33.76 105.7,33.76 106.12,33.34 106.92,33.34 106.93,33.33 106.93,33.33 108.57,31.69 108.57,31.69 109.01,31.26 109.01,27.55 109.58,26.98 v8(109.58,26.83)
  GND3 w0.152: v4(103.91,40.82) 103.93,40.82 v3(104.16,41.05)
  BOTTOM w0.076: v4(103.91,40.82) v2(104.19,41.12) 104.8,41.78 104.8,43.73 104.77,43.8 104.71,44.01 104.64,44.08 104.64,44.46 104.37,44.72 UCPU1.AY59
DDR_A_D48: length 28.7
  TOP w0.152: UD41.E10 103.06,25.3 v8(103.06,25.23)
  IN2 w0.095: v8(99.7,47.01) 98.83,47.01 98.21,46.39 98.21,45.69 97.65,45.13 97.65,35.14 97.93,34.86 97.93,32.51 98.25,32.2 98.41,32.2 99.95,30.65 99.95,30.49 99.81,30.35 99.81,30.19 99.97,30.03 100.13,30.03 100.27,30.17 100.44,30.17 100.6,30.01 100.6,29.85 100.36,29.61 100.36,29.44 100.52,29.28 100.68,29.28 100.92,29.52 101.08,29.52 101.24,29.36 101.24,29.2 101,28.96 101,28.8 101.37,28.43 102.08,28.43 102.57,27.94 102.57,25.71 v8(103.06,25.23)
  BOTTOM w0.152: v8(99.7,47.01) 99.81,47.01 UCPU1.AT66
DDR_A_D49: length 28.1
  TOP w0.152: v8(103.06,26.03) 103.06,25.95 UD41.F10
  IN2 w0.095: v8(99.7,46.38) 99.2,45.88 99.2,45.19 97.97,43.97 97.97,40.79 97.97,40.79 97.97,40.45 97.97,40.45 97.97,37.4 98.2,37.18 98.44,37.18 98.55,37.07 98.55,36.84 98.44,36.72 98.2,36.72 98.08,36.61 98.08,35.96 98.2,35.85 98.57,35.85 98.82,35.59 98.82,34.93 98.71,34.82 98.38,34.82 98.26,34.7 98.26,34.47 98.38,34.36 98.71,34.36 98.82,34.24 98.82,34.02 98.71,33.9 98.38,33.9 98.26,33.79 98.26,33.56 98.38,33.44 98.71,33.44 98.82,33.33 98.82,33.1 98.71,32.99 98.38,32.99 98.26,32.87 98.26,32.64 98.38,32.53 98.71,32.53 98.82,32.42 98.82,32.22 101.5,29.54 102.05,29.54 102.54,29.05 102.54,28.5 102.88,28.16 102.88,27.1 103.08,26.9 103.08,26.05 v8(103.06,26.03)
  BOTTOM w0.152: v8(99.7,46.38) 99.82,46.38 UCPU1.AU66
DDR_A_D50: length 28
  TOP w0.152: v8(103.71,24.43) 103.71,24.35 UD41.F8
  IN2 w0.076: 101.32,46.18 101.32,46.41 100.98,46.76 100.98,47.92 v8(100.61,48.28)
  IN2 w0.095: v8(103.71,24.43) 103.85,24.43 104.51,25.08 104.51,26.11 104.59,26.2 104.59,26.2 104.85,26.46 104.85,29.31 101.68,32.48 101.68,37.8 101.57,37.91 101.4,37.91 101.28,38.03 101.28,38.26 101.4,38.37 101.57,38.37 101.68,38.48 101.68,38.71 101.57,38.83 101.47,38.83 101.28,39.01 101.28,42.88 101.39,42.99 101.39,46.01 101.39,46.01 101.39,46.02 101.32,46.08 101.32,46.18
  BOTTOM w0.152: v8(100.61,48.28) 100.69,48.28 UCPU1.AP65
DDR_A_D51: length 32.4
  TOP w0.076: v8(102.64,23.18) 102.4,23.42 102.4,24.47 102.08,24.79 UD41.D9
  IN2 w0.076: 101.66,46.38 101.16,46.88 101.16,48.16 101.05,48.27 101.05,48.48 v8(100.61,48.92)
  IN2 w0.095: 101.66,46.38 101.66,46.15 101.67,46.14 101.67,46.13 101.68,46.12 101.68,42.83 101.61,42.77 101.61,39.19 101.99,38.81 101.99,32.6 105.16,29.43 105.16,27.43 105.45,27.13 105.45,25.1 105.42,25.07 105.42,25.06 105.2,24.84 105.2,24.84 105.19,24.83 104.86,24.83 104.35,24.32 104.35,23.65 103.88,23.17 102.65,23.17 v8(102.64,23.18)
  BOTTOM w0.152: UCPU1.AN65 100.68,48.92 v8(100.61,48.92)
DDR_A_D52: length 31
  TOP w0.152: v8(103.06,24.43) 103.06,24.5 UD41.E9
  IN2 w0.095: v8(99.7,48.92) 99.62,48.92 98.64,47.94 98.19,47.94 97.01,46.76 97.01,36.25 96.57,35.81 96.57,32.24 99.96,28.85 99.96,28.68 99.73,28.45 99.73,28.29 99.89,28.12 100.05,28.12 100.29,28.36 100.45,28.36 101.49,27.32 101.89,27.32 102.17,27.04 102.17,25.31 v8(103.06,24.43)
  BOTTOM w0.152: UCPU1.AN66 99.76,48.92 v8(99.7,48.92)
DDR_A_D53: length 30.5
  TOP w0.076: v8(102.05,27.85) 102.4,27.5 102.4,26.82 102.73,26.49 UD41.E11
  IN2 w0.095: v8(99.7,48.28) 99.55,48.28 97.7,46.44 97.7,45.61 97.35,45.26 97.35,35.69 97.23,35.58 96.99,35.58 96.88,35.47 96.88,35.24 96.99,35.12 97.23,35.12 97.56,34.8 97.56,34.3 97.44,34.19 97.03,34.19 96.92,34.07 96.92,33.85 97.03,33.73 97.44,33.73 97.56,33.62 97.56,33.39 97.44,33.27 97.03,33.27 96.92,33.16 96.92,32.93 97.03,32.82 97.44,32.82 97.56,32.7 97.56,32.45 97.45,32.34 97.45,31.91 98.06,31.3 98.22,31.3 98.44,31.52 98.6,31.52 98.77,31.35 98.77,31.19 98.55,30.97 98.55,30.81 98.71,30.65 98.87,30.65 99.09,30.87 99.25,30.87 99.41,30.71 99.41,30.55 99.19,30.33 99.19,30.17 101.51,27.85 v8(102.05,27.85)
  BOTTOM w0.152: UCPU1.AP66 99.78,48.28 v8(99.7,48.28)
DDR_A_D54: length 29.8
  TOP w0.152: UD41.F9 103.71,25.15 v8(103.71,25.23)
  IN2 w0.076: v8(100.61,47.01) 100.61,46.89 100.81,46.69 100.81,46.69 101,46.5 101,46.22
  IN2 w0.095: 101,46.22 101,46 101.11,45.89 101.11,43.24 100.37,42.5 100.37,38 101.26,37.11 101.26,33.18 101.13,33.05 100.9,33.05 100.78,33.18 100.78,33.42 100.66,33.53 100.37,33.53 100.26,33.42 100.26,32.72 100.68,32.3 100.84,32.3 101.06,32.51 101.22,32.51 101.38,32.35 101.38,32.19 101.17,31.97 101.17,31.81 101.33,31.65 101.49,31.65 101.7,31.87 101.86,31.87 102.03,31.7 102.03,31.54 101.81,31.33 101.81,31.17 101.98,30.99 102.71,30.99 104.55,29.16 104.55,26.59 104.21,26.24 104.21,25.51 103.92,25.23 v8(103.71,25.23)
  BOTTOM w0.152: v8(100.61,47.01) 100.72,47.01 UCPU1.AT65
DDR_A_D55: length 28.7
  TOP w0.076: 103.27,27.67 103.06,27.46 103.06,26.74 UD41.F11
  TOP w0.173: v8(104.12,28.37) 103.97,28.37 103.27,27.67
  IN2 w0.095: v8(100.61,46.38) 100.61,45.79 100.82,45.58 100.82,43.51 100.07,42.76 100.07,37.23 100.16,37.13 100.74,37.13 100.85,37.02 100.85,36.79 100.74,36.68 100.29,36.68 100.17,36.56 100.17,36.33 100.29,36.22 100.74,36.22 100.85,36.1 100.85,35.88 100.74,35.76 100.23,35.76 100.12,35.65 100.12,35.42 100.23,35.3 100.74,35.3 100.85,35.19 100.85,34.96 100.74,34.85 100.29,34.85 100.17,34.73 100.17,34.5 100.29,34.39 100.74,34.39 100.85,34.28 100.85,34.05 100.74,33.93 100.05,33.93 99.95,33.83 99.95,32.6 101.86,30.69 102.59,30.69 104.22,29.06 104.22,28.47 v8(104.12,28.37)
  BOTTOM w0.152: v8(100.61,46.38) 100.74,46.38 UCPU1.AU65
DDR_A_D56: length 27.6
  TOP w0.152: v8(108.26,25.23) 108.26,25.15 UD41.N9
  IN3 w0.095: v8(108.26,25.23) 107.83,24.8 106.53,24.8 105.48,25.85 105.48,26.42 104.61,27.29 104.61,29.04 102.99,30.65 102.99,38.83 103.29,39.13 103.29,42.67 101.91,44.06 101.91,46.39 102.44,46.92 v8(102.44,47.01)
  BOTTOM w0.152: UCPU1.AT61 102.55,47.01 v8(102.44,47.01)
DDR_A_D57: length 27.2
  TOP w0.152: v8(107.61,25.23) 107.61,25.15 UD41.M9
  IN3 w0.095: v8(102.44,46.38) 102.15,46.09 102.15,45.19 102.26,45.08 102.26,44.11 103.58,42.79 103.58,38.77 103.44,38.63 103.44,38.44 103.54,38.35 104.18,38.35 104.28,38.25 104.28,38.06 104.18,37.97 103.54,37.97 103.44,37.87 103.44,30.63 104.91,29.16 104.91,27.5 105.2,27.2 105.61,27.2 105.74,27.07 105.74,26.93 105.63,26.82 105.63,26.69 105.86,26.46 105.86,25.9 106.53,25.23 v8(107.61,25.23)
  BOTTOM w0.152: v8(102.44,46.38) 102.57,46.38 UCPU1.AU61
DDR_A_D58: length 28.8
  TOP w0.076: UD41.N11 108.24,26.74 108.24,27.71 108.18,27.77 108.18,28.26 v8(108.59,28.66)
  IN3 w0.076: v8(103.36,48.28) 103.85,47.79 103.85,46.82 104.61,46.06
  IN3 w0.095: 104.61,46.06 105,45.68 106.34,45.68 106.67,45.35 106.67,44.74 107.91,43.5 107.91,41.34 107.26,40.68 107.26,38.3 106.93,37.98 106.93,35.53 106.63,35.23 106.41,35.23 106.31,35.14 106.31,34.95 106.41,34.85 106.95,34.85 107.04,34.75 107.04,34.56 106.95,34.47 106.41,34.47 106.31,34.37 106.31,34.18 106.41,34.09 106.95,34.09 107.04,33.99 107.04,32.03 108.03,31.05 108.03,31.04 108.34,30.73 108.62,30.45 108.62,28.7 v8(108.59,28.66)
  BOTTOM w0.152: v8(103.36,48.28) 103.43,48.28 UCPU1.AP60
DDR_A_D59: length 31.4
  TOP w0.152: UD41.N10 108.26,25.95 v8(108.26,26.03)
  IN3 w0.076: 104.61,48.08 104.49,48.2 104.07,48.2 v8(103.36,48.92)
  IN3 w0.095: v8(108.26,26.03) 108.43,26.2 108.43,27.14 108.62,27.34 108.93,27.34 109.08,27.49 109.08,27.79 109.18,27.88 109.72,27.88 109.82,27.98 109.82,28.17 109.72,28.26 109.15,28.26 109.06,28.36 109.06,28.55 109.15,28.64 109.7,28.64 109.79,28.74 109.79,28.93 109.7,29.02 109.13,29.02 109.03,29.12 109.03,29.31 109.13,29.4 109.7,29.4 109.79,29.5 109.79,29.68 109.69,29.79 109.15,29.79 109.06,29.88 109.06,30.42 108.32,31.16 108.32,40.88 108.2,40.99 108.2,43.82 107.06,44.96 107.06,45.42 106.51,45.96 105.79,45.96 105.6,46.15 105.6,46.46 104.69,47.38 104.69,48 104.61,48.08
  BOTTOM w0.152: v8(103.36,48.92) 103.42,48.92 UCPU1.AN60
DDR_A_D60: length 31.8
  TOP w0.152: UD41.M8 107.61,23.7 v8(107.61,23.63)
  IN3 w0.076: v8(102.44,48.92) 101.9,48.38 101.9,46.88 101.67,46.66 101.66,46.66 101.33,46.33 101.33,45.27 101.23,45.17 101.23,45.12
  IN3 w0.095: 101.23,45.12 101.23,43.92 102.72,42.44 102.72,39.45 102.42,39.15 102.42,30.42 102.76,30.08 102.76,30.06 102.81,30.01 102.81,29.99 103.02,29.78 103.02,26.73 103.04,26.71 103.04,26.7 103.32,26.42 104,26.42 104.15,26.27 104.15,24.54 104.69,24.01 105.97,24.01 106.02,24.06 107.17,24.06 v8(107.61,23.63)
  BOTTOM w0.152: UCPU1.AN61 102.51,48.92 v8(102.44,48.92)
DDR_A_D61: length 31.1
  TOP w0.152: UD41.P9 108.91,25.15 v8(108.91,25.23)
  IN3 w0.076: 101.61,44.98 101.61,46.35 102.08,46.82 102.08,47.92 v8(102.44,48.28)
  IN3 w0.095: 101.61,44.98 101.61,43.95 103.01,42.55 103.01,39.27 102.71,38.97 102.71,30.54 102.87,30.37 103.05,30.19 103.05,30.17 103.35,29.87 103.35,27.83 104.55,26.64 104.55,25.03 104.74,24.84 105.83,24.84 106.19,24.47 108.15,24.47 v8(108.91,25.23)
  BOTTOM w0.152: UCPU1.AP61 102.52,48.28 v8(102.44,48.28)
DDR_A_D62: length 32.4
  TOP w0.152: UD41.M10 107.61,25.95 v8(107.61,26.03)
  IN3 w0.076: 104.02,46.34 v8(103.36,47.01)
  IN3 w0.095: v8(107.61,26.03) 107.61,26.07 108.1,26.57 108.1,28.82 108.31,29.03 108.31,29.25 108.21,29.34 107.81,29.34 107.71,29.44 107.71,29.63 107.81,29.72 108.21,29.72 108.31,29.82 108.31,30.17 108.07,30.41 107.93,30.41 107.51,29.98 107.37,29.98 107.24,30.12 107.24,30.25 107.66,30.68 107.66,30.81 107.53,30.95 107.4,30.95 107.02,30.57 106.89,30.57 106.75,30.71 106.75,30.84 107.13,31.22 107.13,31.35 106.99,31.49 106.86,31.49 106.71,31.34 106.58,31.34 106.01,31.91 106.01,32.47 106.1,32.56 106.61,32.56 106.69,32.65 106.69,32.86 106.61,32.95 106.1,32.95 106.01,33.04 106.01,33.23 106.1,33.33 106.68,33.33 106.76,33.41 106.76,33.63 106.68,33.71 106.1,33.71 106.01,33.8 106.01,38.59 106.1,38.68 106.1,40.06 106.24,40.2 106.24,41.05 106.36,41.17 106.36,42.22 106.84,42.7 106.84,43.89 106.49,44.23 106.11,44.23 105.47,44.87 104.98,44.87 104.96,44.84 104.61,44.84 104.37,45.08 104.37,46 104.02,46.34
  BOTTOM w0.152: UCPU1.AT60 103.47,47.01 v8(103.36,47.01)
DDR_A_D63: length 31.2
  TOP w0.152: v8(107.61,26.83) 107.61,26.75 UD41.M11
  IN3 w0.095: v8(107.61,26.83) 107.67,26.89 107.67,28.74 107.36,29.05 106.89,29.05 106.8,29.14 106.8,29.73 106.7,29.83 106.1,29.83 106.01,29.93 106.01,30.12 106.1,30.21 106.37,30.21 106.47,30.31 106.47,30.53 106.37,30.62 105.32,30.62 105.22,30.72 105.22,30.91 105.32,31.01 105.86,31.01 105.96,31.1 105.96,31.29 105.86,31.39 105.32,31.39 105.22,31.48 105.22,31.67 105.32,31.77 105.63,31.77 105.72,31.86 105.72,35.11 105.63,35.2 105.42,35.2 105.32,35.3 105.32,35.49 105.42,35.59 105.63,35.59 105.72,35.68 105.72,35.87 105.63,35.97 105.42,35.97 105.32,36.06 105.32,36.25 105.42,36.35 105.63,36.35 105.72,36.44 105.72,36.63 105.63,36.73 105.42,36.73 105.32,36.82 105.32,37.01 105.42,37.11 105.63,37.11 105.72,37.2 105.72,37.39 105.63,37.49 105.42,37.49 105.35,37.56 105.35,37.8 105.42,37.87 105.63,37.87 105.72,37.97 105.72,38.16 105.63,38.25 105.42,38.25 105.35,38.32 105.35,38.57 105.42,38.63 105.63,38.63 105.72,38.73 105.72,38.92 105.63,39.01 105.42,39.01 105.35,39.08 105.35,39.33 105.42,39.4 105.63,39.4 105.72,39.49 105.72,39.68 105.63,39.78 105.44,39.78 105.35,39.87 105.35,40.07 105.44,40.16 105.77,40.16 105.95,40.34 105.95,41.28 106.06,41.39 106.06,42.34 106.52,42.8 106.52,43.26 105.85,43.93 105.49,43.93 105.42,44 105,44 104.06,44.94 104.06,45.67 v8(103.36,46.38)
  BOTTOM w0.152: v8(103.36,46.38) 103.48,46.38 UCPU1.AU60
DDR_A_DQS0: length 41.7
  TOP w0.14: v8(86.24,25.23) 86.24,25.3 UD42.D10
  IN3 w0.108: v3(93.62,49.95) 93.48,49.81 92.25,49.81 90.7,48.26 88.71,48.26 84.95,44.5 84.95,39.8 85.19,39.56 85.89,39.56 85.99,39.45 85.99,39.13 85.89,39.02 85.19,39.02 84.95,38.78 84.95,38.26 85.19,38.02 85.76,38.02 85.87,37.91 85.87,37.59 85.76,37.48 85.19,37.48 84.95,37.24 84.95,30.18 84.51,29.75 84.51,28.9 83.81,28.19 83.81,27.56 83.61,27.35 83.61,26.45 84.83,25.23 v8(86.24,25.23)
  GND3 w0.14: v4(93.95,49.92) 93.65,49.92 v3(93.62,49.95)
  BOTTOM w0.076: UCPU1.AM69 98.41,49.85 98.34,49.92 98.34,49.98 98.23,50.1 98.03,50.2 97.8,50.2 97.63,50.14 97.55,50.14 97.33,50.21 97.16,50.21 96.98,50.14 96.77,50.14 96.68,50.24 95.95,50.24 95.55,49.84 94.54,49.84 94.47,49.77 94.1,49.77 v4(93.95,49.92)
DDR_A_DQS1: length 32.4
  TOP w0.14: v8(93.4,26.02) 93.4,25.83 93.2,25.63 UD42.P10
  IN2 w0.108: v8(93.97,44.56) 93.97,44.35 93.87,44.26 93.5,44.26 93.2,43.96 93.2,41.02 92.39,40.22 92.39,31.71 96.2,27.9 96.2,25.95 95.73,25.47 93.43,25.47 93.16,25.74 93.16,25.87 93.31,26.02 v8(93.4,26.02)
  BOTTOM w0.076: UCPU1.AT70 98.07,47.4 98.17,47.3 98.17,47.22 98.11,47.16 97.94,47.11 97.82,47.11 97.69,47.17 97.49,47.17 97.3,47.1 97.19,47.1 97.03,47.18 96.13,47.18 95.2,46.25 95.2,45.33 94.63,44.76 94.63,44.53 94.26,44.16 94.11,44.16 93.97,44.31 v8(93.97,44.56)
DDR_A_DQS2: length 40.5
  TOP w0.14: UD42.L10 91.42,25.93 v8(91.42,26.04)
  IN3 w0.076: 99,51.43 99.01,51.45 99.05,51.45 99.58,51.97 100.59,51.97 100.73,51.97 100.98,51.72 100.98,51.58 v8(101.15,51.41)
  IN3 w0.108: v8(91.42,26.04) 91.26,26.2 91.05,26.2 90.73,26.52 90.73,29.37 92.41,31.05 92.41,33.31 92.73,33.63 93.96,33.63 94.07,33.74 94.07,34.06 93.96,34.17 92.69,34.17 92.45,34.41 92.45,34.93 92.69,35.17 93.96,35.17 94.07,35.28 94.07,35.6 93.96,35.71 92.81,35.71 92.57,35.95 92.57,36.46 92.81,36.71 93.96,36.71 94.07,36.81 94.07,37.14 93.96,37.25 93.41,37.25 93.14,37.52 93.14,38.5 93.38,38.74 93.72,38.74 93.92,38.94 93.92,39.55 97.42,43.06 97.42,45.26 97.97,45.81 97.97,50.41 99,51.43
  BOTTOM w0.076: v8(101.15,51.41) 101.15,51.53 UCPU1.AH65
DDR_A_DQS3: length 42.9
  TOP w0.14: v8(88.19,26.03) 88.19,25.95 UD42.G10
  IN2 w0.108: v3(94.19,52.18) 94.19,52.4 94.1,52.49 91.46,52.49 90.9,51.93 90.9,51.24 84.14,44.47 84.14,33.71 86,31.85 86.16,31.85 86.46,32.15 86.81,32.15 87.18,31.78 87.18,31.42 86.89,31.13 86.89,30.97 87.13,30.72 87.29,30.72 87.59,31.02 87.94,31.02 88.32,30.64 88.32,30.29 88.02,29.99 88.02,29.83 89.07,28.78 89.07,26.9 88.63,26.45 88.31,26.45 88.19,26.32 v8(88.19,26.03)
  GND3 w0.14: v4(94.34,51.77) 94.34,52.03 v3(94.19,52.18)
  BOTTOM w0.076: UCPU1.AG70 98.07,52.41 98.17,52.31 98.17,52.23 98.11,52.17 97.94,52.12 97.82,52.12 97.69,52.18 97.49,52.18 97.3,52.11 97.19,52.11 97.03,52.18 95.73,52.18 95.66,52.26 94.83,52.26 94.34,51.78 v4(94.34,51.77)
DDR_A_DQS4: length 24.1
  TOP w0.14: UD41.D10 101.76,25.3 v8(101.76,25.23)
  IN3 w0.108: v8(101.76,25.23) 101.6,25.39 100.85,25.39 99.4,26.85 99.4,37.1 98.88,37.62 98.88,40.63 99.19,40.95 99.45,40.95 v3(99.63,41.12)
  GND3 w0.14: v3(99.63,41.12) 99.66,41.15 99.99,41.15 v4(100.02,41.12)
  BOTTOM w0.076: v4(100.02,41.12) 100.2,40.94 100.31,40.94 100.4,41.03 100.4,42.37 100.78,42.76 100.78,43.25 100.96,43.43 100.96,43.64 100.89,43.82 100.89,43.99 100.96,44.21 100.96,44.29 100.9,44.46 100.9,44.69 101.01,44.89 101.13,45 101.19,45 101.25,45.07 UCPU1.AY64
DDR_A_DQS5: length 26.4
  TOP w0.14: UD41.P10 108.91,25.95 v8(108.91,26.03)
  IN2 w0.076: 107.89,28.12 107.89,28.11 107.92,28.07 107.92,27.28 108.18,27.02 108.18,26.66 108.55,26.28 108.76,26.28 108.91,26.14 v8(108.91,26.03)
  IN2 w0.108: v3(104.24,39.32) 104.43,39.51 104.61,39.51 104.81,39.31 104.81,38.6 103.8,37.58 103.8,33.41 104.1,33.12 105.43,33.12 105.85,32.7 106.67,32.7 107.94,31.43 107.94,31.28 107.83,31.17 107.4,31.17 107.15,30.92 107.15,30.39 107.4,30.14 107.77,30.14 107.89,30.03 107.89,28.12
  GND3 w0.14: v4(103.92,39.54) 104.02,39.54 v3(104.24,39.32)
  BOTTOM w0.076: v4(103.92,39.54) 103.92,39.54 103.79,39.67 103.78,39.67 103.32,40.13 103.32,42.67 103.53,42.88 103.74,42.88 103.93,43.07 103.93,43.69 104,43.85 104,43.96 103.94,44.15 103.94,44.35 104,44.48 104,44.6 103.94,44.77 103.89,44.83 103.81,44.83 103.71,44.73 UCPU1.BA60
DDR_A_DQS6: length 28.3
  TOP w0.14: v8(103.71,26.03) 103.71,25.95 UD41.G10
  IN2 w0.076: 103.52,28.2 103.52,28.18 103.49,28.15 103.49,27.67 103.75,27.41 103.99,27.41 104.27,27.13 104.27,26.59 103.97,26.3 103.84,26.3 103.71,26.16 v8(103.71,26.03) ; 100.31,45.5 100.31,45.52 100.28,45.55 100.28,46.24 100.24,46.28 100.24,47.28 v8(100.61,47.65)
  IN2 w0.108: 103.52,28.2 103.52,28.58 103.19,28.92 103.19,29.31 102.32,30.18 101.77,30.18 99.53,32.42 99.53,35.73 99.73,35.93 99.73,36.89 99.18,37.45 99.18,38.05 99.28,38.15 99.42,38.15 99.66,38.4 99.66,38.91 99.42,39.15 99.28,39.15 99.18,39.26 99.18,41.33 99.25,41.41 99.25,41.94 98.97,42.22 98.74,42.22 98.62,42.34 98.62,43.3 98.78,43.46 99.2,43.46 99.38,43.64 99.79,43.64 100.4,44.25 100.4,45.09 100.31,45.17 100.31,45.5
  BOTTOM w0.132: UCPU1.AR65 100.98,48.01 v8(100.61,47.65)
DDR_A_DQS7: length 30.5
  TOP w0.14: UD41.L10 106.31,25.95 v8(106.31,26.03)
  IN3 w0.076: v8(103.36,47.65) 102.97,47.27 102.97,45.89 103.31,45.56 103.31,45.03 103.34,45 103.34,44.98
  IN3 w0.108: 103.34,44.98 103.34,44.65 103.85,44.14 104.09,44.14 104.74,43.48 104.74,42.26 104.94,42.06 104.94,37.62 104.11,36.8 104.11,36.49 104.22,36.38 104.5,36.38 104.74,36.14 104.74,35.63 104.5,35.38 104.22,35.38 104.11,35.28 104.11,34.91 104.22,34.8 105.03,34.8 105.27,34.56 105.27,34.04 105.03,33.8 104.22,33.8 104.11,33.69 104.11,33.37 104.22,33.26 105.03,33.26 105.27,33.02 105.27,32.51 105.03,32.27 104.38,32.27 104.11,32 104.11,30.94 106.34,28.71 106.34,27.79 107.08,27.05 107.08,26.48 106.79,26.19 106.58,26.19 106.47,26.19 v8(106.31,26.03)
  BOTTOM w0.14: UCPU1.AR60 103.45,47.65 v8(103.36,47.65)
DDR_A_DQS#0: length 41.7
  TOP w0.14: UD42.D11 86.24,26.1 v8(86.24,26.03)
  IN3 w0.108: v8(86.24,26.03) 86.37,26.03 86.47,25.92 86.47,25.72 86.37,25.61 86.08,25.61 85.92,25.45 84.93,25.45 83.83,26.55 83.83,27.26 84.04,27.46 84.04,28.1 84.74,28.8 84.74,29.65 85.18,30.09 85.18,37.14 85.29,37.25 85.85,37.25 86.1,37.49 86.1,38.01 85.85,38.25 85.29,38.25 85.18,38.36 85.18,38.68 85.29,38.79 85.98,38.79 86.22,39.03 86.22,39.54 85.98,39.79 85.29,39.79 85.18,39.89 85.18,44.41 88.81,48.03 90.79,48.03 92.34,49.58 93.42,49.58 v3(93.61,49.38)
  GND3 w0.14: v4(93.95,49.49) 93.72,49.49 v3(93.61,49.38)
  BOTTOM w0.076: v4(93.95,49.49) 94.06,49.61 94.54,49.61 94.6,49.67 95.62,49.67 96.02,50.07 96.61,50.07 96.71,49.98 97.01,49.98 97.19,50.05 97.31,50.05 97.53,49.98 97.66,49.98 97.83,50.04 97.99,50.04 98.13,49.96 98.18,49.91 98.18,49.83 98.1,49.75 UCPU1.AM70
DDR_A_DQS#1: length 32.4
  TOP w0.14: v8(92.75,26.02) 92.75,26.11 UD42.P11
  IN2 w0.108: v8(92.75,26.02) 92.93,25.84 92.93,25.65 93.33,25.25 95.82,25.25 96.43,25.86 96.43,27.99 92.62,31.8 92.62,40.12 93.43,40.93 93.43,43.86 93.56,44 93.79,44 v8(93.94,43.85)
  BOTTOM w0.076: UCPU1.AT69 98.44,47.4 98.33,47.3 98.33,47.15 98.2,47.02 97.96,46.95 97.78,46.95 97.65,47.01 97.52,47.01 97.33,46.94 97.16,46.94 96.99,47.01 96.2,47.01 95.37,46.18 95.37,45.26 94.8,44.69 94.8,44.47 94.33,44 94.1,44 v8(93.94,43.85)
DDR_A_DQS#2: length 40.5
  TOP w0.14: v8(91.44,26.83) 91.44,26.75 UD42.L11
  IN3 w0.076: v8(100.52,51.41) 100.69,51.41 100.82,51.54 100.82,51.65 100.66,51.8 99.64,51.8 99.17,51.33 99.17,51.28 99.16,51.27
  IN3 w0.108: 99.16,51.27 98.2,50.31 98.2,45.72 97.65,45.17 97.65,42.96 94.15,39.46 94.15,38.84 93.82,38.51 93.47,38.51 93.36,38.41 93.36,37.61 93.5,37.47 94.06,37.47 94.3,37.23 94.3,36.72 94.06,36.48 92.91,36.48 92.8,36.37 92.8,36.05 92.91,35.94 94.06,35.94 94.3,35.7 94.3,35.18 94.06,34.94 92.78,34.94 92.67,34.83 92.67,34.51 92.78,34.4 94.06,34.4 94.3,34.16 94.3,33.65 94.06,33.4 92.82,33.4 92.64,33.22 92.64,30.96 90.96,29.28 90.96,26.61 91.14,26.43 91.56,26.43 91.69,26.56 91.69,26.71 91.58,26.83 v8(91.44,26.83)
  BOTTOM w0.076: UCPU1.AH66 100.37,51.85 100.52,51.7 v8(100.52,51.41)
DDR_A_DQS#3: length 42.9
  TOP w0.14: UD42.G11 88.19,26.75 v8(88.19,26.83)
  IN2 w0.108: v3(94.79,52.2) 94.72,52.2 94.2,52.72 91.37,52.72 90.67,52.03 90.67,51.33 83.91,44.57 83.91,33.62 85.9,31.63 86.25,31.63 86.55,31.92 86.71,31.92 86.96,31.68 86.96,31.52 86.66,31.22 86.66,30.87 87.03,30.49 87.39,30.49 87.68,30.79 87.85,30.79 88.09,30.55 88.09,30.39 87.79,30.09 87.79,29.74 88.85,28.68 88.85,26.99 88.53,26.68 88.34,26.68 v8(88.19,26.83)
  GND3 w0.14: v3(94.79,52.2) 94.75,52.16 v4(94.75,51.77)
  BOTTOM w0.076: v4(94.75,51.77) 94.75,51.95 94.9,52.1 95.59,52.1 95.67,52.02 96.99,52.02 97.16,51.94 97.33,51.94 97.52,52.01 97.65,52.01 97.78,51.95 97.96,51.95 98.2,52.02 98.33,52.16 98.33,52.22 98.42,52.31 UCPU1.AG69
DDR_A_DQS#4: length 24
  TOP w0.14: UD41.D11 102.08,26.17 101.94,26.03 v8(101.76,26.03)
  IN3 w0.108: v3(99.63,40.53) 99.44,40.72 99.29,40.72 99.1,40.54 99.1,37.71 99.62,37.19 99.62,26.94 100.95,25.62 101.78,25.62 101.89,25.72 101.89,25.9 v8(101.76,26.03)
  GND3 w0.14: v3(99.63,40.53) 99.78,40.68 v4(100.05,40.68)
  BOTTOM w0.076: v4(100.05,40.68) 100.15,40.77 100.38,40.77 100.56,40.96 100.56,42.3 100.95,42.69 100.95,43.18 101.13,43.37 101.13,43.67 101.06,43.85 101.06,43.97 101.13,44.19 101.13,44.32 101.07,44.49 101.07,44.65 101.15,44.79 101.2,44.84 101.27,44.84 101.35,44.76 UCPU1.BA64
DDR_A_DQS#5: length 26.4
  TOP w0.14: v8(108.91,26.84) 108.91,26.76 UD41.P11
  IN2 w0.076: v8(108.91,26.84) 108.91,26.53 108.83,26.45 108.62,26.45 108.34,26.73 108.34,27.09 108.09,27.35 108.09,28.07 108.12,28.11 108.12,28.12
  IN2 w0.108: v3(104.28,39.94) 104.48,39.74 104.71,39.74 105.04,39.41 105.04,38.5 104.03,37.49 104.03,33.51 104.19,33.34 105.53,33.34 105.95,32.93 106.77,32.93 108.17,31.53 108.17,31.18 107.92,30.94 107.49,30.94 107.38,30.83 107.38,30.48 107.49,30.37 107.87,30.37 108.12,30.12 108.12,28.12
  GND3 w0.14: v3(104.28,39.94) 104.27,39.93 103.96,39.93 v4(103.95,39.92)
  BOTTOM w0.076: v4(103.95,39.92) 103.94,39.92 103.85,39.83 103.48,40.2 103.48,42.6 103.6,42.72 103.81,42.72 104.1,43.01 104.1,43.65 104.17,43.82 104.17,43.99 104.1,44.18 104.1,44.31 104.16,44.44 104.16,44.62 104.09,44.86 103.81,45.14 UCPU1.AY60
DDR_A_DQS#6: length 28.2
  TOP w0.14: UD41.G11 103.71,26.75 v8(103.71,26.83)
  IN2 w0.076: 100.08,45.5 100.08,45.52 100.12,45.55 100.12,46.17 100.08,46.21 100.08,47.29 99.72,47.65 v8(99.7,47.65) ; 103.3,28.2 103.3,28.18 103.33,28.15 103.33,27.6 103.68,27.24 103.92,27.24 104.1,27.06 104.1,26.66 103.91,26.46 103.73,26.46 103.64,26.55 103.64,26.76 v8(103.71,26.83)
  IN2 w0.108: 103.3,28.2 103.3,28.49 103.09,28.69 102.96,28.82 102.96,28.87 102.96,28.87 102.96,29.22 102.22,29.96 101.68,29.96 99.3,32.33 99.3,35.82 99.51,36.02 99.51,36.79 98.95,37.35 98.95,38.14 99.19,38.38 99.32,38.38 99.43,38.49 99.43,38.81 99.32,38.92 99.19,38.92 98.95,39.16 98.95,41.43 99.02,41.5 99.02,41.85 98.88,41.99 98.64,41.99 98.39,42.24 98.39,43.4 98.69,43.69 99.1,43.69 99.29,43.87 99.69,43.87 100.17,44.35 100.17,45 100.08,45.08 100.08,45.5
  BOTTOM w0.132: UCPU1.AR66 100.06,48.01 v8(99.7,47.65)
DDR_A_DQS#7: length 30.5
  TOP w0.14: UD41.L11 106.31,26.75 v8(106.31,26.83)
  IN3 w0.076: 103.11,44.98 103.11,45 103.14,45.03 103.14,45.49 102.81,45.82 102.81,47.56 102.72,47.65 v8(102.44,47.65)
  IN3 w0.108: 103.11,44.98 103.11,44.56 103.76,43.91 103.99,43.91 104.51,43.39 104.51,42.17 104.71,41.97 104.71,37.72 103.88,36.89 103.88,36.4 104.13,36.15 104.4,36.15 104.51,36.05 104.51,35.72 104.4,35.61 104.13,35.61 103.88,35.37 103.88,34.81 104.13,34.57 104.94,34.57 105.04,34.46 105.04,34.14 104.94,34.03 104.13,34.03 103.88,33.79 103.88,33.28 104.13,33.03 104.94,33.03 105.04,32.93 105.04,32.6 104.94,32.49 104.28,32.49 103.88,32.1 103.88,30.84 106.11,28.62 106.11,27.69 106.85,26.95 106.85,26.58 106.7,26.42 106.52,26.42 106.31,26.63 v8(106.31,26.83)
  BOTTOM w0.14: v8(102.44,47.65) 102.54,47.65 UCPU1.AR61
DDR_A_ODT0: length 72.7
  TOP w0.152: v8(89.87,23.34) 89.81,23.4 UD42.J8 ; v8(105.66,23.58) 105.66,23.7 UD41.J8 ; v8(98.71,21.1) 98.86,21.1 99.09,20.87 99.09,17.37 98.39,16.67 RD73.1
  IN2 w0.095: v8(105.66,23.58) 104.72,22.64 103.16,22.64 102.95,22.43 102.33,22.43 102.12,22.64 100.49,22.64 100.29,22.44 100.29,22.44 100.04,22.2 100.04,21.75 100.2,21.6 100.45,21.6 100.57,21.48 100.57,21.15 100.43,21.01 98.79,21.01 v8(98.71,21.1) 97.06,21.1 95.67,22.49 90.72,22.49 90.43,22.78 v8(89.87,23.34)
  IN3 w0.095: v8(111.64,47.04) 111.24,46.65 111.24,45.48 110.02,44.25 110.02,32.06 112.87,29.22 112.87,20.81 110.37,18.31 110.37,17.88 109.85,17.36 105.76,17.36 105.05,18.07 101.26,18.07 99.99,19.34 99.99,19.82 v8(98.71,21.1)
  BOTTOM w0.152: v8(111.64,47.04) 111.72,47.04 UCPU1.AT45
DDR_B0_ZQ0: length 3.3
  TOP w0.095: RD5.1 118.97,19.62 120.29,19.62 UD44.B3
DDR_B0_ZQ1: length 3.6
  TOP w0.095: RD7.1 118.15,19.51 119.86,21.22 120.3,21.22 UD44.B4
DDR_B1_ZQ0: length 5.6
  TOP w0.095: UD43.B3 135.82,19.58 135.28,19.58 134.76,19.06 134.76,16.87 134.51,16.62 134.51,16.09 RD6.1
DDR_B1_ZQ1: length 4.3
  TOP w0.095: RD8.1 133.39,22.19 133.9,22.7 134.33,22.7 134.72,22.31 134.72,21.74 135.29,21.17 135.93,21.17 136.26,20.83 UD43.B4
DDR_B_CA1_0: length 50.9
  TOP w0.152: RD22.1 127.99,16.5 128.76,17.27 129.06,17.27 129.25,17.46 129.25,18.54 v8(129.14,18.65) UD44.R2
  IN2 w0.095: v8(129.14,18.65) 130.16,18.65 130.29,18.52 130.29,18.25 130.13,18.09 129.15,18.09 128.94,18.29 128.72,18.29 128.08,17.66 122.52,17.66 121.92,18.26 121.69,18.26 121.45,18.5 120.65,18.5 116.83,22.32 116.83,22.46 117.14,22.77 117.14,22.91 117.01,23.04 116.87,23.04 116.56,22.73 116.42,22.73 115.81,23.34 115.81,30.64 111.66,34.79 111.66,35.46 111.57,35.56 111.29,35.56 111.19,35.66 111.19,35.85 111.29,35.94 111.57,35.94 111.66,36.04 111.66,36.27 111.57,36.37 111.15,36.37 111.05,36.46 111.05,36.65 111.15,36.75 111.57,36.75 111.66,36.84 111.66,37.04 111.57,37.13 111.15,37.13 111.05,37.23 111.05,37.42 111.15,37.51 111.57,37.51 111.66,37.61 111.66,40.71 111.54,40.83 v3(111.26,40.83)
  GND3 w0.152: v3(111.26,40.83) 111.16,40.94 v4(110.94,40.94)
  BOTTOM w0.076: v4(110.94,40.94) v2(111.31,41.31) 111.44,41.44 111.44,42.46 111.13,42.78 110.92,42.78 110.64,43.06 110.64,43.32 110.73,43.41 110.73,44.53 110.46,44.81 UCPU1.AY48
DDR_B_CA1_1: length 48.1
  TOP w0.152: RD24.1 127.41,16.4 v8(128.84,17.84) 128.49,18.19 UD44.P2
  IN2 w0.076: v8(108.84,48.28) 109.23,47.9 109.23,45.85 109.23,45.85 109.23,45.75
  IN2 w0.095: v8(128.84,17.84) 128.36,17.36 122.17,17.36 121.38,18.14 120.58,18.14 115.51,23.21 115.51,30.54 110.74,35.31 110.74,42.42 110.66,42.5 110.66,43.9 109.23,45.32 109.23,45.75
  BOTTOM w0.152: UCPU1.AP50 108.92,48.28 v8(108.84,48.28)
DDR_B_CA1_2: length 49.7
  TOP w0.152: RD26.1 126.27,16.55 127.83,18.12 v8(127.83,18.57) 127.84,18.59 UD44.N2
  IN2 w0.095: v3(111.22,42.46) 111.22,42.45 111.43,42.45 112.23,41.65 112.23,35.03 116.4,30.86 116.4,30.85 116.45,30.8 116.45,28.59 116.56,28.48 117.64,28.48 117.76,28.37 117.76,28.14 117.64,28.02 116.56,28.02 116.45,27.91 116.45,27.68 116.56,27.57 117.64,27.57 117.76,27.45 117.76,27.22 117.64,27.11 116.56,27.11 116.45,26.99 116.45,26.76 116.56,26.65 117.64,26.65 117.76,26.54 117.76,26.31 117.64,26.19 116.56,26.19 116.45,26.08 116.45,25.85 116.56,25.74 117.64,25.74 117.76,25.62 117.76,22.27 120.81,19.21 121.6,19.21 121.94,18.87 122.17,18.87 122.77,18.27 125.85,18.27 126,18.42 126,18.79 126.37,19.16 127.31,19.16 127.83,18.64 v8(127.83,18.57)
  GND3 w0.152: v4(110.9,42.32) 111.04,42.46 v3(111.22,42.46)
  BOTTOM w0.076: UCPU1.BA48 110.19,43.97 110.19,42.84 110.71,42.32 v4(110.9,42.32)
DDR_B_CA1_3: length 48.6
  TOP w0.076: v8(128.17,19.6) 128.17,18.79 128.22,18.74 128.22,17.98
  TOP w0.152: UD44.N3 128.17,19.7 v8(128.17,19.6) ; RD28.1 126.84,16.59 128.22,17.98
  IN2 w0.095: v3(111.25,41.38) 111.45,41.38 111.95,40.89 111.95,34.91 116.12,30.74 116.12,25.52 116.33,25.31 117.34,25.31 117.45,25.19 117.45,24.96 117.34,24.85 116.33,24.85 116.22,24.73 116.22,24.5 116.33,24.39 117.34,24.39 117.45,24.28 117.45,24.05 117.34,23.93 116.33,23.93 116.22,23.82 116.22,23.59 116.33,23.48 117.34,23.48 117.45,23.36 117.45,22.13 120.72,18.86 121.52,18.86 121.82,18.57 122.04,18.57 122.65,17.96 127.85,17.96 128.36,18.47 128.36,19.41 v8(128.17,19.6)
  GND3 w0.152: v4(110.91,41.39) 110.91,41.38 v3(111.25,41.38)
  BOTTOM w0.076: v4(110.91,41.39) 111.28,41.76 111.28,42.39 111.06,42.61 110.85,42.61 110.46,43 UCPU1.BB48
DDR_B_CA1_4: length 53.1
  TOP w0.076: 127.36,18.18 127.47,18.29 127.47,19.06 127.53,19.11 v8(127.53,19.61)
  TOP w0.152: 127.36,18.18 125.69,16.52 RD30.1 ; UD44.M3 127.53,19.69 v8(127.53,19.61)
  IN2 w0.076: 109.56,45.78 109.54,45.78 109.39,45.92 109.39,47.91 v8(109.77,48.28)
  IN2 w0.095: v8(127.53,19.61) 127.5,19.59 127.31,19.59 127.21,19.69 127.21,19.86 127.12,19.96 126.83,19.96 126.74,19.86 126.74,19.69 126.64,19.59 126.13,19.59 125.71,19.18 122.3,19.18 122.07,19.18 121.7,19.54 121.7,20.33 121.19,20.84 119.64,20.84 118.89,21.59 118.89,21.75 118.99,21.84 118.99,22 118.82,22.16 118.66,22.16 118.57,22.07 118.41,22.07 118.06,22.42 118.06,22.66 118.17,22.78 118.59,22.78 118.71,22.89 118.71,23.12 118.59,23.24 118.17,23.24 118.06,23.35 118.06,23.58 118.17,23.69 118.57,23.69 118.68,23.81 118.68,24.04 118.57,24.15 118.17,24.15 118.06,24.26 118.06,28.78 117.95,28.9 116.87,28.9 116.75,29.01 116.75,29.24 116.87,29.36 117.95,29.36 118.06,29.47 118.06,29.83 117.82,30.07 117.51,30.07 117.31,29.86 117.15,29.86 116.99,30.02 116.99,30.19 117.28,30.48 117.28,30.61 112.53,35.37 112.53,41.86 112.13,42.26 112.13,42.83 111.04,43.92 111.04,44.24 110.78,44.51 110.48,44.51 110.32,44.67 110.32,44.83 110.46,44.97 110.46,45.35 110.03,45.78 109.56,45.78
  BOTTOM w0.152: UCPU1.AP48 109.84,48.28 v8(109.77,48.28)
DDR_B_CA1_5: length 50.7
  TOP w0.076: 123.48,18.61 123.48,18.8 123.61,18.93 123.61,19.71 UD44.F3
  TOP w0.152: 123.48,18.61 122.3,17.43 121.43,17.43 v8(121.35,17.51) 121.25,17.41 120.69,17.41 120.11,16.82 RD32.1
  IN2 w0.076: v8(107.93,48.28) 108.27,47.94 108.27,45.91 108.43,45.75
  IN2 w0.095: v8(121.35,17.51) 120.44,17.51 119.72,18.22 118.96,18.22 117.02,20.16 116.86,20.16 116.66,19.97 116.5,19.97 116.34,20.13 116.34,20.29 116.53,20.49 116.53,20.65 116.36,20.82 116.2,20.82 115.89,20.51 115.73,20.51 115.57,20.67 115.57,20.84 115.88,21.14 115.88,21.3 115.71,21.47 115.55,21.47 115.23,21.15 115.07,21.15 114.91,21.31 114.91,21.47 115.23,21.79 115.23,21.95 113.76,23.42 113.76,24.1 113.87,24.21 114.22,24.21 114.33,24.33 114.33,24.56 114.22,24.67 113.87,24.67 113.76,24.78 113.76,25.01 113.87,25.13 114.22,25.13 114.33,25.24 114.33,25.47 114.22,25.58 113.87,25.58 113.76,25.7 113.76,25.93 113.87,26.04 114.22,26.04 114.33,26.16 114.33,26.38 114.22,26.5 113.87,26.5 113.76,26.61 113.76,26.84 113.87,26.96 114.22,26.96 114.33,27.07 114.33,27.3 114.22,27.41 113.87,27.41 113.76,27.53 113.76,28.94 113.76,29.78 113.13,30.4 113.13,31.69 110.17,34.66 110.17,41.86 110.08,41.94 110.08,43.53 108.55,45.06 108.55,45.63 108.43,45.75
  BOTTOM w0.152: UCPU1.AP52 108.01,48.28 v8(107.93,48.28)
DDR_B_CA1_6: length 53.8
  TOP w0.076: v8(122.33,19.63) 122.33,18.79 121.62,18.08 121.15,18.08 120.92,17.85 120.11,17.85 119.86,17.61
  TOP w0.152: RD34.1 118.94,16.68 119.86,17.61 ; UD44.E3 122.33,19.71 v8(122.33,19.63)
  IN2 w0.095: v8(108.84,48.92) 109.09,48.67 110.04,48.67 110.23,48.49 110.23,46.08 111.14,45.17 111.14,45.04 110.97,44.87 110.97,44.74 111.11,44.6 111.24,44.6 111.41,44.77 111.54,44.77 111.73,44.58 111.73,44.42 111.44,44.13 111.44,43.97 111.6,43.81 111.76,43.81 112.05,44.1 112.21,44.1 112.37,43.93 112.37,43.77 112.08,43.48 112.08,43.32 112.24,43.15 112.4,43.15 112.7,43.45 113.14,43.45 113.39,43.2 113.39,39.02 112.83,38.46 112.83,38.21 112.92,38.12 113.1,38.12 113.2,38.02 113.2,37.83 113.1,37.74 112.92,37.74 112.83,37.64 112.83,37.45 112.92,37.35 113.1,37.35 113.2,37.26 113.2,37.07 113.1,36.97 112.92,36.97 112.83,36.88 112.83,36.66 112.94,36.55 113.41,36.55 113.5,36.45 113.5,36.26 113.41,36.17 112.96,36.17 112.87,36.07 112.87,35.88 112.96,35.79 113.31,35.79 113.41,35.69 113.41,35.55 113.23,35.37 113.23,35.09 118.36,29.96 118.36,26 118.66,25.71 118.66,25.55 118.35,25.24 118.35,24.93 118.51,24.77 118.67,24.77 119,25.1 119.16,25.1 119.32,24.94 119.32,24.78 119.02,24.48 119.02,24.32 119.62,23.71 119.62,23.2 119.78,23.04 120.37,23.04 120.49,22.93 120.49,22.7 120.37,22.59 120.05,22.59 119.88,22.41 119.88,21.65 119.98,21.55 120.12,21.55 120.22,21.45 120.22,21.26 120.32,21.17 120.51,21.17 120.6,21.26 120.6,21.45 120.7,21.55 120.89,21.55 120.98,21.45 120.98,21.26 121.08,21.17 121.27,21.17 121.36,21.26 121.36,21.45 121.46,21.55 121.68,21.55 121.83,21.39 121.83,20.96 122.06,20.73 122.82,20.73 122.95,20.6 122.95,20.31 122.84,20.2 122.26,20.2 122.19,20.12 122.19,19.76 v8(122.33,19.63)
  BOTTOM w0.152: UCPU1.AN50 108.91,48.92 v8(108.84,48.92)
DDR_B_CA1_7: length 55.1
  TOP w0.076: 120.37,17.61 120.91,17.61 121.22,17.91 121.69,17.91 122.64,18.87 UD44.E2
  TOP w0.152: 120.37,17.61 119.53,16.77 RD36.1 ; UD44.E2 122.98,19.56 v8(122.98,19.63)
  IN2 w0.095: v8(122.98,19.63) 123.29,19.63 123.41,19.74 123.41,20.02 123.52,20.13 126.01,20.13 126.13,20.25 126.13,20.48 126.01,20.59 123.52,20.59 123.41,20.71 123.41,22.34 123.58,22.51 125.34,22.51 125.49,22.66 125.49,22.94 125.34,23.1 123.36,23.1 123.2,22.94 122.9,22.94 122.78,22.82 122.78,22.53 122.67,22.41 122.44,22.41 122.33,22.53 122.33,22.82 122.21,22.94 121.98,22.94 121.87,22.82 121.87,22.53 121.75,22.41 121.53,22.41 121.41,22.53 121.41,22.82 121.3,22.94 121.02,22.94 119.81,24.15 119.81,25.05 118.67,26.19 118.67,30.06 113.79,34.94 113.79,37.08 113.51,37.36 113.51,38.74 113.68,38.9 113.68,43.54 113.23,43.98 112.87,43.98 111.19,45.66 111.19,49.03 110.87,49.35 110.05,49.35 v8(109.74,49.04)
  BOTTOM w0.152: v8(109.74,49.04) 109.95,49.04 UCPU1.AN48
DDR_B_CA1_8: length 48.2
  TOP w0.152: RD38.1 118.81,17.23 v8(119.37,17.79) 119.65,18.07 120.82,18.07 121.15,18.4 121.58,18.4 121.99,18.81 UD44.D2
  IN2 w0.095: v8(107.01,48.92) 107.46,48.47 107.46,46.21 108.16,45.52 108.16,45.05 109.79,43.41 109.79,41.83 109.88,41.74 109.88,34.54 112.83,31.59 112.83,30.27 113.45,29.65 113.45,29.3 113.45,23.3 114.57,22.18 114.57,20.3 116.11,18.76 116.27,18.76 117.03,19.51 117.19,19.51 117.35,19.35 117.35,19.19 116.59,18.43 116.59,18.27 116.76,18.11 116.92,18.11 117.67,18.87 117.83,18.87 118,18.7 118,18.54 117.24,17.79 117.24,17.63 117.45,17.42 117.63,17.42 118,17.79 v8(119.37,17.79)
  BOTTOM w0.152: v8(107.01,48.92) 107.08,48.92 UCPU1.AN53
DDR_B_CA1_9: length 50.2
  TOP w0.152: UD44.C2 120.93,18.81 119.81,18.81 119.78,18.78 v8(119.24,18.78) 118.28,17.81 RD40.1
  IN2 w0.095: v8(119.24,18.78) 119.24,19.05 119.04,19.24 118.88,19.24 118.71,19.07 118.54,19.07 118.38,19.23 118.38,19.39 118.56,19.57 118.56,19.73 118.4,19.89 118.23,19.89 118.06,19.72 117.9,19.72 117.74,19.88 117.74,20.04 117.91,20.21 117.91,20.38 117.75,20.54 117.59,20.54 117.41,20.36 117.25,20.36 117.09,20.52 117.09,20.69 117.26,20.86 117.26,21.02 117.1,21.18 116.94,21.18 116.77,21.01 116.6,21.01 116.44,21.17 116.44,21.33 116.62,21.51 116.62,21.67 116.46,21.83 116.29,21.83 116.12,21.66 115.96,21.66 115.8,21.82 115.8,21.98 115.97,22.15 115.97,22.32 115.81,22.48 115.65,22.48 115.47,22.3 115.31,22.3 115.15,22.46 115.15,22.63 115.32,22.8 115.32,22.96 115.2,23.08 115.2,27.83 115.09,27.95 114.17,27.95 114.06,28.06 114.06,28.29 114.17,28.4 115.09,28.4 115.2,28.52 115.2,28.97 115.09,29.08 114.68,29.08 114.57,29.2 114.57,29.42 114.68,29.54 115.09,29.54 115.2,29.65 115.2,29.88 115.09,30 114.1,30 113.98,30.11 113.98,30.34 114.1,30.45 114.8,30.45 114.92,30.58 114.92,30.73 114.77,30.88 114.61,30.88 114.39,31.09 114.39,31.26 114.2,31.45 113.92,31.45 113.74,31.27 113.73,31.27 113.72,31.27 113.6,31.27 113.47,31.41 113.47,31.54 113.65,31.71 113.65,32 113.47,32.18 113.33,32.18 113.26,32.1 113.13,32.1 112.99,32.24 112.99,32.37 113.06,32.45 113.06,32.58 112.93,32.71 112.79,32.71 112.72,32.64 112.59,32.64 112.45,32.78 112.45,32.91 112.53,32.98 112.53,33.12 112.39,33.25 112.26,33.25 112.18,33.18 112.05,33.18 111.91,33.32 111.91,33.45 111.99,33.52 111.99,33.66 110.45,35.19 110.45,41.98 110.36,42.07 110.36,43.65 108.92,45.09 108.92,45.74 108.45,46.2 108.45,48.39 v8(107.93,48.92)
  BOTTOM w0.152: v8(107.93,48.92) 107.99,48.92 UCPU1.AN52
DDR_B_CA2_0: length 54.5
  TOP w0.152: RD42.1 145.12,17.7 144.65,18.17 v8(144.65,18.48) 144.71,18.54 UD43.R2
  IN1 w0.114: v9(114.38,39.04) 114.43,38.99 114.43,35.42 116.96,32.89 124.76,32.89 126.95,30.7 130.04,30.7 133.11,27.63 133.11,21.05 133.16,21 134.46,19.7 135.2,19.7 135.66,19.24 136.75,19.24 136.75,19.24 136.79,19.24 137.06,19.52 137.95,19.52 138.55,18.91 138.55,18.87 139.27,18.16 142.59,18.16 143.03,18.59 144.54,18.59 v8(144.65,18.48)
  GND1 w0.152: v3(114.07,39.27) 114.15,39.27 v9(114.38,39.04)
  GND3 w0.152: v3(114.07,39.27) 114.08,39.3 v4(114.08,39.64)
  BOTTOM w0.076: v4(114.08,39.64) 114.08,40.23 113.8,40.51 113.8,44.25 UCPU1.BA43
DDR_B_CA2_1: length 58.5
  TOP w0.152: UD43.P2 144.06,18.18 144.14,18.1 v8(144.16,18.1) 144.54,17.72 RD44.1
  IN1 w0.114: v8(144.16,18.1) 143.49,17.43 142.43,17.43 142.16,17.16 139.75,17.16 139.4,17.51 139.1,17.51 137.98,18.63 137.98,18.67 137.71,18.94 137.32,18.94 137.01,18.64 134.74,18.64 134.74,18.63 134.49,18.63 134.49,18.64 134.45,18.64 132.5,20.58 132.5,27.38 129.8,30.08 127.88,30.08 127.78,29.99 127.78,29.85 127.69,29.75 127.5,29.75 127.4,29.85 127.4,29.96 127.31,30.06 126.13,30.06 124.98,31.2 124.98,31.33 125.15,31.51 125.15,31.64 125.02,31.77 124.88,31.77 124.71,31.6 124.58,31.6 124.44,31.74 124.44,31.87 124.5,31.94 124.5,32.1 124.32,32.28 122.17,32.28 122.17,32.29 116.58,32.29 113.42,35.44 113.42,38.22 v9(113.69,38.49)
  GND1 w0.152: v3(114,38.69) 113.89,38.69 v9(113.69,38.49)
  GND3 w0.152: v3(114,38.69) 113.96,38.69 v4(113.72,38.45)
  BOTTOM w0.076: v4(113.72,38.45) v2(113.72,38.87) 113.72,38.96 113.63,39.04 113.63,43.28 113.27,43.65 113.21,43.8 113.21,43.99 113.26,44.18 113.26,44.37 113.22,44.48 113.22,44.87 UCPU1.AY43
