# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PD3_GPIO0: length 4.8
  IN4 w0.076: v5(285.52,14.32) 285.52,13.75 v5(285.18,13.41)
  BOTTOM w0.095: R5818.1 282.4,12.2 282.4,12.2 282.5,12.2 282.95,12.64 R5786.1 283.41,12.78 283.48,12.72 284.16,12.72 284.86,13.41 v5(285.18,13.41)
PD3_GPIO1: length 8
  IN4 w0.076: v5(285.84,14.66) 285.83,14.67 284.91,14.67 284.67,14.43 284.67,14.18 v5(284.62,14.13)
  BOTTOM w0.095: U21.C2 285.68,14.82 v5(285.84,14.66) ; R229.1 279.83,13.84 280.19,13.48 281.08,13.48 R5769.1 281.72,13.21 283.26,13.21 283.41,13.06 v2(283.78,13.06) 284.62,13.9 v5(284.62,14.13)
PD3_GPIO2: length 5.8
  IN4 w0.076: v5(294.53,17.06) 294.41,17.18 291.73,17.18 289.88,15.32 v5(289.52,15.32)
PD3_GPIO4: length 5.5
  IN4 w0.076: v5(294.49,16.22) 291.07,16.22 289.67,14.82 v5(289.52,14.82)
PD3_GPIO5: length 7.4
  IN4 w0.076: v5(289.52,15.82) 289.4,15.82 288.81,16.42 288.81,18.24 288.85,18.28 288.85,20.03 288.65,20.24 288.65,20.94 288.66,20.95 v5(288.66,20.96)
  BOTTOM w0.095: v5(288.66,20.96) 288.66,20.97 288.58,21.05 288.58,21.97 289.07,22.45 R5791.1
PD3_GPIO6: length 3.4
  IN4 w0.076: v5(291.37,19.12) 290.73,19.12 290.34,18.73 290.34,17.64 v5(289.52,16.83)
PD3_GPIO7: length 8.6
  IN4 w0.076: v5(294.49,15.63) 294.1,16.02 291.15,16.02 289.62,14.48 289.3,14.48 288.77,13.96 288.43,13.96 288.23,14.16 288.23,15.12 v5(288.02,15.32)
PD3_GPIO8: length 4.3
  IN4 w0.076: v5(287.52,17.33) 287.52,17.36 287.26,17.62 286.91,17.62 286.64,17.89 286.64,19.54 286.7,19.61 286.7,20.4 v5(287.11,20.8)
PD3_GPIO8_EXT: length 2.8
  BOTTOM w0.095: R5793.1 288.9,23.02 288.27,22.38 R5792.2 288.06,22.38 287.61,21.93 287.38,21.93 287.1,21.65 R234.2
PD3_HOLD#: length 11.8
  TOP w0.095: R226.2 288.18,18.4 285.79,18.4 285.46,18.73 281.31,18.73 280.69,19.35 v2(280.69,20.26) 280.69,20.63 280.96,20.9 UT6.7
PD3_LPS1: length 5.1
  BOTTOM w0.305: PR264.2 196.39,4.49 196.92,3.96 196.92,3.24 196.75,3.08 PQ158.2 197.1,2.07 197.73,2.71 PR262.1
PD3_LPS2: length 2.1
  BOTTOM w0.095: 189.5,7.39 189.5,8.6 v2(190.13,9.24)
PD3_USBC_AMSEL: length 13.2
  TOP w0.095: R5835.2 280.26,28.22 v7(280.35,28.13)
  IN1 w0.076: v7(280.35,28.13) 280.35,27.87 280.81,27.41 280.81,22.36 281.98,21.19 282,21.19 282.12,21.06 284.76,21.06 v9(285.15,20.68)
  GND1 w0.095: v3(285.25,20.36) 285.25,20.58 v9(285.15,20.68)
  GND3 w0.095: v4(285.01,20.13) 285.24,20.36 v3(285.25,20.36)
PD3_USBC_AMSEL_R: length 17.5
  TOP w0.095: R5835.1 277.99,28.23 R5833.1 277.99,29.23 v2(277.99,30.3) 277.99,30.44 276.08,32.35 274.95,32.35 274.74,32.57 v1(274.12,32.57) ; v1(274.52,23.33) 274.49,23.33 274.14,23.68 U30.23
  IN1 w0.076: v1(274.12,32.57) 274.14,32.54 274.14,28.89 274.54,28.5 274.54,23.35 v1(274.52,23.33)
PD3_USBC_EN: length 5.7
  TOP w0.095: R5804.2 R5803.1 271.17,30.07 271.17,29.65 v2(271.15,29.62) 270.8,29.27 270.8,28.95 270.6,28.75 270.6,27.61 270.31,27.33 U30.35
PD3_USBC_POL: length 39.3
  TOP w0.095: U30.38 269.11,26.82 269.33,27.03 269.33,27.45 268.9,27.88 268.9,28.4 R5805.1 267.93,28.53 v7(267.91,28.51) 267.88,28.51 267.74,28.37 v2(267.74,27.5)
  IN1 w0.076: v9(274.06,20.96) 274.06,21.44 273.58,21.92 273.58,28.27 273.2,28.65 273.2,29.55 272.58,30.17 269.16,30.17 267.91,28.92 v7(267.91,28.51)
  GND1 w0.095: v9(274.06,20.96) 274.06,20.86 v3(273.77,20.57)
  IN3 w0.064: v3(280.9,12.5) 280.52,12.88 276.23,12.88 275.06,14.05 274.11,14.05 273.34,14.82 273.34,16.34 273.94,16.94 274.42,16.94 275.01,17.53 275.01,20.37 274.82,20.57 v3(273.77,20.57)
  GND3 w0.095: v3(280.9,12.5) 280.65,12.25 v4(280.65,12.19)
  BOTTOM w0.095: R5786.2 282.09,12.78 281.88,12.57 280.84,12.57 280.65,12.38 v4(280.65,12.19)
PD_MRESET_A: length 4
  TOP w0.076: U19.E11 19.57,28.21 19.57,27.85
  TOP w0.095: 19.57,27.85 19.57,27.49 19.04,26.96
  TOP w0.127: v7(18.89,26.31) 18.89,26.8 19.04,26.96
  IN1 w0.076: v7(18.89,26.31) 18.89,25.31 v7(19.39,24.8)
PD_MRESET_B: length 3.8
  TOP w0.095: U20.E11 31.89,30.41 31.89,29.37 31.28,28.76 R211.1 30.82,27.85 30.74,27.93 R209.1
PD_MRESET_C: length 5.8
  BOTTOM w0.095: R239.1 294.53,17.94 v2(293.37,17.94) 293.23,17.8 R237.1 291.97,17.8 291.11,16.94 291.11,16.5 290.43,15.82 U21.E11
PECI_EC: length 142.8
  IN1 w0.076: v9(14.62,19.88) 14.62,19.44 14.15,18.97 13.29,18.97 12.56,18.25 12.56,17.95 v7(11.65,17.04)
  GND1 w0.095: v3(14.62,20.32) v9(14.62,19.88)
  GND3 w0.095: v3(14.62,20.32) 14.77,20.47 v4(14.77,20.86)
  IN4 w0.076: v5(105.81,69.59) 105.67,69.73 105.67,70.24 104.94,70.96 102.64,70.96 102.2,70.52 102.2,69.17 102.6,68.77 102.6,68.5 101.86,67.76 98.93,67.76 98.17,67 98.17,66.24 98.17,65.68 96.52,64.04 93.25,64.04 92.67,63.46 92.67,63.08 92.35,62.76 90.08,62.76 89.81,63.03 86.26,63.03 85.84,63.45 85.84,63.45 84.28,65 78.44,65 78.11,65.34 61.05,65.34 60.51,65.88 56.7,65.88 54.56,63.73 54.56,62.1 53.07,60.62 53.07,60.47 51.83,59.22 51.83,56.52 50.17,54.86 49.24,54.86 48.92,54.53 48.92,51.7 48.03,50.81 48.03,47.12 47.58,46.67 44.93,46.67 v5(44.15,45.88)
  BOTTOM w0.076: UCPU1.A54 106.52,66.48 106.52,67.34 106.76,67.57 106.76,69.34 106.5,69.59 v5(105.81,69.59)
  BOTTOM w0.095: v5(44.15,45.88) 43.72,45.88 43.28,45.45 38.33,45.45 36.78,43.9 36.78,41.65 38.1,40.34 38.1,39.71 37.84,39.45 36.73,39.45 35.93,38.66 v2(35.93,37.08) 35.93,35.05 34.69,33.81 33.79,33.81 33.48,34.11 31.32,34.11 29.29,32.09 27.7,32.09 27.08,31.46 26.43,31.46 25.45,30.49 24.43,30.49 23.73,29.8 23.73,29.1 21.6,26.96 21.6,25.72 19.94,24.06 19.94,23.04 18.82,21.91 17.07,21.91 16.01,20.86 v4(14.77,20.86)
PECI_EC_R: length 2.6
  TOP w0.095: RE153.1 12.74,17.22 UE3.K13
PM_SYS_RESET#: length 2.3
  TOP w0.095: RC87.1 v2(139.1,64.68) 138.44,64.68 138.27,64.85 RC248.1
PME#: length 2.6
  TOP w0.095: T12.1 130.47,47.96 130.47,46.82 v8(130.89,46.4)
  BOTTOM w0.112: v8(130.89,46.4) 131.2,46.71 UCPU1.AU11
POWER_SW_IN#: length 11
  TOP w0.095: UE3.D5 v8(21.93,12.84)
  IN4 w0.076: v5(25.03,9.51) 24.82,9.72 24.82,10.23 23.79,11.26 23.64,11.26 23.4,11.5 23.4,11.91 22.47,12.84 v8(21.93,12.84)
  BOTTOM w0.095: v5(25.03,9.51) 25.19,9.35 25.19,8.47 24.74,8.02 CE69.1 RE184.2 25.65,7.78 RE187.1 26.65,6.78 v2(26.65,5.75)
PRIM_PWRGD_GPIO024: length 11.7
  TOP w0.095: RE247.1 31.5,15.34 v2(31.5,14.38) 31.53,14.35 31.53,11.57 30.76,10.8 28.88,10.8 28.4,11.28 26.61,11.28 26.13,10.81 25.51,10.81 UE3.C1
PRODUCT_ID_EC: length 7.1
  TOP w0.095: RE250.2 29.38,17.23 29.35,17.2 RE249.1 29.33,16.8 28.76,17.36 27.01,17.36 26.86,17.21 v2(26.53,17.21) 25.73,17.21 25.59,17.06 25.59,17.06 25.3,16.77 24.26,16.77 UE3.J2
PTP_DIS#: length 177.3
  GND1 w0.095: v1(22.3,14.01) 22.3,13.94 v3(22.52,13.72)
  GND3 w0.095: v6(22.93,13.57) 22.67,13.57 v3(22.52,13.72)
  IN4 w0.076: v6(22.93,13.57) 23.2,13.29 23.2,13 27.4,8.81 34.51,8.81 35.23,8.08 38.74,8.08 39.62,8.96 49.07,8.96 51.27,6.76 58.73,6.76 58.81,6.84 65.08,6.84 65.8,6.11 67.93,6.11 68.22,5.82 69.25,5.82 69.43,5.65 76.17,5.65 79.74,9.21 99.13,9.21 100.68,10.76 110.03,10.76 111.07,11.81 114.89,11.81 114.96,11.88 119.74,11.88 120.34,12.48 120.37,12.48 120.46,12.57 125.78,12.57 125.89,12.68 129.57,12.68 129.7,12.55 139.85,12.55 139.98,12.68 144.95,12.68 145.47,12.16 146.36,12.16 146.55,11.97 149.92,11.97 150.51,12.56 v5(150.9,12.56) ; v5(174.92,6.1) 172.53,8.5 170.54,8.5 169.39,9.65 165.16,9.65 163.92,8.4 161.19,8.4 157.19,4.4 155.07,4.4 154.37,5.1 152.74,5.1 151.7,6.15 151.7,6.94 v5(151.82,7.06)
  BOTTOM w0.095: v2(174.26,8.83) 174.47,9.05 175.82,9.05 176.08,8.79 JTP1.6 176.08,6.45 175.73,6.1 v5(174.92,6.1) ; v5(150.9,12.56) 151.06,12.39 151.06,10.95 151.23,10.78 151.67,10.78 152.17,10.29 152.17,9.31 151.82,8.96 v5(151.82,7.06)
PTP_INT#_EC: length 4.5
  TOP w0.095: RE251.1 27.48,15.96 24.42,15.96 24.28,15.82 24.28,15.18 23.92,14.82 UE3.G2
PWM1_GT: length 25.5
  TOP w0.095: v8(63.34,40.38) 63.34,39.95 v2(63.53,39.76)
  TOP w0.203: v7(44.49,43.82) 44.49,43.9 44.13,44.25 43.57,44.25 43.37,44.46 PU1000.12
  IN1 w0.254: v7(44.49,43.82) 46.2,43.82 46.62,43.4 47.11,43.4 47.53,43.82 48.83,43.82 50.92,41.74 50.94,41.74 51.22,41.46 51.22,41.43 53.43,39.22 56.33,39.22 57.06,39.95 62.91,39.95 v8(63.34,40.38)
  BOTTOM w0.254: v8(63.34,40.38) 63.34,40.66 63.91,41.23 PU1150.1
PWM1_VCORE: length 29.1
  TOP w0.095: v8(62.38,58.53) 62.38,58.64 v2(62.07,58.95)
  TOP w0.203: PU1000.25 43.37,51.14 43.57,51.34 v1(44.74,51.34)
  GND1 w0.254: v1(44.74,51.34) 44.95,51.34 v3(45.63,52.03)
  IN3 w0.254: v8(62.38,58.53) 62.87,58.04 62.87,53.3 61.9,52.34 60.84,52.34 60.14,53.04 53.93,53.04 52.71,51.82 48.87,51.82 47.92,52.77 46.24,52.77 45.63,52.17 v3(45.63,52.03)
  BOTTOM w0.254: v8(62.38,58.53) 62.49,58.53 62.84,58.88 PU1100.1
PWM2_GT: length 23.1
  TOP w0.095: v8(60.46,49.03) v2(59.04,49.03)
  TOP w0.203: PU1000.13 44.57,45.68 v1(45,45.24)
  TOP w0.254: v8(60.46,49.03) 60.85,49.03 61.13,49.31 61.16,49.31 PR1102.1
  IN1 w0.254: v1(45,45.24) 45.14,45.1 46.02,45.1 47.54,46.63 51.26,46.63 52.67,45.22 58.34,45.22 61.09,47.97 61.09,48.51 60.57,49.03 v8(60.46,49.03)
PWM2_PH: length 79.8
  TOP w0.095: PR1110.1 v2(70.39,49.38)
  TOP w0.254: v1(49.44,53.45) 48.91,52.92 PR1113.1
  GND1 w0.254: v1(49.44,53.45) 49.19,53.45 v3(49.09,53.35)
  IN2 w0.254: v8(72.46,52.33) 72.41,52.37 69.84,52.37 68.64,53.58 63.89,53.58 62.69,52.38 62.69,51.91 60.81,50.03 57.41,50.03 56.91,50.54 56.89,50.54 55.62,51.8 51.06,51.8 50.51,52.35 50.09,52.35 v3(49.09,53.35)
  IN3 w0.254: v8(75.15,49.35) 75.34,49.17 75.34,48.53 74.44,47.63 70.43,47.63 69.24,46.44 69.24,42.27 68.58,41.61 67.54,41.61 66.73,40.8 64.86,40.8 64.05,41.61 61.61,41.61 59.92,39.91 53.7,39.91 50.48,43.13 48.54,43.13 46.89,44.79 v3(42.71,44.79)
  GND3 w0.254: v4(42.61,44.33) 42.61,44.69 v3(42.71,44.79)
  BOTTOM w0.254: PR1112.1 42.56,44.28 v4(42.61,44.33) ; v8(75.15,49.35) 75.11,49.31 PL1107.1 72.61,52.14 72.46,52.29 v8(72.46,52.33)
  vias: v8(68.96,50.95) v8(68.96,50.26)
PWM2_VCORE: length 23.2
  TOP w0.095: v2(60.03,48.1) 60.15,48.1 60.46,48.42 v8(60.49,48.42)
  TOP w0.203: v7(44.19,52.11) 43.74,51.67 43.17,51.67 42.97,51.47 PU1000.26
  TOP w0.254: v8(60.49,48.42) 61.17,48.42 PR1103.1
  IN1 w0.254: v7(44.19,52.11) 44.12,52.04 44.12,51.22 44.55,50.79 44.92,50.79 46.88,48.83 50.84,48.83 52.73,46.94 59.39,46.94 60.49,48.04 v8(60.49,48.42)
PWM_SA: length 22.9
  TOP w0.203: PU1000.35 39.37,51.81 v7(39.38,51.82)
  IN1 w0.254: v7(39.38,51.82) 39.38,51.31 39.74,50.96 42.74,50.96 43.8,49.9 43.8,47.46 44.19,47.08 51.42,47.08 52.87,45.63 55.41,45.63 55.97,46.19 v8(55.97,46.29)
  BOTTOM w0.254: v8(55.97,46.29) 55.84,46.42 PU1151.1
PWR_MONITOR_EC_SMBCLK: length 197.1
  IN1 w0.076: v7(173.09,22.5) 172.34,21.75 171.85,21.75 170.26,20.15 157.76,20.15 156.68,19.07 153.45,19.07 152.11,17.73 149.3,17.73 148.25,16.68 147.61,16.68 147.43,16.86 145.41,16.86 143.94,15.39 137.76,15.39 137.17,14.8 132.63,14.8 132.12,15.31 126.98,15.31 126.48,15.8 116.27,15.8 114.9,14.43 106.69,14.43 105.7,15.42 101.94,15.42 100.93,14.42 100.48,14.42 98.84,12.79 90.84,12.79 90.68,12.94 80.42,12.94 75.18,7.71 71.85,7.71 71.64,7.92 66.97,7.92 66.4,8.49 61.75,8.49 61.31,8.93 60.89,8.93 59.41,10.41 53.17,10.41 49.55,14.03 42.1,14.03 40.88,15.24 38.25,15.24 36.96,16.53 32.32,16.53 29.7,19.15 27.22,19.15 26.76,19.61 24.17,19.61 23.84,19.94 22.52,19.94 22.4,19.82 20.54,19.82 v9(20.25,20.12)
  GND1 w0.095: v1(15.9,10.01) 15.62,10.29 v3(15.53,10.29) ; v3(19.9,20.5) 20.25,20.16 v9(20.25,20.12)
  IN2 w0.064: v3(19.9,20.5) 19.06,19.66 17.76,19.66 13.11,15.01 12.89,15.01 11.05,13.17 9.65,13.17 8.16,11.68 8.16,8.02 9.27,6.91 9.27,6.28 9.69,5.86 10.27,5.86 11.27,6.86 11.27,7.58 13.5,9.8 14.18,9.8 14.67,10.29 v3(15.53,10.29)
PWR_MONITOR_EC_SMBDAT: length 198.1
  IN1 w0.076: v7(173.83,22.5) 173.5,22.17 173.04,22.17 172.42,21.54 171.94,21.54 170.35,19.95 157.84,19.95 156.77,18.87 153.54,18.87 152.19,17.53 149.38,17.53 148.34,16.48 147.52,16.48 147.35,16.66 145.5,16.66 143.99,15.15 137.81,15.15 137.26,14.6 132.55,14.6 132.04,15.11 126.89,15.11 126.4,15.6 116.35,15.6 114.98,14.23 106.61,14.23 105.61,15.22 102.02,15.22 101.02,14.22 100.56,14.22 98.93,12.58 90.75,12.58 90.6,12.74 80.5,12.74 75.27,7.51 71.76,7.51 71.55,7.72 66.89,7.72 66.32,8.29 61.67,8.29 61.23,8.73 60.8,8.73 60.47,9.06 60.37,9.06 60.16,8.86 60.05,8.86 59.95,8.97 59.95,9.07 60.15,9.28 60.15,9.39 60.04,9.49 59.93,9.49 59.52,9.08 59.41,9.08 59.31,9.19 59.31,9.3 59.72,9.71 59.72,9.82 59.33,10.21 58.92,10.21 58.84,10.13 58.84,9.32 58.76,9.24 58.62,9.24 58.54,9.32 58.54,10.13 58.47,10.21 58.32,10.21 58.25,10.13 58.25,9.09 58.17,9.01 58.03,9.01 57.95,9.09 57.95,10.13 57.88,10.21 57.16,10.21 57.09,10.13 57.09,8.99 57.02,8.92 56.86,8.92 56.78,9 56.78,10.13 56.71,10.21 56.55,10.21 56.48,10.13 56.48,9.85 56.4,9.77 56.25,9.77 56.17,9.85 56.17,10.13 56.1,10.21 55.95,10.21 55.87,10.13 55.87,8.97 55.82,8.92 55.64,8.92 55.56,9 55.56,10.13 55.49,10.21 55.34,10.21 55.26,10.13 55.26,8.99 55.18,8.91 55.03,8.91 54.95,8.99 54.95,10.13 54.88,10.21 54.73,10.21 54.65,10.13 54.65,8.99 54.57,8.91 54.42,8.91 54.35,8.99 54.35,10.13 54.27,10.21 54.12,10.21 54.04,10.13 54.04,8.97 53.96,8.89 53.81,8.89 53.74,8.97 53.74,10.13 53.66,10.21 53.46,10.21 53.37,10.13 53.37,9.32 53.32,9.27 53.12,9.27 53.04,9.35 53.04,10.25 52.93,10.36 52.82,10.36 52.49,10.03 52.38,10.03 52.27,10.14 52.27,10.25 52.6,10.58 52.6,10.69 52.5,10.8 52.39,10.8 52.06,10.46 51.95,10.46 51.84,10.57 51.84,10.68 52.17,11.01 52.17,11.12 52.07,11.23 51.96,11.23 51.63,10.9 51.52,10.9 51.41,11 51.41,11.11 51.74,11.44 51.74,11.55 51.63,11.66 51.53,11.66 51.2,11.33 51.09,11.33 50.98,11.43 50.98,11.54 51.31,11.87 51.31,11.98 51.2,12.09 51.09,12.09 50.76,11.76 50.66,11.76 50.55,11.87 50.55,11.97 50.88,12.3 50.88,12.41 49.47,13.82 42.01,13.82 40.8,15.04 38.16,15.04 36.88,16.33 33.79,16.33 33.72,16.25 33.72,15.89 33.64,15.82 33.49,15.82 33.41,15.89 33.41,16.25 33.34,16.33 33.18,16.33 33.11,16.25 33.11,15.41 33.03,15.34 32.88,15.34 32.8,15.41 32.8,16.25 32.73,16.33 32.24,16.33 29.62,18.94 27.14,18.94 26.68,19.4 24.09,19.4 23.75,19.74 22.61,19.74 22.49,19.62 v7(17.5,19.62)
PWR_MONITOR_I2CCLK: length 67.6
  IN1 w0.076: v9(156.6,22.8) 157.45,22.8 157.82,22.44 167.68,22.44 169.97,24.72 172,24.72 172.66,24.06 172.66,24.01 172.66,23.93 v7(172.45,23.72)
  GND1 w0.095: v3(156.26,22.81) 156.6,22.81 v9(156.6,22.8)
  IN2 w0.064: v8(131.33,53.45) 132.01,52.77 134.94,52.77 134.99,52.82 135.38,52.82 135.56,52.64 135.56,52.13 136.7,50.99 136.7,48.8 136.94,48.56 136.94,46.09 138.3,44.73 139.84,44.73 141.02,43.56 141.53,43.56 141.99,43.1 141.99,41.38 144.26,39.11 150.09,39.11 151.2,38.01 151.2,35.33 152.76,33.77 152.76,33.23 154.9,31.09 154.9,29.9 155.87,28.92 155.87,23.14 156.15,22.86 156.21,22.86 v3(156.26,22.81)
  BOTTOM w0.076: UCPU1.AH12 130.93,52.15 131.27,52.49 131.27,53.39 v8(131.33,53.45)
PWR_MONITOR_I2CSDA: length 67.2
  IN1 w0.076: v7(173.08,23.73) 172.87,23.94 172.87,24.01 172.87,24.14 172.08,24.92 169.88,24.92 167.6,22.64 157.9,22.64 157.39,23.16 156.65,23.16 v9(156.61,23.19)
  GND1 w0.095: v3(156.27,23.39) 156.46,23.19 v9(156.61,23.19)
  IN2 w0.064: v8(131.96,53.43) 131.96,53.08 132.09,52.96 134.86,52.96 134.92,53.02 135.46,53.02 135.75,52.72 135.75,52.21 136.89,51.07 136.89,48.88 137.13,48.64 137.13,46.17 138.38,44.92 139.92,44.92 141.1,43.75 141.61,43.75 142.18,43.17 142.18,41.46 144.34,39.3 150.17,39.3 151.39,38.08 151.39,35.41 152.95,33.85 152.95,33.31 155.09,31.17 155.09,29.97 156.06,29 156.06,23.6 v3(156.27,23.39)
  BOTTOM w0.076: v8(131.96,53.43) 131.9,53.37 131.9,52.65 131.58,52.33 UCPU1.AH11
PWR_MONITOR_SMBCLK: length 73.7
  IN1 w0.076: v7(172.46,22.5) 171.98,22.97 169.9,22.97 168.65,21.72 v9(156.72,21.72)
  GND1 w0.095: v9(156.72,21.72) 156.72,21.34 v3(156.78,21.29)
  IN2 w0.064: v3(156.78,21.29) 156.78,21.59 157.25,22.06 157.25,25.78 156.57,26.46 156.57,29.79 155.55,30.82 155.55,31.93 151.85,35.62 151.85,38.29 150.39,39.76 144.55,39.76 142.69,41.61 142.69,44.35 142.01,45.03 140.67,45.03 140.45,45.25 140.45,46.05 140.79,46.39 140.79,46.99 141.56,47.76 141.56,52.36 139.96,53.96 138.83,53.96 138.13,54.66 138.13,56.04 137.52,56.66 136.47,56.66 136.2,56.92 132.4,56.92 v3(132.31,56.84)
  GND3 w0.095: v3(132.31,56.84) v4(132.65,56.84)
  BOTTOM w0.076: v4(132.65,56.84) 132.54,56.95 132.54,57.39 132.88,57.73 UCPU1.R9
PWR_MONITOR_SMBDAT: length 67.2
  IN1 w0.076: v9(157.06,22.02) 157.15,21.93 168.57,21.93 169.82,23.18 173.81,23.18 174.4,22.58 v7(174.4,22.49)
  GND1 w0.095: v9(157.06,22.02) 156.9,22.18 v3(156.76,22.18)
  IN2 w0.064: v3(137.24,56.05) 137.26,56.03 137.71,56.03 137.94,55.79 137.94,54.58 138.75,53.77 139.88,53.77 141.37,52.28 141.37,47.84 140.6,47.07 140.6,46.47 140.26,46.13 140.26,45.18 140.59,44.84 141.93,44.84 142.5,44.27 142.5,41.53 144.47,39.56 150.31,39.56 151.66,38.21 151.66,35.54 155.36,31.85 155.36,30.74 156.38,29.71 156.38,26.38 157.06,25.7 157.06,22.49 v3(156.76,22.18)
  GND3 w0.095: v3(137.24,56.05) 136.95,56.05 v4(136.91,56.08)
PWRGD_XDP: length 9.5
  TOP w0.095: v7(43.98,67.28) RC250.2 45.44,67.28 v2(45.9,66.82) ; v7(41.83,71.78) 41.68,71.93 JXDP1.39
  IN1 w0.076: v7(41.83,71.78) 42.6,71.01 42.6,67.91 42.7,67.81 43.45,67.81 v7(43.98,67.28)
PWRM_SCL: length 6
  TOP w0.095: R5820.1 172.41,23.14 171.68,23.87 v2(171.5,23.87) 171.5,22.85 RE232.1 171.69,22.61 172.38,21.91 R283.1 R285.1 173.09,20.91 173.36,20.65 U24.C4
PWRM_SDA: length 6.4
  TOP w0.095: R284.1 174.4,21.91 R286.1 ; R286.1 173.83,21.56 173.73,21.45 173.73,21.2 173.86,21.07 U24.D4 174.49,20.96 v2(175.05,20.96) 175.05,20.05 RE233.1 ; R286.1 173.71,21.91 173.46,22.17 173.46,22.76 R5821.1
REM_DIODE1_N: length 228.9
  TOP w0.127: QE12.3 124.65,56.26 122.42,56.26 122.25,56.09 v1(121.76,56.09) ; UE3.A8 19.31,9.81 19.31,9.57 18.68,8.95 18.68,7.98 v1(18.51,7.8)
  GND1 w0.127: v1(121.76,56.09) v3(122.13,56.09) ; v3(19.08,7.93) 18.95,7.8 v1(18.51,7.8)
  IN2 w0.127: v3(159.84,15.06) 159.89,15.11 159.89,15.29 156.01,19.17 156.01,20.83 155.49,21.34 155.49,21.93 154.86,22.56 154.86,28.32 154.02,29.15 154.02,30.65 151.42,33.25 151.42,33.85 150.34,34.94 150.34,37.58 149.74,38.17 143.93,38.17 141.08,41.03 141.08,42.17 140.45,42.81 139.34,42.81 138.99,42.46 138.12,42.46 136.04,44.54 136.04,48.08 135.84,48.29 135.84,49.61 134.81,50.64 134.81,51.66 134.18,52.3 131.78,52.3 131.36,52.71 131.11,52.71 130.85,52.97 122.55,52.97 121.86,53.65 121.86,54.55 121.72,54.7 121.72,55.46 122.13,55.88 v3(122.13,56.09)
  GND3 w0.127: v3(19.08,7.93) v6(19.08,7.46) ; v3(159.84,15.06) 159.6,14.83 v6(159.6,14.82)
  IN4 w0.127: v6(159.6,14.82) 159.54,14.76 153.83,14.76 150.43,11.36 146.3,11.36 146.11,11.55 145.22,11.55 144.97,11.8 133.73,11.8 132.96,11.03 121.04,11.03 120.39,10.38 118.01,10.38 117.73,10.1 116.86,10.1 116.49,9.74 111.88,9.74 111.41,9.26 101.3,9.26 99.57,7.53 80.3,7.53 76.74,3.97 70.14,3.97 v5(70.05,4.06) 69.97,3.98 64.34,3.98 63.76,4.55 58.2,4.55 57.9,4.86 50.06,4.86 49.42,5.49 40.04,5.49 39.91,5.36 33.84,5.36 32.46,6.74 28.48,6.74 28.17,6.42 27.37,6.42 26.85,6.94 26,6.94 25.33,7.61 23.26,7.61 22.94,7.3 19.24,7.3 v6(19.08,7.46)
  BOTTOM w0.127: v5(70.05,4.06) QE20.1 69.6,2.86 69.6,4.11 QE20.2 69.86,4.76 CE93.2
REM_DIODE1_P: length 226.9
  TOP w0.127: CE58.2 18.51,7.04 18.95,7.48 18.95,8.84 19.57,9.46 19.57,9.68 UE3.A7 ; QE12.2 124.15,55.66 123.13,55.66 123.07,55.71 QE12.1 122.29,55.71 v1(121.76,55.18)
  GND1 w0.127: v1(18.49,6.96) 18.49,7.29 v3(18.45,7.32) ; v1(121.76,55.18) v3(122.11,55.18)
  IN2 w0.127: v3(160.29,14.68) 160.38,14.77 160.38,15.16 156.26,19.28 156.26,20.93 155.74,21.45 155.74,22.03 155.11,22.66 155.11,28.42 154.28,29.26 154.28,30.75 151.67,33.36 151.67,33.96 150.59,35.04 150.59,37.68 149.85,38.43 144.04,38.43 141.33,41.13 141.33,42.28 140.55,43.06 139.23,43.06 138.89,42.71 138.23,42.71 136.3,44.64 136.3,48.19 136.09,48.39 136.09,49.71 135.06,50.75 135.06,51.77 134.28,52.55 131.88,52.55 131.47,52.96 131.21,52.96 130.95,53.22 122.65,53.22 122.11,53.76 v3(122.11,55.18)
  GND3 w0.127: v6(159.97,14.54) 159.97,14.54 160.15,14.54 v3(160.29,14.68) ; v3(18.45,7.32) 18.58,7.32 18.86,7.04 v6(19.05,7.04)
  IN4 w0.127: v6(19.05,7.04) 23.04,7.04 23.36,7.36 25.22,7.36 25.89,6.69 26.74,6.69 27.26,6.17 28.27,6.17 28.59,6.48 32.35,6.48 33.73,5.1 40.01,5.1 40.15,5.24 49.31,5.24 49.95,4.6 57.79,4.6 58.09,4.3 63.66,4.3 64.24,3.72 70.08,3.72 70.09,3.72 70.54,3.72 v5(70.7,3.55) 70.87,3.72 76.84,3.72 80.4,7.28 99.67,7.28 101.4,9.01 111.52,9.01 111.99,9.48 116.6,9.48 116.96,9.84 117.83,9.84 118.12,10.13 120.5,10.13 121.15,10.78 133.06,10.78 133.83,11.55 144.86,11.55 145.12,11.29 146,11.29 146.19,11.11 150.54,11.11 153.93,14.5 159.93,14.5 v6(159.97,14.54)
  BOTTOM w0.127: v5(70.7,3.55) 70.7,3.55 QE20.3 70.7,5.33 CE93.1
REM_DIODE2_N: length 229.6
  TOP w0.127: v7(168.87,70.37) 168.87,70.87 169.39,71.38 QE21.1 170.04,72.12 QE21.2 ; v7(150,18.36) 149.8,18.16 149.8,14.74 146.53,11.47 144.69,11.47 143.77,12.38 139.94,12.38 139.07,11.52 v10(136.6,11.52) 134.52,11.52 134.42,11.41 134.42,11.02 v1(134.44,11) 134.42,10.98 QE14.3 134.18,8.35 CE87.2 ; v1(16.25,7.83) 16.25,8.15 17.5,9.4 UE3.A10
  IN1 w0.127: v7(168.87,70.37) 168.54,70.04 168.54,64.72 167.97,64.15 167.97,60.08 164.35,56.46 164.35,41.89 166.53,39.71 167.08,39.71 168.65,38.14 168.65,37.58 171.06,35.16 171.06,28.57 166.31,23.81 156.07,23.81 153.27,21.01 153.27,19.85 151.78,18.36 v7(150,18.36)
  GND1 w0.127: v1(16.25,7.83) 16.25,7.6 v3(16.03,7.39) ; v1(134.44,11) 134.03,11.41 v3(133.76,11.41)
  GND3 w0.127: v3(16.03,7.39) 16.14,7.49 v6(16.14,7.84) ; v6(133.2,11.94) 133.22,11.94 v3(133.76,11.41)
  IN4 w0.127: v6(16.14,7.84) 16.39,8.1 18.42,8.1 18.82,8.5 19.54,8.5 20.4,9.35 23.32,9.35 24.26,8.41 25.33,8.41 26.22,7.53 27.9,7.53 28.03,7.65 34.22,7.65 34.82,7.06 49.31,7.06 50.62,5.74 58.27,5.74 58.57,5.44 64.13,5.44 64.68,4.9 76.28,4.9 79.82,8.44 99.22,8.44 100.93,10.15 110.28,10.15 111.32,11.2 116.8,11.2 116.88,11.27 120.03,11.27 120.71,11.96 126.01,11.96 126.1,12.05 128.92,12.05 129.03,11.94 v6(133.2,11.94)
REM_DIODE2_P: length 231.6
  TOP w0.127: QE21.3 168.74,72.27 168.26,71.79 168.26,70.67 v7(167.96,70.37) ; UE3.A9 18.3,9.83 16.73,8.26 16.73,7.4 v1(16.25,6.92) ; v7(150,18.74) 149.77,18.74 149.55,18.52 149.55,14.84 146.43,11.72 144.79,11.72 143.88,12.64 v10(142.32,12.64) 139.83,12.64 138.96,11.77 133.12,11.77 132.81,11.46 v1(132.81,10.98) 132.81,10.75 133.06,10.5 QE14.1 133.77,9.89 133.12,9.24 QE14.2 133.26,8.46 CE87.1
  IN1 w0.127: v7(150,18.74) 150.02,18.76 151.82,18.76 153.02,19.96 153.02,21.12 155.97,24.07 166.2,24.07 170.81,28.67 170.81,35.06 168.39,37.47 168.39,38.04 166.97,39.46 166.42,39.46 164.1,41.78 164.1,56.57 167.72,60.19 167.72,64.26 168.29,64.83 168.29,70.04 v7(167.96,70.37)
  GND1 w0.127: v1(16.25,6.92) 16.58,7.25 v3(16.58,7.35) ; v3(133.18,11.41) 133.18,11.35 v1(132.81,10.98)
  GND3 w0.127: v6(132.78,11.63) 133,11.41 v3(133.18,11.41) ; v3(16.58,7.35) 16.57,7.37 v6(16.57,7.77)
  IN4 w0.127: v6(132.78,11.63) 132.72,11.69 128.92,11.69 128.82,11.79 126.2,11.79 126.11,11.7 120.82,11.7 120.13,11.02 116.99,11.02 116.91,10.94 111.43,10.94 110.39,9.9 101.04,9.9 99.32,8.19 79.93,8.19 76.39,4.64 64.57,4.64 64.03,5.19 58.46,5.19 58.16,5.49 50.51,5.49 49.2,6.8 34.72,6.8 34.12,7.4 28.13,7.4 28,7.27 26.11,7.27 25.22,8.16 24.15,8.16 23.21,9.1 20.5,9.1 19.65,8.24 18.92,8.24 18.53,7.85 16.64,7.85 v6(16.57,7.77)
REM_DIODE3_N: length 234.1
  TOP w0.127: QE22.3 144.39,71.27 v1(144.24,71.11)
  IN1 w0.127: v7(18.3,10.81) 18.62,10.5 18.62,9.65 17.46,8.49 17.46,7.98 v1(17.34,7.87)
  GND1 w0.127: v1(17.34,7.87) 17.43,7.87 v3(17.81,7.5) ; v1(144.24,71.11) 143.93,71.42 v3(143.93,71.71)
  GND3 w0.127: v3(17.81,7.5) 17.73,7.42 v6(17.73,7.09) ; v3(143.93,71.71) v6(143.93,72.12)
  IN4 w0.127: v6(17.73,7.09) 18.24,6.57 25.4,6.57 25.72,6.26 26.66,6.26 28.08,4.84 32.87,4.84 33.24,4.47 40.49,4.47 40.63,4.6 45.33,4.6 45.97,3.97 57.53,3.97 57.83,3.66 63.4,3.66 63.98,3.08 77.11,3.08 80.64,6.62 99.91,6.62 101.67,8.37 112.1,8.37 112.57,8.85 117.2,8.85 117.24,8.88 117.77,8.88 118.38,9.49 120.76,9.49 121.41,10.14 133.44,10.14 134.21,10.91 144.6,10.91 144.85,10.66 145.7,10.66 145.89,10.47 150.82,10.47 154.22,13.87 161.09,13.87 161.27,14.05 161.27,14.32 v5(160.91,14.68) 161.24,15.01 161.24,15.29 161.49,15.54 162.71,15.54 163.95,16.77 163.95,23.18 165.1,24.33 165.1,25.99 164.33,26.75 164.33,32.29 161.4,35.22 161.4,39.42 162.34,40.36 162.34,45.64 159.3,48.68 158.57,48.68 155.01,52.24 155.01,54.83 153.14,56.71 153.14,58.45 152.7,58.88 152.08,58.88 151.61,59.35 151.61,61.79 150.55,62.86 150.55,68.81 147.99,71.37 147.87,71.47 146.57,71.91 146.51,71.91 144.97,71.91 144.36,72.52 143.87,72.52 143.77,72.42 143.77,72.28 v6(143.93,72.12)
  BOTTOM w0.127: v5(160.91,14.68) 160.91,14.08 160.76,13.92 QE15.2 161.41,12.89 QE15.1
REM_DIODE3_P: length 236.9
  TOP w0.127: QE22.1 143.74,72.87 QE22.2 143.09,71.35 v1(143.32,71.11)
  IN1 w0.127: v1(17.36,6.92) 17.36,7.24 17.72,7.6 17.72,8.4 18.87,9.55 18.87,10.59 v7(19.1,10.81)
  GND1 w0.127: v1(143.32,71.11) v3(143.32,71.71) ; v3(17.22,7.4) 17.22,7.34 17.36,7.2 v1(17.36,6.92)
  GND3 w0.127: v3(17.22,7.4) 17.22,7.11 v6(17.14,7.02) ; v3(143.32,71.71) v6(143.32,72.1)
  IN4 w0.127: v6(17.14,7.02) 17.41,6.75 17.7,6.75 18.14,6.32 25.3,6.32 25.61,6 26.55,6 27.97,4.58 32.76,4.58 33.13,4.21 40.59,4.21 40.73,4.35 45.22,4.35 45.86,3.71 57.42,3.71 57.72,3.41 63.29,3.41 63.87,2.83 77.21,2.83 80.75,6.36 100.02,6.36 101.77,8.12 112.2,8.12 112.68,8.59 117.3,8.59 117.34,8.63 117.88,8.63 118.48,9.24 120.87,9.24 121.52,9.89 133.54,9.89 134.31,10.66 144.5,10.66 144.75,10.41 145.6,10.41 145.79,10.22 150.93,10.22 154.32,13.61 161.19,13.61 161.52,13.94 161.52,14.37 v5(161.83,14.68) 161.49,15.01 161.49,15.18 161.6,15.28 162.82,15.28 164.2,16.67 164.2,23.08 165.35,24.23 165.35,26.09 164.58,26.86 164.58,32.39 161.65,35.32 161.65,39.31 162.59,40.25 162.59,45.75 159.4,48.93 158.68,48.93 155.27,52.34 155.27,54.94 153.39,56.81 153.39,58.55 152.81,59.14 152.19,59.14 151.87,59.46 151.87,61.9 150.81,62.96 150.81,68.92 148.16,71.56 147.99,71.7 146.63,72.15 146.54,72.17 145.07,72.17 144.46,72.78 143.77,72.78 143.52,72.53 143.52,72.3 v6(143.32,72.1)
  BOTTOM w0.127: v5(161.83,14.68) 161.83,13.77 QE15.3
REM_DIODE4_N: length 326.1
  TOP w0.127: v1(15.1,7.83) 15.1,8.41 UE3.A11
  GND1 w0.127: v3(14.75,7.33) 14.75,7.48 v1(15.1,7.83)
  IN2 w0.127: v8(285.19,39.83) 285.03,39.67 285.03,38.44 284.58,37.99 283.5,37.99 282.79,37.29 282.79,35.53 281.27,34.01 281.27,32.48 281.02,32.23 277.27,32.23 274.8,29.75 274.8,26.98 273.58,25.77 271.55,25.77 271.48,25.83 269.55,25.83 269.32,25.59 269.32,23.04 266.19,19.92 266.19,19.64 260.48,13.93 260.21,13.93 258.4,12.12 258.4,10.91 256.05,8.56 254.63,8.56 v3(254.22,8.16)
  GND3 w0.127: v6(14.75,6.95) v3(14.75,7.33) ; v6(254.5,7.44) 254.5,7.88 v3(254.22,8.16)
  IN4 w0.127: v6(14.75,6.95) 15.35,6.36 17,6.36 18.73,4.63 19.63,4.63 20.33,3.93 26.93,3.93 27.99,2.87 29.65,2.87 30.24,2.28 37.42,2.28 37.64,2.06 40.74,2.06 40.87,1.92 46.07,1.92 46.3,2.15 56.91,2.15 57.13,1.92 59.95,1.92 60.51,1.35 77.82,1.35 80.81,4.34 88.87,4.34 91.88,1.33 128.57,1.33 129.78,2.54 129.78,6.72 130.66,7.6 136.43,7.6 138.01,9.18 142.96,9.18 144.5,7.65 144.5,3.93 146.42,2.01 156.39,2.01 160.1,5.72 162.75,5.72 164.29,4.19 168.74,4.19 168.87,4.31 178.25,4.31 178.88,4.95 184.02,4.95 185,3.97 197.12,3.97 197.35,4.2 201.48,4.2 203.04,5.76 204.31,5.76 204.71,6.17 208.14,6.17 209.49,7.51 209.49,7.72 213.02,11.25 215.6,11.25 218.67,8.18 222.9,8.18 224.45,6.62 252.08,6.62 252.25,6.79 254.13,6.79 254.38,7.04 254.38,7.32 v6(254.5,7.44)
  BOTTOM w0.127: QE19.3 286.63,41.19 CE89.1 285.7,42.12 285.37,42.12 285.03,41.77 285.03,40 v8(285.19,39.83)
REM_DIODE4_P: length 328.3
  TOP w0.127: v1(15.1,6.92) 15.56,7.37 15.56,8.51 16.68,9.64 16.96,9.64 17.12,9.8 17.12,10.25 17.5,10.63 UE3.B10
  GND1 w0.127: v3(15.36,7.33) 15.36,7.17 v1(15.1,6.92)
  IN2 w0.127: v8(284.61,39.83) 284.77,39.67 284.77,38.54 284.48,38.25 283.39,38.25 282.54,37.4 282.54,35.63 281.02,34.11 281.02,32.58 280.91,32.48 277.17,32.48 274.54,29.86 274.54,27.08 273.48,26.02 271.65,26.02 271.59,26.08 269.44,26.08 269.06,25.7 269.06,23.14 265.94,20.02 265.94,19.75 260.38,14.19 260.1,14.19 258.15,12.23 258.15,11.01 255.95,8.82 254.33,8.82 253.83,8.32 253.83,8.29 v3(253.69,8.15)
  GND3 w0.127: v6(15.49,6.98) 15.49,7.2 v3(15.36,7.33) ; v3(253.69,8.15) 253.69,8.13 253.98,7.84 v6(253.98,7.43)
  IN4 w0.127: v6(253.98,7.43) 254.13,7.28 254.13,7.14 254.02,7.04 252.14,7.04 251.98,6.88 224.56,6.88 223.01,8.43 218.78,8.43 215.71,11.5 212.91,11.5 209.23,7.83 209.23,7.62 208.04,6.42 204.61,6.42 204.2,6.01 202.94,6.01 201.38,4.45 197.24,4.45 197.01,4.22 185.11,4.22 184.13,5.2 178.78,5.2 178.14,4.57 168.76,4.57 168.64,4.44 164.39,4.44 162.86,5.97 160,5.97 156.28,2.26 146.53,2.26 144.75,4.04 144.75,7.76 143.07,9.44 137.91,9.44 136.33,7.86 130.55,7.86 129.52,6.83 129.52,2.64 128.47,1.59 91.98,1.59 88.98,4.59 80.7,4.59 77.72,1.61 60.62,1.61 60.05,2.17 57.24,2.17 57.01,2.4 46.19,2.4 45.97,2.17 40.98,2.17 40.84,2.31 37.75,2.31 37.53,2.53 30.34,2.53 29.75,3.12 28.09,3.12 27.03,4.19 20.43,4.19 19.74,4.88 18.83,4.88 17.1,6.61 15.45,6.61 15.38,6.69 15.38,6.87 v6(15.49,6.98)
  BOTTOM w0.127: QE19.2 288.38,41.84 QE19.1 286.22,42.74 CE89.2 285.62,42.37 285.27,42.37 284.77,41.88 v10(284.77,41.04) 284.77,40 v8(284.61,39.83)
RESET_OUT#_R: length 156.6
  TOP w0.095: v7(39.28,73.31) 39.28,74 39.17,74.11 33.85,74.11 33.01,73.27 v2(33.01,72.65) 33.33,72.33 CC89.1
  IN1 w0.076: v7(39.28,73.31) 40.31,74.34 79.03,74.34 80.81,72.56 82.26,72.56 83.98,74.28 136.74,74.28 139.16,71.86 144.57,71.86 145.27,71.16 147.08,71.16 149.54,68.7 149.54,64.69 151.42,62.81 151.42,59.92 150.94,59.44 150.94,58.28 150.24,57.58 149.72,57.58 148.96,56.81 148.96,51.4 148.26,50.71 v9(143.17,50.71)
  GND1 w0.095: v3(142.9,51.07) 142.91,51.07 142.91,50.97 v9(143.17,50.71)
  GND3 w0.095: v3(142.9,51.07) 142.9,50.75 v4(142.94,50.71)
  BOTTOM w0.095: v4(142.94,50.71) 143.02,50.62 143.02,48.9 142.84,48.72 142.84,47.76 143.3,47.3 RC370.2 143.3,47.12 142.61,46.44 RC241.2
RING2: length 1.1
  BOTTOM w0.102: RA52.1 283.66,62.78 v2(284.16,63.28)
RING2_R: length 11
  IN3 w1.524: 291.29,64.9 291.03,64.65 285.41,64.65 ; 291.29,64.9 291.29,66.28 292.08,67.06 292.08,65.69 291.29,64.9
  vias: v2(292.04,66.22) v3(284.06,64.04) v3(284.19,63.53) v3(284.44,63.86) v3(291.58,68.17) v3(291.68,68.57) v3(291.99,68.14) v4(283.73,63.94) v4(283.76,63.51) v4(283.91,63.74) v4(292.29,68.66) v4(292.38,68.4) v4(292.61,68.61)
RREF: length 1.6
  BOTTOM w0.305: RR8.2 286.15,30.42 286.15,31.93
RTCRST_ON: length 9.2
  TOP w0.095: UE3.F11 16.32,13.63 13.91,13.63 13.69,13.42 13.69,12.69 12.55,11.54 RE176.1 11.69,11.17 v2(11.35,11.51) 11.15,11.7 QE10.2
RTD3_CIO_PWR_EN: length 245.1
  IN4 w0.076: v5(23.75,58.25) 23.37,58.25 22.94,57.82 22.94,55.47 21.03,53.56 21.03,52.55 20.3,51.82 20.3,51.33 20.49,51.13 24.57,51.13 25.47,50.24 25.47,49.39 26.15,48.72 26.15,47 26.76,46.39 26.76,43.62 29.72,40.66 31.12,40.66 31.84,41.38 32.76,41.38 33.46,40.68 33.46,38.74 32.33,37.61 32.33,35.92 33.08,35.18 33.08,32.97 32.59,32.49 32.59,30.47 33.01,30.05 33.01,28.37 32.29,27.65 32.29,26.3 32.79,25.79 32.79,23.39 32.13,22.73 32.13,19.77 33.97,17.92 33.97,12.34 35.62,10.69 41.63,10.69 42.12,10.2 46.93,10.2 47.57,9.57 49.4,9.57 51.52,7.45 65.35,7.45 66.07,6.73 76.39,6.73 79.54,9.87 98.93,9.87 100.42,11.37 109.23,11.37 110.28,12.41 114.29,12.41 114.97,13.09 118.21,13.09 118.47,12.83 119.83,12.83 120.17,13.18 125.53,13.18 125.64,13.29 129.84,13.29 129.96,13.16 139.07,13.16 139.59,13.68 144.81,13.68 145.24,13.25 146.27,13.25 146.59,13.57 149.72,13.57 153.16,17.02 153.16,25.49 154.37,26.7 154.37,31.78 153.24,32.91 153.24,34.29 152.07,35.46 152.07,38.64 152.4,38.97 152.4,47.89 148.65,51.64 148.65,53.54 146.46,55.73 146.46,56.29 144.02,58.73 143.07,58.73 142.4,59.4 141.86,59.4 141.63,59.64 141.63,60.11 v5(141.42,60.32)
  BOTTOM w0.095: v5(23.75,58.25) RT34.2 23.16,57.03 23.16,55.64 22.25,54.73 21.94,54.73 21.33,54.12 20.97,54.12 20.65,53.8 20.65,53.08 20.43,52.86 20.43,52.61 UT2.F1
RTD3_USB_PWR_EN: length 163.2
  IN1 w0.076: v9(113,71.38) 113,70.27 113.93,69.33 120.69,69.33 121.49,70.13 121.49,71.58 121.75,71.84 v9(122.77,71.84)
  GND1 w0.095: v3(123.28,71.79) 122.83,71.79 v9(122.77,71.84) ; v9(113,71.38) v3(112.65,71.38)
  GND3 w0.095: v3(123.28,71.79) 123.42,71.65 v6(123.69,71.65) ; v6(112.31,71.38) v3(112.65,71.38)
  IN4 w0.076: v6(123.69,71.65) 124.41,72.36 133.63,72.36 134.41,71.58 134.41,70.27 133.39,69.25 133.39,67.7 132.35,66.66 132.35,64.46 132.49,64.32 132.49,63.74 132.66,63.56 132.84,63.56 133.18,63.22 133.18,62 134.29,60.9 v5(134.9,60.9) ; v6(112.31,71.38) 112.3,71.38 112.17,71.25 109.15,71.25 106.72,73.68 96.28,73.68 95.07,72.48 94.15,72.48 93.65,72.98 91.12,72.98 90.82,73.28 86.93,73.28 85.56,71.92 83.96,71.92 83.2,71.16 79.84,71.16 78.1,72.89 61.9,72.89 61.19,72.18 52.91,72.18 45.47,64.75 32.67,64.75 28.14,60.22 14.15,60.22 13.7,59.77 13.7,55.06 13.23,54.59 13.23,51.76 13.67,51.32 14.86,51.32 14.96,51.43 15.72,51.43 15.84,51.54 v5(15.84,51.75) 15.86,51.77 15.86,51.87 16.57,52.57 18.52,52.57 19.29,51.8 v4(19.29,51.45)
  BOTTOM w0.095: v5(15.84,51.75) 15.82,51.73 RT35.2
RUN_ON: length 51.4
  TOP w0.095: v7(27.55,7.7) 27.55,5.62 27.36,5.43 27.36,4.66 27.72,4.3 v1(28.13,4.3)
  IN1 w0.076: v9(3.64,19.57) 3.64,18.48 4.14,17.98 4.14,13.71 6.9,10.96 6.9,8.35 9.64,5.61 11.03,5.61 11.98,4.65 13.63,4.65 15.39,6.41 20.33,6.41 21.5,7.58 21.5,8.96 22.13,9.58 24.21,9.58 25.68,8.11 26.13,8.11 26.84,7.4 27.24,7.4 v7(27.55,7.7)
  GND1 w0.095: v1(28.13,4.3) 28.39,4.3 28.54,4.45 v3(28.59,4.45) ; v3(3.64,19.9) v9(3.64,19.57)
  GND3 w0.095: v3(28.59,4.45) 28.61,4.42 v4(28.61,4.08) ; v4(4.21,20.4) 3.99,20.19 3.92,20.19 v3(3.64,19.9)
  BOTTOM w0.095: v4(4.21,20.4) 3.7,19.9 2.96,19.9 RE192.1 1.94,20.4 1.54,20.81 v2(1.54,22.91) 2.02,23.39 UE8.4
RUN_ON#: length 4
  BOTTOM w0.095: RE174.1 v2(26.71,1.72) 27.51,1.72 QE11.3 27.96,2.61 28.11,2.76 28.45,2.76 28.61,2.6 QE11.2
RUN_ON_EC: length 40.9
  TOP w0.095: v2(4.82,21.97) v8(5.86,21.97) 6.29,21.97 6.59,22.27 UC5.2 ; RPE6.4 20.34,22.27 20.44,22.36 v8(20.44,22.71) ; UE3.E8 19.07,13.21 v8(18.71,13.57)
  IN1 w0.076: v7(8.45,21.87) 8.26,22.07 5.96,22.07 v8(5.86,21.97)
  IN4 w0.076: v8(5.86,21.97) 6.67,22.77 6.67,24.42 7.46,25.2 10.8,25.2 11.32,24.69 11.32,24.02 12.85,22.49 16.61,22.49 17.06,22.94 18.3,22.94 18.95,22.29 19.65,22.29 20.08,22.71 v8(20.44,22.71) 20.44,21.75 19.81,21.13 19.39,21.13 17.95,19.68 17.95,16.85 18.31,16.49 18.31,13.97 v8(18.71,13.57)
  BOTTOM w0.095: RE192.2 3.34,20.43 UE8.2 3.34,21.97 3.51,22.13 5.7,22.13 v8(5.86,21.97)
RUN_ON_P: length 382.6
  TOP w0.095: U13.5 267.77,48.66 v7(267.74,48.69) ; RE6.1 8.51,20.91 v7(9.35,20.91) ; v7(218.65,11.91) 218.63,11.91 218.35,11.63 218.35,10.71 218.56,10.51 219.18,10.51 219.74,9.94 R88.2 220.96,9.94 220.99,9.91 U12.3 ; v1(149.99,12.61) 151.31,13.93 151.31,20.04 150.99,20.36 v2(150.99,20.59) 150.63,20.96 150.47,20.96 150.16,21.26 150.16,21.73 151.15,22.72 R82.1
  IN1 w0.076: v7(9.35,20.91) 9.13,21.13 v7(5.94,21.13) 5.79,21.13 4.92,20.25 4.92,18.69 5.11,18.5 5.11,14.11 6.98,12.24 9.63,12.24 11.03,10.84 11.03,8.29 12.31,7.01 12.31,6.67 12.88,6.1 13.8,6.1 14.08,6.38 14.08,9.4 15.58,10.9 16.46,10.9 17.01,11.45 17.01,11.63 17.36,11.98 18.37,11.98 18.5,11.85 18.93,11.85 19.19,12.11 22.87,12.11 23.01,11.97 24.35,11.97 24.67,11.65 26.26,11.65 28.2,9.71 28.94,9.71 29.81,8.85 30.51,8.85 31.59,7.77 32.68,7.77 33.09,8.17 39.78,8.17 40.42,7.54 47.95,7.54 50.77,4.72 58.57,4.72 58.8,4.49 62.72,4.49 63.41,3.8 68.66,3.8 68.75,3.71 73.58,3.71 73.87,4 76.76,4 80.58,7.82 104.38,7.82 106.86,10.31 109.16,10.31 109.86,11 114.76,11 116.74,12.98 v9(117.64,12.98) 129.57,12.98 129.96,12.6 137.97,12.6 138.62,13.25 144.77,13.25 145.53,12.49 149.86,12.49 v1(149.99,12.61) 150.38,13.01 164.22,13.01 v9(164.27,12.96) 164.72,13.41 168.45,13.41 169.93,11.93 174.41,11.93 175.37,12.89 177.74,12.89 179.45,11.17 180.55,11.17 181.7,10.01 184.23,10.01 186.13,8.11 207.04,8.11 212.09,13.16 216.5,13.16 217.85,11.82 218.56,11.82 v7(218.65,11.91) 219.11,11.91 219.31,12.11 221.91,12.11 222.58,11.43 227.04,11.43 230.59,7.89 249.89,7.89 250.94,8.94 254.03,8.94 257.18,12.09 260.36,12.09 261.22,12.95 261.22,14.19 262.17,15.15 264.08,15.15 264.65,14.57 268.7,14.57 268.92,14.8 269.37,14.8 269.55,14.62 271.53,14.62 272.64,15.73 272.64,16.35 272.84,16.56 274.57,16.56 275.22,17.22 275.22,18.68 274.7,19.2 274.7,21.27 273.78,22.19 273.78,28.39 273.42,28.75 273.42,32.2 273.04,32.58 267.69,32.58 266.56,33.71 266.56,37.46 268.85,39.74 268.85,41.58 267.98,42.44 267.98,43.85 267.58,44.25 267.58,48.52 v7(267.74,48.69)
  GND1 w0.095: v3(164.27,12.2) v9(164.27,12.96) ; v9(117.64,12.98) 117.68,12.95 v3(118.05,12.95) ; v3(150.31,12.47) 150.17,12.61 v1(149.99,12.61)
  GND3 w0.095: v4(149.97,12.81) 149.97,12.81 v3(150.31,12.47) ; v3(164.27,12.2) 164.25,12.22 v4(163.83,12.22) ; v4(118.05,12.4) v3(118.05,12.95)
  BOTTOM w0.095: PR901.1 151.46,6.73 151.46,9.18 151.94,9.67 151.94,10.2 151.59,10.55 151.15,10.55 150.84,10.86 150.84,12.19 150.21,12.82 149.97,12.82 v4(149.97,12.81) ; v4(118.05,12.4) 118.05,12.36 117.93,12.24 PR611.1
RUNPWROK: length 15
  TOP w0.095: v1(26.96,8.6) 27.57,8.6 27.89,8.29 27.89,7.4 27.82,7.32 27.82,5.43 27.7,5.32 v2(27.7,4.83) 27.83,4.7 v1(28.14,4.7)
  GND1 w0.095: v1(28.14,4.7) 28.26,4.83 28.87,4.83 29.21,4.48 v3(29.21,4.45) ; v3(22.76,14.55) 23.02,14.82 v1(23.1,14.82) ; v1(26.96,8.6) v3(26.96,9.1)
  GND3 w0.095: v4(29.26,4.08) 29.26,4.39 v3(29.21,4.45) ; v6(23.04,14.22) 23.04,14.26 v3(22.76,14.55) ; v6(27.03,9.55) 27.03,9.17 v3(26.96,9.1)
  IN4 w0.076: v6(23.04,14.22) 23.38,13.88 23.38,13.32 27.04,9.67 27.04,9.56 v6(27.03,9.55)
SA_B+:
  vias: v2(53.76,48.23) v8(53.02,48.82) v8(53.02,47.8) v8(54.37,48.82) v8(54.37,47.8)
SATA_PRX_SSDTX_N2: length 69.5
  IN3 w0.089: v3(120.61,63.2) 120.38,63.2 120.29,63.29 120.29,64.22 120.43,64.36 120.43,65.14 122.06,66.77 122.06,67.54 122.64,68.12 122.64,69.11 124.25,70.71 133.08,70.71 133.53,71.16 139.17,71.16 141.52,68.82 141.52,67.3 144.29,64.53 148.51,64.53 149.02,64.02 149.02,58.78 151.05,56.74 151.05,55.75 152.06,54.75 152.06,54.04 157.19,48.9 157.19,48.43 157.82,47.8 158.19,47.8 158.3,47.69 v8(158.3,47.57)
  GND3 w0.102: v4(120.27,63.5) 120.27,63.48 120.56,63.2 v3(120.61,63.2)
  BOTTOM w0.102: v8(158.3,47.57) 158.08,47.8 157.25,47.8 155.72,46.27 155.72,39.95 155.84,39.83 155.98,39.83 R31.1
SATA_PRX_SSDTX_N2_C: length 14.2
  BOTTOM w0.102: R31.2 155.8,39.12 155.7,39.02 155.7,38.64 156.79,37.54 156.79,35.63 157.81,34.61 157.81,29.22 159.02,28.01 159.31,28.01 159.49,28.2 JNGFF1.43
SATA_PRX_SSDTX_P2: length 69.5
  IN3 w0.089: v3(119.94,63.14) 119.94,64.37 120.07,64.5 120.07,65.28 121.71,66.92 121.71,67.68 122.29,68.26 122.29,69.25 124.1,71.07 132.93,71.07 133.38,71.52 139.32,71.52 141.87,68.97 141.87,67.44 144.44,64.88 148.66,64.88 149.37,64.17 149.37,58.93 151.41,56.89 151.41,55.9 152.41,54.9 152.41,54.18 157.55,49.04 157.55,48.57 157.97,48.16 158.24,48.16 v8(158.31,48.22)
  GND3 w0.102: v4(120.27,62.85) 119.98,63.14 v3(119.94,63.14)
  BOTTOM w0.102: R30.1 155.49,40.29 155.49,46.36 157.15,48.03 158.11,48.03 v8(158.31,48.22)
SATA_PRX_SSDTX_P2_C: length 14.3
  BOTTOM w0.102: R30.2 155.47,38.89 155.47,38.54 156.56,37.45 156.56,35.53 157.59,34.51 157.59,29.12 158.93,27.78 159.36,27.78 159.45,27.7 JNGFF1.41
SATA_PTX_SSDRX_N2: length 75.2
  IN2 w0.089: v3(122.13,70.15) 121.88,70.15 121.79,70.24 121.79,70.44 121.88,70.53 122.3,70.53 122.71,70.94 122.71,71.8 125.03,74.12 143.51,74.12 144.97,72.67 147.52,72.67 151.13,69.06 151.13,64.78 151.82,64.09 151.82,60.14 153.75,58.21 153.75,54.58 159.8,48.53 159.8,43.68 159.68,43.56 159.39,43.56 159.2,43.76 v3(159.2,43.8)
  GND3 w0.102: v4(121.73,70.28) 121.96,70.28 122.1,70.15 v3(122.13,70.15) ; v4(158.69,43.51) 158.98,43.51 159.2,43.73 v3(159.2,43.8)
  BOTTOM w0.076: UCPU1.A25 123,66.2 122.9,66.1 122.79,66.1 121.41,67.48 v10(121.41,69.58) 121.41,70.5 121.48,70.58 121.9,70.58 121.98,70.5 121.98,70.35 121.9,70.28 v4(121.73,70.28)
  BOTTOM w0.102: CD98.1 157.68,40.27 157.68,40.64 158.11,41.06 158.11,42.84 158.69,43.41 v4(158.69,43.51)
SATA_PTX_SSDRX_N2_C: length 11.9
  BOTTOM w0.102: CD98.2 157.68,38.89 157.68,35.63 158.27,35.05 158.27,29.89 158.96,29.2 JNGFF1.47
SATA_PTX_SSDRX_P2: length 75.3
  IN2 w0.089: v3(122.13,70.92) 122.35,71.14 122.35,71.95 124.88,74.48 143.66,74.48 145.12,73.02 147.67,73.02 151.48,69.21 151.48,64.93 152.18,64.24 152.18,60.29 154.11,58.36 154.11,54.72 159.95,48.88 160.16,48.67 160.16,43.54 159.83,43.21 159.41,43.21 159.41,43.21 159.31,43.21 v3(159.28,43.18)
  GND3 w0.102: v3(122.13,70.92) 122.05,70.92 122,70.87 v4(121.69,70.87) ; v4(158.7,42.98) 159.08,42.98 v3(159.28,43.18)
  BOTTOM w0.076: v4(121.69,70.87) 121.59,70.77 121.41,70.77 121.24,70.6 121.24,69.92 121.2,69.87 121.2,69.28 121.24,69.24 121.24,67.55 121.24,67.55 121.24,67.41 123,65.65 UCPU1.B25
  BOTTOM w0.102: v4(158.7,42.98) 158.58,42.98 158.34,42.74 158.34,40.97 157.91,40.54 157.91,39.93 158.04,39.81 158.18,39.81 158.35,39.97 CD99.1
SATA_PTX_SSDRX_P2_C: length 11.9
  BOTTOM w0.102: CD99.2 158.02,39.12 157.91,39.02 157.91,35.73 158.5,35.15 158.5,29.98 159.06,29.42 159.25,29.42 159.52,29.7 JNGFF1.49
SBIOS_TX: length 201
  IN1 w0.076: v9(12.1,16.21) 12.33,16.21 14.48,18.36 16.96,18.36 17.78,19.18 23.93,19.18 23.96,19.15 26.54,19.15 28.29,17.4 28.69,17.4 29.13,16.97 30.22,16.97 32.01,15.18 32.01,12.97 32.35,12.63 35.38,12.63 35.94,12.07 48.23,12.07 52.64,7.66 60.6,7.66 61.19,7.07 66.02,7.07 66.44,6.65 70.57,6.65 71.06,6.16 72.58,6.16 72.86,6.44 75.71,6.44 80.09,10.82 99.45,10.82 102.31,13.68 104.57,13.68 v9(105.09,14.21)
  GND1 w0.095: v3(11.85,15.7) 12.1,15.96 v9(12.1,16.21) ; v3(105.48,14.24) 105.13,14.24 v9(105.09,14.21)
  IN3 w0.064: v8(146.16,17.49) 145.37,16.71 143.88,16.71 143.54,16.36 138.21,16.36 136.71,17.86 130.02,17.86 129.43,17.27 125.96,17.27 125.57,17.66 123.21,17.66 122.7,18.17 117.73,18.17 115.19,15.63 110.6,15.63 109.05,14.08 105.64,14.08 v3(105.48,14.24)
  GND3 w0.095: v4(11.75,15.29) 11.85,15.38 v3(11.85,15.7)
  IN4 w0.076: v8(146.16,17.49) 146.5,17.15 146.86,17.15 147.06,16.96 147.53,16.96 147.72,16.77 148.81,16.77 150.28,18.24 150.28,19.53 149.82,19.98 149.82,22.8 150.06,23.04 150.06,29.16 148.36,30.86 148.36,33.27 147.84,33.79 147.84,35.13 148.09,35.39 148.09,38.43 148.69,39.03 148.69,46.52 145.99,49.22 144.02,49.22 141.41,51.83 141.41,52.74 140.46,53.69 v5(140.46,54.07)
  BOTTOM w0.095: v5(140.46,54.07) 140.39,54.07 140.01,54.45 v2(139.83,54.45) 138.31,54.45 137.68,55.09 137.26,55.09 136.93,54.76 UCPU1.AB2
SD_CD#: length 13.7
  TOP w0.095: JCR1.9 283.01,27.04 283.41,27.04 283.76,27.4 283.76,27.89 284.1,28.24 289.7,28.24 290.72,29.26 290.72,32.16 v8(291.35,32.79)
  BOTTOM w0.095: UR1.30 290.9,33.24 v8(291.35,32.79)
SD_CLK: length 11.7
  GND1 w0.095: v1(282.91,31.34) v3(282.58,31.34)
  IN2 w0.064: v3(285.55,37.29) 285.17,37.29 283.77,35.9 283.77,35.16 283.4,34.79 282.98,34.79 282.88,34.7 282.88,34.55 282.97,34.47 283.52,34.47 283.6,34.39 283.6,34.23 283.52,34.15 282.97,34.15 282.9,34.08 282.9,33.9 282.96,33.84 283.52,33.84 283.6,33.76 283.6,33.62 283.5,33.52 283.11,33.52 282.89,33.3 282.89,31.65 v3(282.58,31.34)
  GND3 w0.095: v4(285.92,37.29) v3(285.55,37.29)
  BOTTOM w0.095: RR4.2 286.46,37.84 v4(285.92,37.29)
SD_CLK_L: length 1.5
  BOTTOM w0.095: UR1.17 287.07,36.28 286.68,36.67 RR4.1
SD_CMD: length 13.7
  TOP w0.095: v8(287.9,36.68) 287.9,36.06 288.24,35.72 288.24,34.34 287.78,33.89 286.71,33.89 286.17,34.43 286.17,36.4 285.81,36.76 285.55,36.76 284.46,35.67 284.46,33.69 283.91,33.14 JCR1.3
  BOTTOM w0.095: v8(287.9,36.68) 287.87,36.66 UR1.19
SD_D2: length 13.2
  TOP w0.095: JCR1.1 283.01,34.94 283.46,34.94 283.61,35.1 283.61,36.05 285.3,37.74 285.72,37.74 285.81,37.83 285.81,38 285.91,38.09 286.09,38.09 286.19,37.99 286.19,37.83 286.29,37.74 286.48,37.74 286.57,37.83 286.57,38.3 286.67,38.4 286.85,38.4 286.95,38.29 286.95,37.83 287.05,37.74 287.24,37.74 287.33,37.83 287.33,38.3 287.43,38.4 287.61,38.4 287.72,38.29 287.72,37.83 287.81,37.74 288,37.74 288.1,37.83 288.1,38.3 288.19,38.4 288.37,38.4 288.48,38.29 288.48,37.83 288.89,37.42 v8(288.89,37.27)
  BOTTOM w0.095: UR1.21 288.67,36.37 288.53,36.51 288.53,36.91 v8(288.89,37.27)
SD_D3: length 14.1
  TOP w0.095: v8(288.2,37.24) 287.69,37.24 287.47,37.02 287.47,35.56 287.8,35.24 287.8,34.76 287.52,34.48 286.94,34.48 286.72,34.7 286.72,36.71 286.19,37.24 285.38,37.24 284.02,35.88 284.02,34.35 283.71,34.04 283.01,34.04 JCR1.2
  BOTTOM w0.095: UR1.20 288.27,36.45 288.33,36.51 288.33,37.11 v8(288.2,37.24)
SD_LN0_M: length 12.4
  TOP w0.089: v8(295.22,30.76) 295.22,30.76 JCR1.19
  IN2 w0.064: v8(291.4,35.64) 291.53,35.51 291.53,35.35 291.43,35.24 291.16,35.24 290.81,35.59 290.81,36.22 291.11,36.52 291.45,36.52 291.96,36.01 291.96,34.65 292.89,33.73 292.89,32.87 294.51,31.25 294.73,31.25 v8(295.22,30.76)
  BOTTOM w0.089: UR1.25 291.41,35.24 291.54,35.38 291.54,35.5 v8(291.4,35.64)
SD_LN0_P: length 12.5
  TOP w0.089: v8(295.2,31.62) 295.48,31.62 295.53,31.67 296.16,31.67 JCR1.18
  IN2 w0.064: v8(295.2,31.62) 294.66,31.62 293.26,33.02 293.26,33.88 292.33,34.81 292.33,36.16 291.6,36.89 290.96,36.89 290.45,36.37 290.45,35.43 291.01,34.87 291.38,34.87 v8(291.41,34.85)
  BOTTOM w0.089: v8(291.41,34.85) 291.4,34.84 UR1.26
SD_LN1_M: length 14.5
  TOP w0.089: JCR1.21 295.21,28.94 v8(295.21,28.94)
  IN2 w0.064: v8(295.21,28.94) 295.21,28.55 295.07,28.41 294.52,28.41 292.45,30.47 292.45,32.97 291.52,33.9 290.05,33.9 289.16,34.79 289.16,35.48 289.31,35.63 289.31,36.47 289.51,36.67 v8(289.58,36.67)
  BOTTOM w0.089: v8(289.58,36.67) 289.56,36.67 289.47,36.59 UR1.23
SD_LN1_P: length 14.5
  TOP w0.089: v8(295.19,28.03) 295.19,28.03 JCR1.22
  IN2 w0.064: v8(295.19,28.03) 295.19,28.04 294.37,28.04 292.08,30.32 292.08,32.82 291.37,33.53 289.89,33.53 288.79,34.64 288.79,35.64 288.94,35.79 v8(288.94,36.68)
  BOTTOM w0.089: UR1.22 289.07,36.55 v8(288.94,36.68)
SD_RCLK_M: length 11.9
  TOP w0.089: v8(285.61,34.84) 285.58,34.88 285.38,34.88 285.29,34.79 285.29,32.23 285.65,31.88 286.61,31.88 287.24,31.25 287.24,30.46 285.84,29.06 284.02,29.06 283.6,28.64 283.01,28.64 JCR1.8
  BOTTOM w0.089: UR1.15 v8(285.61,34.84)
SD_RCLK_P: length 11.9
  TOP w0.089: v8(285.61,35.46) 285.41,35.26 285.22,35.26 284.91,34.95 284.91,32.08 285.49,31.5 286.45,31.5 286.86,31.09 286.86,30.61 285.68,29.44 284.07,29.44 283.96,29.54 JCR1.7
  BOTTOM w0.089: v8(285.61,35.46) 285.82,35.24 UR1.16
SD_RCOMP: length 2
  TOP w0.095: v8(133.86,55.71) 133.23,56.35 RC116.1
  BOTTOM w0.305: UCPU1.AB7 133.86,55.36 v8(133.86,55.71)
SD_REG2: length 1.8
  BOTTOM w0.095: v2(290.43,38.73) 290.43,37.64 289.99,37.21 CR20.2
SHD_CLK: length 5.3
  TOP w0.095: v8(19.51,16.83) 19.51,16.82 UE3.J8
  BOTTOM w0.095: T57.1 23.12,17.87 23.12,17.37 22.95,17.21 22.55,17.21 22.53,17.23 21.28,17.23 21.28,17.24 20.94,17.24 20.94,17.23 19.91,17.23 v8(19.51,16.83)
SHD_CS#: length 8
  TOP w0.095: UE3.M5 21.87,19.18 21.87,19.79 22.24,20.16 v8(22.24,20.24)
  IN2 w0.064: v8(26.2,20.05) 25.6,19.45 24.2,19.45 23.4,20.24 v8(22.24,20.24)
  BOTTOM w0.095: v8(26.2,20.05) 26.2,20.45 v2(26.39,20.64) 26.85,20.64 26.99,20.78 RE177.1
SHD_IO2: length 13.2
  TOP w0.095: v7(28.67,15.31) 28.67,14.56 RE245.1 29.22,14.36 29.22,14.43 29.45,14.66 29.66,14.66 30.2,15.2 v2(30.44,15.2)
  IN1 w0.076: v7(19.9,18.02) 19.9,17.81 20.46,17.26 21.31,17.26 21.37,17.19 24.67,17.19 25.03,16.82 25.41,16.82 25.48,16.89 26.87,16.89 28.45,15.31 v7(28.67,15.31)
SHD_IO3: length 2.7
  TOP w0.095: UE3.M6 20.26,19.26 20.26,20.23 19.79,20.7 T56.1
SIO_EXT_SCI#: length 13.7
  TOP w0.095: RC39.2 140.74,41.28 140.31,41.71 138.26,41.71 137.66,42.31 136.25,42.31 133.07,45.49 v2(133.07,45.89) 133.07,48.45 v8(133.55,48.93)
  BOTTOM w0.112: UCPU1.AN7 133.92,49.31 v8(133.55,48.93)
SIO_EXT_SMI#: length 6.5
  BOTTOM w0.076: UCPU1.A6 134.72,66.53 135.57,67.38 137.02,67.38 138.42,68.77 138.42,69.73 RH81.2
SIO_EXT_WAKE#: length 200.1
  IN1 w0.076: v7(15.9,18.82) 15.9,19.23 16.58,19.91 18.21,19.91 18.25,19.87 19.36,19.87 20.13,20.64 26.42,20.64 26.99,20.06 28.8,20.06 29.14,19.72 30.54,19.72 32.46,17.79 36.41,17.79 38.22,15.98 40.79,15.98 42.29,14.48 48.12,14.48 48.32,14.69 50.66,14.69 54.27,11.08 59.74,11.08 60.2,10.62 61.87,10.62 62.48,10.01 65.98,10.01 66.54,9.45 69.2,9.45 69.39,9.25 72.13,9.25 72.41,8.98 74.06,8.98 74.51,9.43 74.51,9.92 75.55,10.96 76.64,10.96 81.17,15.49 84.24,15.49 86.32,13.41 91.61,13.41 92.41,14.21 99.62,14.21 100.29,14.88 100.74,14.88 101.98,16.11 109.04,16.11 109.51,16.58 112.62,16.58 113.58,17.53 117.11,17.53 117.73,16.91 123.14,16.91 123.62,17.39 125.54,17.39 127.17,15.77 132.31,15.77 132.82,15.26 136.98,15.26 137.57,15.84 143.75,15.84 147.41,19.5 148.25,19.5 150.17,21.42 150.17,21.54 151.16,22.53 151.16,23.65 151.8,24.3 151.8,28.14 144.7,35.25 144.7,36.41 143.99,37.12 142,37.12 138.47,40.65 138.47,41.76 138.32,41.91 138.32,42.48 136.6,44.2 136.6,45.77 137.62,46.79 v9(137.8,46.79)
  GND1 w0.095: v3(138.49,46.81) 138.47,46.79 v9(137.8,46.79)
  GND3 w0.095: v4(138.49,47.17) v3(138.49,46.81)
  BOTTOM w0.095: v4(138.49,47.17) 138.5,47.18 140.71,47.18 v2(140.78,47.25) 141.9,47.25 142.49,47.84 142.49,49.16 142.6,49.27 142.6,51.19 142.28,51.51 141.62,51.51 RC40.2 140.44,52.03 139.09,53.38 137.97,53.38 137.71,53.12 136.75,53.12 136.44,53.43 UCPU1.AD3
SIO_PWRBTN#: length 260.9
  TOP w0.095: v1(37.28,23.43) 37.28,24.24 37.53,24.49 37.53,26.44 37.74,26.65 37.74,32.48 37.93,32.68 37.93,38.16 36.16,39.93 32.14,39.93 29.33,42.74 28.89,42.74 28.37,43.26 28.37,44.77 30.56,46.96 30.56,52.62 29.33,53.84 29.33,55.68 29.52,55.87 29.52,58.2 30.86,59.55 33.42,59.55 35.17,61.3 37.61,61.3 RC247.1 ; UE3.K11 16.66,17.22 16.28,17.6 16.28,18.26 16.48,18.45 16.93,18.45 17.06,18.58 17.06,20.54 16.05,21.55 v7(15.79,21.55) ; v1(153.68,30.65) v2(157.34,30.65) 158,30.65 160.06,32.71 JAPS1.11
  IN1 w0.076: v7(15.79,21.55) 15.91,21.67 15.91,22.18 16.79,23.06 16.79,23.94 17.11,24.26 19.97,24.26 20.39,24.68 22.01,24.68 22.72,25.39 23.72,25.39 23.95,25.16 28.72,25.16 28.91,24.97 29.68,24.97 29.97,24.69 31.36,24.69 31.7,24.35 36.97,24.35 37.23,24.09 37.23,23.47 v1(37.28,23.43)
  GND1 w0.095: v1(153.68,30.65) 153.65,30.68 v3(153.33,30.68) ; v1(37.28,23.43) 37.35,23.43 37.57,23.2 v3(37.82,23.2)
  IN2 w0.064: v3(133.21,41.63) 133.32,41.75 133.89,41.75 134.62,41.02 134.67,41.02 134.86,40.82 134.86,40.65 135.58,39.94 140.28,39.94 142.72,37.5 142.72,36.99 142.96,36.76 144.53,36.76 145.31,37.54 147.97,37.54 148.65,36.87 148.65,35.03 152.99,30.68 v3(153.33,30.68)
  GND3 w0.095: v4(132.84,41.48) 133,41.63 v3(133.21,41.63) ; v3(37.82,23.2) 37.82,23.17 37.92,23.07 v6(38.42,23.07)
  IN4 w0.076: v6(38.42,23.07) 39.02,22.47 39.27,22.47 39.55,22.19 39.55,21.77 40.04,21.28 40.04,19.84 39.98,19.78 39.98,15.57 40.4,15.16 52.49,15.16 54.13,13.52 61.76,13.52 61.96,13.72 65.38,13.72 66.4,12.7 66.4,11.97 66.65,11.71 67.83,11.71 67.94,11.6 72.02,11.6 74.94,14.52 75.83,14.52 77.07,15.75 79.35,15.75 79.45,15.86 79.45,21.98 79.56,22.08 79.56,23.68 81.22,25.34 81.22,29.27 81.61,29.66 81.61,29.97 84.08,32.44 102.28,32.44 102.88,33.04 105.72,33.04 106.01,32.75 130.79,32.75 132.58,34.54 132.58,37.95 132.91,38.28 132.91,40.2 133.32,40.6 133.32,41.07 132.91,41.48 v4(132.84,41.48)
  BOTTOM w0.076: UCPU1.BA15 128.76,43.99 128.76,42.98 129.26,42.48 129.43,42.48 130.49,41.42 131.42,41.42 131.8,41.03 132.25,41.03 132.55,41.33 132.7,41.33 v4(132.84,41.48)
