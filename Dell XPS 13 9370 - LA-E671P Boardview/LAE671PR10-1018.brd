# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_A_USB2_T_N_R: length 11.3
  TOP w0.102: v8(6.56,47.16) 6.5,47.09 JUSBC1.B7 ; ML3.3 10.64,40.04 10.56,40.13 D38.1 10.56,42.05 v10(10.29,42.32) 10.07,42.54 9.18,42.54 v8(9.01,42.72)
  IN2 w0.089: v8(9.01,42.72) 8.89,42.6 8.63,42.6 8.5,42.73 8.5,46.01 7.49,47.02 6.69,47.02 v8(6.56,47.16)
TBT_A_USB2_T_P: length 15.6
  TOP w0.076: 13.59,31.05 15.46,31.05 15.61,30.89 16.05,30.89 16.38,30.56 16.73,30.56 U19.K6
  TOP w0.102: 13.59,31.05 13.36,31.05 13.31,31.1 v8(12.65,31.1) ; v8(10.89,37.16) 10.71,37.34 10.49,37.34 10.21,37.62 10.21,38.06 10.14,38.13 ML3.1
  IN2 w0.089: v8(10.89,37.16) 10.54,37.16 10.43,37.05 10.43,36.86 10.65,36.65 11.6,36.65 12.44,35.81 12.44,33.97 13.71,32.7 13.71,31.49 13.31,31.1 v8(12.65,31.1)
TBT_A_USB2_T_P_R: length 11.3
  TOP w0.102: v8(6.54,46.51) 6.46,46.59 JUSBC1.B6 ; ML3.2 10.14,40.11 10.33,40.29 10.33,40.62 D36.1 10.33,41.44 10.33,41.95 10.14,42.14 9.97,42.31 9.18,42.31 v8(9.01,42.13)
  IN2 w0.089: v8(6.54,46.51) 6.7,46.66 7.34,46.66 8.14,45.86 8.14,42.58 8.48,42.25 8.89,42.25 v8(9.01,42.13)
TBT_A_USB_OC0#: length 247.7
  IN1 w0.076: v9(22.38,29.27) 22.54,29.27 22.76,29.04 22.76,28.69 23.01,28.45 23.54,28.45 23.78,28.69 23.78,28.98 23.6,29.17 23.6,30.15 24.18,30.74 24.18,32.74 24.39,32.94 24.39,33.77 24.15,34.01 24.15,34.4 24.46,34.71 25.1,34.71 25.96,35.56 25.96,35.89 26.54,36.47 26.54,39.15 28.2,40.81 31.39,40.81 31.84,40.36 32.4,40.36 33.03,39.73 33.03,39.29 33.44,38.88 v9(33.44,38.69)
  GND1 w0.095: v9(33.44,38.69) 33.44,38.13 v3(33.53,38.05) ; v9(22.38,29.27) 22.3,29.35 v3(22.04,29.35)
  GND3 w0.095: v3(33.53,38.05) 33.44,37.96 v6(33.44,37.68) ; v4(21.63,29.29) 21.98,29.29 v3(22.04,29.35)
  IN4 w0.076: v5(134.53,69.61) 134.53,69.07 133.86,68.4 133.86,67.51 132.81,66.46 132.81,64.7 132.95,64.57 132.95,64.16 132.95,64.16 133.12,63.99 133.12,63.64 133.47,63.29 133.47,62.01 133.92,61.55 136.02,61.55 136.14,61.68 136.38,61.68 136.55,61.51 136.55,61.51 136.59,61.47 136.59,59.67 137.85,58.42 140.74,58.42 141.31,57.85 143.75,57.85 145.64,55.95 145.64,55.3 146.26,54.69 146.26,52.8 151.59,47.47 151.59,39.46 151.26,39.13 151.26,34.96 152.42,33.8 152.42,32.42 153.56,31.28 153.56,27.03 152.35,25.83 152.35,17.43 149.42,14.5 139.25,14.5 138.73,13.98 130.3,13.98 130.17,14.11 125.31,14.11 125.19,13.99 120.29,13.99 120.21,14.07 114.69,14.07 113.86,13.23 109.94,13.23 108.9,12.19 100.03,12.19 98.93,11.08 81.73,11.08 81.33,10.69 79.2,10.69 76.05,7.54 67.02,7.54 66.3,8.26 51.86,8.26 49.74,10.38 47.9,10.38 46.77,11.51 35.95,11.51 34.79,12.68 34.79,19.04 34.4,19.43 34.4,19.93 34.36,19.97 34.36,22.37 33.82,22.91 33.82,27.74 34.13,28.06 34.13,32.58 33.93,32.78 33.93,36.3 33.44,36.79 v6(33.44,37.68)
  BOTTOM w0.095: v5(134.53,69.61) 134.53,69.32 132.91,67.7 UCPU1.A9 ; v2(21.08,30.78) 21.08,29.8 21.59,29.29 v4(21.63,29.29)
TBT_A_VBUS_L: length 10.6
  IN3 w0.508: v8(16.23,27.08) 16.56,26.75 16.7,26.75 18.62,24.84 19.72,24.84 20.23,25.34 20.23,25.87 20.79,26.43 21.46,26.43 21.82,26.79 21.82,28.14 22.14,28.47 v8(22.14,28.75)
  BOTTOM w0.102: v2(22.67,29.42) 22.14,28.89 v8(22.14,28.75)
TBT_B_AUX_N: length 10.7
  IN1 w0.089: v7(30.02,35.04) 29.2,35.87 29.1,35.87 28.23,36.74 28.23,38.19 28.61,38.57 v1(28.61,38.74)
  GND1 w0.157: v3(28.69,39.34) 28.69,38.82 v1(28.61,38.74)
  IN3 w0.076: v3(31.06,41.29) 31.06,41.32 31.24,41.5 31.36,41.5 31.59,41.28 31.59,40.95 31.02,40.39 29.57,40.39 29.15,39.97 29.15,39.53 28.96,39.34 v3(28.69,39.34)
  GND3 w0.157: v4(30.6,41.36) 30.99,41.36 v3(31.06,41.29)
TBT_B_AUX_N_C: length 6.9
  IN3 w0.076: v3(29.46,41.29) 29.24,41.5 28.99,41.5 27.73,42.77 27.73,44.36 27.14,44.95 26.68,44.95 26.3,45.33 v3(26.17,45.33)
  GND3 w0.157: v3(26.17,45.33) 26.18,45.33 v4(26.44,45.6) ; v4(30.01,41.36) 29.52,41.36 v3(29.46,41.29)
TBT_B_AUX_P: length 10.7
  TOP w0.157: U20.J1 30.02,36.24 29.83,36.44 29.24,36.44 29.08,36.6 29.08,37.39 29.2,37.52 29.41,37.52 29.55,37.66 29.55,37.95 29.41,38.09 29.27,38.09 29.16,38.21 29.16,38.35 v1(29.55,38.74)
  GND1 w0.157: v3(29.48,39.33) 29.47,39.33 29.47,38.83 v1(29.55,38.74)
  IN3 w0.076: v3(29.48,39.33) 29.32,39.49 29.32,39.9 29.64,40.22 31.09,40.22 31.76,40.89 31.76,41.35 31.43,41.67 31.22,41.67 v3(31.03,41.87)
  GND3 w0.157: v4(30.6,41.99) 30.72,41.87 v3(31.03,41.87)
TBT_B_AUX_P_C: length 6.9
  IN3 w0.076: v3(29.45,42.04) 29.58,42.04 29.67,41.95 29.67,41.75 29.59,41.67 29.06,41.67 27.89,42.83 27.89,44.43 27.21,45.11 26.9,45.11 26.82,45.19 v3(26.82,45.34)
  GND3 w0.157: v4(27.09,45.6) 27.08,45.6 v3(26.82,45.34) ; v3(29.45,42.04) 29.5,41.99 v4(30.01,41.99)
TBT_B_CC1: length 63.5
  TOP w0.254: D44.1 7.47,55.65 v8(7.28,55.46)
  IN2 w0.508: v3(4.56,61.78) 3.85,61.07 3.85,58.88 4.87,57.87 6.77,57.87 7.28,57.36 v8(7.28,55.46) 7.24,55.42 7.24,52.92 6.68,52.36 4.89,52.36 3.51,50.98 3.51,42.71 6.19,40.04 6.19,37.54 5.23,36.58 5.23,33.77 v8(5.65,33.35)
  IN4 w0.508: v8(5.65,33.35) 6.13,33.35 6.91,32.57 6.91,30.9 7.5,30.31 7.93,30.31 8.97,29.28 16.63,29.28 18.36,31 22.5,31 23.07,30.44 27.66,30.44 28.42,31.19 v8(28.42,31.49)
  vias: v7(5.54,62.55) v7(5.8,62.55) v9(4.44,62.15) v9(4.7,62.15)
TBT_B_CC2: length 61.2
  IN3 w0.508: v8(6.54,35.6) 6.44,35.5 5.97,35.5 5.57,35.9 5.57,38.4 7.99,40.82 7.99,41.59 8.26,41.86 8.26,46.31 8.97,47.02 8.97,50.67 9.9,51.6 9.9,54.41 10.52,55.04 10.52,59.09 8.88,60.73 8.88,63.35 v3(10.4,64.87)
  IN4 w0.508: v8(6.54,35.6) 6.54,35.19 7.93,33.8 7.93,32.71 9.85,30.8 11.27,30.8 11.78,30.29 16.21,30.29 17.94,32.02 23.29,32.02 24.53,33.26 25,33.26 26.87,31.38 v8(27.62,31.38)
  BOTTOM w0.508: v8(27.62,31.38) 28.51,30.49 C162.1
  vias: v1(9.86,64.37) v1(10.26,64.35) v2(8.68,64.12)
TBT_B_DBG_CTL1: length 11.8
  IN1 w0.076: v7(32.02,34.04) 32.1,34.12 32.1,34.81 32.05,34.86 32.05,36.18 33.21,37.34 33.21,38.21 32.59,38.82 32.59,38.98 31.17,40.4 28.5,40.4 27.57,39.48 v7(27.57,39.43)
TBT_B_DBG_CTL2: length 13.6
  TOP w0.095: U20.D5 32.52,33.75 v7(32.63,33.85)
  IN1 w0.076: v7(32.63,33.85) 32.3,34.18 32.3,34.88 32.25,34.93 32.25,36.07 33.46,37.28 33.46,38.25 33.03,38.69 33.03,38.88 31.3,40.61 28.28,40.61 26.99,39.31 v7(26.99,39.17)
TBT_B_DEBUG3: length 4.1
  TOP w0.095: R218.2 25.5,34.98 RT59.1 26.27,35.12 26.48,35.34 27.14,35.34 27.56,34.92 v2(27.7,34.92) 28.08,34.54 U20.L3
TBT_B_DEBUG4: length 5.1
  TOP w0.095: RT60.1 26.21,34.37 R220.2 ; v7(29.85,34.51) 29.76,34.51 29.73,34.54 U20.K3
  IN1 w0.076: v7(29.85,34.51) 28.93,34.51 28.73,34.71 28.41,34.71 28.18,34.93 27.31,34.93 27.06,34.67 26.55,34.67 v7(26.3,34.42)
TBT_B_HPD: length 43.7
  GND1 w0.095: v1(36.59,30.89) 36.59,30.99 36.5,31.08 v3(36.5,31.22)
  GND3 w0.095: v3(36.5,31.22) 36.56,31.22 36.73,31.39 v6(36.8,31.39)
  IN4 w0.076: v5(23.75,56.98) 24.07,56.66 24.54,56.66 25.22,55.98 25.66,55.98 25.91,55.73 25.91,55.12 26.92,54.11 27.73,54.11 28,54.38 30.07,54.38 30.79,55.1 32.73,55.1 34.38,53.45 34.38,53.32 35.71,52 35.71,39.61 36.29,39.03 36.29,34.11 36.8,33.6 v6(36.8,31.39)
  BOTTOM w0.095: v5(23.75,56.98) 23.39,56.61 23.39,55.54 22.31,54.46 22,54.46 21.47,53.93 21.08,53.93 20.97,53.81 20.97,53.81 20.83,53.68 20.83,52.96 20.66,52.79 20.66,52.3 20.81,52.15 UT2.G2
TBT_B_I2C_B_N: length 45.2
  TOP w0.102: v8(12.47,62.69) 12.28,62.88 12.14,62.88 12.01,62.75 ML4.1
  GND1 w0.102: v1(29.02,32.54) 29.02,32 v3(28.97,31.95)
  IN2 w0.089: v3(28.97,31.95) 28.97,32.11 29.17,32.31 29.49,32.31 30.25,33.07 30.25,33.43 29.99,33.69 27.98,33.69 27.76,33.47 26.41,33.47 26.07,33.81 23.78,33.81 20.29,37.3 20.29,38.18 18.1,40.37 17.43,40.37 15.52,42.28 15.52,49.18 14.3,50.41 14.3,53.5 13.65,54.15 13.65,62.54 13.27,62.92 12.7,62.92 v8(12.47,62.69)
TBT_B_I2C_B_N_R: length 3.3
  TOP w0.102: JUSBC2.A7 8.03,62.8 8.17,62.93 9.26,62.93 D53.1 9.68,62.75 ML4.2
TBT_B_I2C_B_P: length 45.3
  TOP w0.102: ML4.4 12.44,63.25 v8(12.47,63.28)
  GND1 w0.102: v3(29.62,31.96) 29.52,32.05 v1(29.52,32.54)
  IN2 w0.089: v3(29.62,31.96) 29.64,31.96 30.61,32.93 30.61,33.57 30.14,34.04 27.83,34.04 27.61,33.83 26.56,33.83 26.22,34.17 23.92,34.17 20.65,37.44 20.65,38.33 18.25,40.73 17.57,40.73 15.87,42.42 15.87,49.33 14.65,50.55 14.65,53.64 14,54.29 14,62.69 13.41,63.28 v8(12.47,63.28)
TBT_B_I2C_B_P_R: length 3.3
  TOP w0.102: ML4.3 9.69,63.25 9.56,63.38 D55.1 9.33,63.16 8.16,63.16 8.02,63.3 JUSBC2.A6
TBT_B_I2C_INT#: length 39.5
  IN1 w0.076: v7(33.02,35.54) 33.01,35.54 32.8,35.34 32.8,34.79 v9(32.72,34.71)
  GND1 w0.095: v3(33.09,34.73) 33.07,34.71 v9(32.72,34.71)
  GND3 w0.095: v6(32.7,34.83) 32.81,34.73 v3(33.09,34.73)
  IN4 w0.076: v6(32.7,34.83) 32.7,35.15 32.01,35.84 32.01,37.6 33.26,38.85 33.26,40.6 32.68,41.18 31.92,41.18 31.2,40.45 29.64,40.45 26.74,43.35 24.61,43.35 23.85,44.11 22.71,44.11 22.22,44.6 22.22,48.34 21.57,48.99 21.57,49.74 21.49,49.82 21.1,49.82 20.92,49.99 20.92,50.31 20.74,50.49 19.8,50.49 19.64,50.65 19.64,51.91 19.88,52.15 v5(19.97,52.15) 20.34,52.15 20.83,52.64 20.83,53.65 22.74,55.56 22.74,56.78 22.29,57.23 22.29,57.77 21.74,58.31 v5(21.41,58.31)
TBT_B_LSRX: length 26
  GND1 w0.157: v1(18.59,50.73) 18.54,50.77 18.32,50.77 18.2,50.65 v3(18.2,50.63) ; v1(24.89,34.37) 24.72,34.55 v3(24.59,34.55)
  IN2 w0.076: v3(24.59,34.55) 24.59,34.75 21.57,37.77 21.57,38.02 18.46,41.13 17.83,41.13 16.99,41.96 16.99,44.54 18.09,45.63 18.09,49.87 18.61,50.4 18.61,50.9 18.5,51.02 18.22,51.02 18.11,50.91 18.11,50.72 v3(18.2,50.63)
  GND3 w0.157: v3(24.59,34.55) 24.59,34.35 v4(24.78,34.16) ; v4(18.59,50.77) 18.34,50.77 v3(18.2,50.63)
  BOTTOM w0.157: R5765.1 R216.1 26.03,33.11 25.58,33.11 25.28,33.41 25.28,33.87 25,34.16 v4(24.78,34.16)
TBT_B_LSRX_R: length 5.2
  TOP w0.157: U20.K4 29.52,33.98 29.72,33.79 v1(29.82,33.79)
  GND1 w0.157: v3(30.15,34.42) 29.82,34.1 v1(29.82,33.79)
  GND3 w0.157: v4(29.75,34.04) 29.77,34.04 v3(30.15,34.42)
  BOTTOM w0.157: v4(29.75,34.04) 29.68,34.04 28.96,33.33 27.21,33.33 26.86,32.98 R216.2
TBT_B_LSTX: length 25.9
  GND1 w0.157: v1(18.59,51.34) 18.27,51.34 v3(18.16,51.45) ; v3(25.24,35.01) v1(24.89,35.01)
  IN2 w0.076: v3(25.24,35.01) 24.87,35.01 21.95,37.93 21.95,38.17 18.61,41.51 17.99,41.51 17.38,42.12 17.38,44.38 18.47,45.47 18.47,49.72 18.99,50.24 18.99,51.06 18.64,51.41 18.2,51.41 v3(18.16,51.45)
  GND3 w0.157: v3(18.16,51.45) 18.37,51.45 v4(18.59,51.23) ; v4(25.5,34.57) 25.5,34.75 v3(25.24,35.01)
  BOTTOM w0.157: v4(25.5,34.57) 25.5,34 25.55,33.95 25.55,33.51 25.69,33.37 25.92,33.37 R215.1 R5764.1
TBT_B_LSTX_R: length 5.3
  TOP w0.157: v1(28.62,34.04) U20.L4
  GND1 w0.157: v3(27.91,34.47) 28.35,34.04 v1(28.62,34.04)
  GND3 w0.157: v4(28.27,34.12) 27.92,34.47 v3(27.91,34.47)
  BOTTOM w0.157: R215.2 26.77,33.59 28.86,33.59 29.06,33.79 29.06,34.02 28.96,34.12 v4(28.27,34.12)
TBT_B_RESET_N: length 50.2
  TOP w0.095: U20.F11 31.33,30.34 31.33,29.97 v7(31.59,29.71) ; v1(19.98,54.06) 19.98,54.24 v2(19.38,54.83)
  IN1 w0.076: v1(19.98,54.06) 22.12,54.06 23.01,54.95 23.01,55.88 25.43,58.3 29.09,58.3 31.12,56.26 31.12,44.44 32.85,42.71 33.65,42.71 34.37,42 34.37,41.31 34.91,40.76 34.91,40.02 36.31,38.62 36.31,33.16 36.01,32.85 36.01,31.89 35.74,31.63 35.3,31.63 34.75,32.17 34.2,32.17 34.04,32.01 34.04,31.45 33.74,31.14 33.38,31.14 33.12,31.4 32.81,31.4 32.64,31.24 32.64,30.58 32.4,30.34 32.1,30.34 31.59,29.83 v7(31.59,29.71)
TBT_B_SBU1: length 66.3
  IN1 w0.076: v9(26.67,33.96) 26.67,33.38 26.99,33.07 27.77,33.07 28.55,32.29 29.27,32.29 v7(29.52,32.04) ; v7(5.8,64.05) 5.8,63.94 6.13,63.61 6.13,63.2 6.05,63.13 5.88,63.13 5.46,63.56 4.33,63.56 3.49,62.71 3.49,59.38 5.12,57.74 7.54,57.74 7.7,57.58 7.7,57.33 v1(7.41,57.04) 7.74,56.71 7.74,56.48 7.6,56.34 6.77,56.34 6.36,55.93 6.36,54.33 3.24,51.2 3.24,42.32 5.86,39.7 5.86,38.91 6.19,38.58 6.19,36.84 v9(5.99,36.63)
  GND1 w0.095: v9(5.99,36.63) 6.15,36.46 v3(6.15,36.22) ; v3(27.12,34.21) 26.99,34.21 26.74,33.96 v9(26.67,33.96)
  GND3 w0.095: v3(6.15,36.22) 6.15,36.34 v6(6.34,36.53) ; v3(27.12,34.21) 27.12,34.11 v4(27.32,33.9)
  IN4 w0.076: v4(27.32,33.9) 26.9,33.9 25.27,35.53 9,35.53 7.5,37.02 6.83,37.02 v6(6.34,36.53)
  BOTTOM w0.095: v4(27.32,33.9) 26.98,34.25 R5764.2
TBT_B_SBU2: length 66.3
  TOP w0.095: v7(7.4,62.3) v2(8.63,62.3)
  IN1 w0.076: v7(7.4,62.3) 6.95,62.3 6.7,62.54 6.39,62.54 6.04,62.9 5.75,62.9 5.31,63.34 4.42,63.34 3.69,62.62 3.69,59.46 5.2,57.95 7.63,57.95 7.9,57.68 7.9,57.31 v1(8.17,57.04) 7.94,56.81 7.94,56.34 7.73,56.13 6.85,56.13 6.57,55.85 6.57,54.24 3.46,51.14 3.46,42.46 6.07,39.85 6.07,38.99 6.4,38.66 6.4,36.75 6.51,36.64 v9(6.54,36.64) ; v7(29.02,32.04) 28.51,32.04 27.69,32.86 27.23,32.86 27.15,32.79 27.15,32.36 v9(27.21,32.3)
  GND1 w0.095: v9(6.54,36.64) 6.69,36.49 v3(6.69,36.22) ; v9(27.21,32.3) 27.46,32.55 v3(27.54,32.55)
  GND3 w0.095: v6(6.83,36.53) 6.83,36.53 6.69,36.39 v3(6.69,36.22) ; v4(27.25,32.76) 27.46,32.55 v3(27.54,32.55)
  IN4 w0.076: v6(6.83,36.53) 7.12,36.82 7.42,36.82 8.91,35.33 25.19,35.33 27.25,33.27 v4(27.25,32.76)
  BOTTOM w0.095: R5765.2 27.16,32.76 v4(27.25,32.76)
TBT_B_USB2_D_N: length 19.4
  GND1 w0.102: v1(29.52,33.54) 29.52,33.58 29.24,33.87 29.24,34.87 v3(29.38,35.01)
  IN2 w0.089: v3(19.03,44.03) 19.38,44.03 19.48,44.14 19.48,44.28 19.36,44.41 18.77,44.41 18.61,44.26 18.61,43.77 21.37,41.01 21.37,40.09 22.74,38.72 22.74,38.26 24.05,36.96 27.54,36.96 29.38,35.12 v3(29.38,35.01)
  GND3 w0.102: v4(19.29,44.3) 19.29,44.3 v3(19.03,44.03)
TBT_B_USB2_D_P: length 19.4
  GND1 w0.102: v1(29.02,33.54) 29.01,33.56 29.01,34.78 v3(28.79,35.01)
  IN2 w0.089: v3(28.79,35.01) 28.79,35.21 27.4,36.6 23.9,36.6 22.39,38.11 22.39,38.57 21.02,39.94 21.02,40.87 18.26,43.63 18.26,44.4 18.64,44.79 v3(19.1,44.79)
  GND3 w0.102: v4(19.94,44.3) 19.8,44.3 19.39,44.71 19.17,44.71 v3(19.1,44.79)
TBT_B_USB2_T_N: length 43.3
  TOP w0.102: v8(8.89,53.22) 8.54,53.58 8.54,53.75 8.64,53.85 9.27,53.85 9.84,54.42 ML5.4
  GND1 w0.102: v3(28.44,33.29) 28.69,33.04 v1(29.02,33.04)
  IN2 w0.089: v8(8.89,53.22) 8.66,52.99 8.66,52.67 9.04,52.29 10.67,52.29 15.1,47.86 15.1,44.81 13.33,43.05 13.33,39.77 12.89,39.33 12.89,37.56 13.69,36.76 14.24,36.76 15.42,35.58 21.35,35.58 23.51,33.42 25.78,33.42 27.04,32.16 27.96,32.16 28.86,33.06 29.06,33.06 29.11,33.12 29.11,33.22 29.04,33.3 28.45,33.3 v3(28.44,33.29)
TBT_B_USB2_T_N_R: length 11.2
  TOP w0.102: ML5.3 9.84,56.94 D54.1 9.88,57.76 9.69,57.95 v8(9.69,58.21) ; JUSBC2.B7 6.49,63.55 v8(6.53,63.58)
  IN2 w0.089: v8(9.69,58.21) 9.69,59.13 10.23,59.66 10.23,61.65 8.29,63.58 v8(6.53,63.58)
TBT_B_USB2_T_P: length 43.3
  TOP w0.102: ML5.1 9.34,54.25 9.18,54.08 8.54,54.08 8.31,53.85 v8(8.31,53.22)
  GND1 w0.102: v1(29.52,33.04) 29.68,33.19 v3(29.83,33.19)
  IN2 w0.089: v8(8.31,53.22) 8.31,52.53 8.9,51.94 10.52,51.94 14.74,47.72 14.74,44.96 12.98,43.19 12.98,39.91 12.54,39.47 12.54,37.41 13.55,36.41 14.09,36.41 15.27,35.22 21.2,35.22 23.36,33.06 25.64,33.06 26.89,31.81 28.11,31.81 29.01,32.71 29.33,32.71 29.82,33.19 v3(29.83,33.19)
TBT_B_USB2_T_P_R: length 11.2
  TOP w0.102: v8(6.53,62.97) 6.46,62.97 6.39,63.05 JUSBC2.B6 ; v8(9.11,58.21) 9.65,57.66 9.65,57.46 9.55,57.36 9.42,57.36 9.25,57.19 D52.1 9.25,56.7 9.34,56.61 ML5.2
  IN2 w0.089: v8(9.11,58.21) 9.34,58.44 9.34,59.27 9.87,59.81 9.87,61.5 8.15,63.22 6.78,63.22 v8(6.53,62.97)
TBT_B_USB_OC1#: length 216.7
  IN4 w0.076: v5(33.59,30.54) 33.62,30.51 33.62,28.12 33.41,27.91 33.41,22.74 33.95,22.21 33.95,18.81 34.58,18.18 34.58,12.59 35.87,11.31 46.69,11.31 47.82,10.18 49.65,10.18 51.78,8.06 65.61,8.06 66.33,7.33 76.13,7.33 79.28,10.48 81.42,10.48 81.81,10.88 99.01,10.88 100.12,11.98 108.98,11.98 110.03,13.02 113.94,13.02 114.78,13.86 120.13,13.86 120.2,13.79 125.27,13.79 125.39,13.9 130.09,13.9 130.22,13.77 138.82,13.77 139.34,14.29 149.5,14.29 152.55,17.35 152.55,25.74 153.76,26.95 153.76,31.52 152.63,32.65 152.63,34.01 151.46,35.19 151.46,39.05 151.79,39.38 151.79,47.62 148.04,51.37 148.04,52.78 147.77,53.05 v5(147.77,53.31) 147.77,53.46 145.85,55.39 145.85,56.04 143.82,58.06 141.39,58.06 140.73,58.72 138.6,58.72 137.57,59.76 137.4,59.76 136.82,60.34 136.82,61.58 136.06,62.34 135.63,62.34 135.04,61.76 134.04,61.76 133.68,62.11 133.68,63.37 133.33,63.73 133.33,64.07 133.17,64.23 133.17,64.64 133.02,64.79 133.02,66.38 134.06,67.42 134.06,68.28 v5(135.43,69.65)
  BOTTOM w0.095: R204.2 33.83,30.3 v5(33.59,30.54) ; UCPU1.C9 132.91,65.14 133.25,65.47 133.25,67.46 v5(135.43,69.65)
TBT_B_VBUS_L:
  vias: v2(28.18,29.08) v8(28.11,28.52) v8(28.12,27.93) v8(34.57,31.65) v8(34.56,31.02)
TBT_BATLOW#: length 150.3
  IN1 w0.076: v9(123.29,72.29) 121.78,72.29 121.28,71.79 121.28,70.3 120.57,69.59 113.99,69.59 113.38,70.2 113.38,71.58 113,71.96 v9(113,71.97)
  GND1 w0.095: v3(123.64,72.18) 123.41,72.18 v9(123.29,72.29) ; v9(113,71.97) v3(112.65,71.97)
  GND3 w0.095: v6(123.94,72.43) 123.72,72.22 123.68,72.22 v3(123.64,72.18) ; v3(112.65,71.97) v6(112.3,71.97)
  IN4 w0.076: v5(23.25,57.6) 23.52,57.33 24.01,57.33 24.04,57.3 24.49,57.3 24.65,57.14 24.65,56.94 25.41,56.18 26.72,56.18 27.6,55.3 28.83,55.3 29.36,55.84 29.36,59.14 28.95,59.56 28.95,60.73 32.75,64.54 45.56,64.54 53,71.98 61.28,71.98 61.99,72.69 78.02,72.69 79.75,70.95 83.28,70.95 84.04,71.71 85.65,71.71 87.01,73.08 90.73,73.08 91.03,72.78 93.57,72.78 94.06,72.28 95.17,72.28 96.37,73.47 106.53,73.47 109.11,70.89 112.4,70.89 112.77,71.26 112.77,71.5 v6(112.3,71.97) ; v5(132.83,63.86) 132.69,64 132.69,64.42 132.56,64.56 132.56,66.58 133.6,67.62 133.6,69.18 134.61,70.19 134.61,71.67 133.71,72.56 124.07,72.56 v6(123.94,72.43)
  BOTTOM w0.076: UCPU1.D8 133.48,64.15 133.25,63.92 132.91,63.92 132.86,63.86 v5(132.83,63.86)
  BOTTOM w0.095: RT30.2 23.25,58.25 v5(23.25,57.6) 22.94,57.28 22.94,55.94 21.95,54.95 21.85,54.95 21.23,54.34 20.87,54.34 20.46,53.93 20.46,53.18 20.2,52.91 20.2,52.38 20.43,52.15 UT2.F2
TBT_C_DBG_CTL1: length 30.1
  IN4 w0.076: v5(286.52,15.82) 286.6,15.82 286.82,16.05 286.82,17.06 286.69,17.19 286.01,17.19 285.94,17.13 283.8,17.13 283.71,17.23 282.08,17.23 281.55,17.76 280.8,17.76 280.08,18.47 277.7,18.47 277.27,18.9 277.27,19.96 276.4,20.83 276.4,26.31 278.75,28.66 279.52,28.66 280.63,27.55 284.74,27.55 v5(285.29,26.99)
TBT_C_DBG_CTL2: length 28.1
  IN4 w0.076: v5(287.02,15.32) 287.02,17.15 286.78,17.39 285.92,17.39 285.86,17.33 283.89,17.33 283.79,17.43 282.17,17.43 281.63,17.96 280.88,17.96 280.17,18.68 277.83,18.68 277.5,19 277.5,20.02 276.66,20.86 276.66,26.21 278.86,28.4 279.41,28.4 280.53,27.29 283.26,27.29 v5(283.55,26.99)
TBT_C_DEBUG1: length 2.8
  BOTTOM w0.095: R236.2 284.42,20.5 284.42,19.61 284.91,19.13 285.22,19.13 U21.L2
TBT_C_DEBUG2: length 3.4
  IN4 w0.076: v5(285.06,19.43) 285.31,19.17 285.31,18.53 v5(285.52,18.33)
  BOTTOM w0.095: R238.2 285.35,20.75 285.08,20.48 284.75,20.48 284.64,20.38 284.64,19.84 v5(285.06,19.43)
TBT_C_DEBUG3: length 1.5
  BOTTOM w0.095: R5787.2 285.59,19.49 286.02,19.07 U21.L3
TBT_C_DEBUG4: length 2.7
  IN4 w0.076: v5(286.02,18.33) 286.02,19.7 285.98,19.74 285.98,20.34 286.43,20.79 v5(286.48,20.79)
TBT_C_LSRX_R: length 2.7
  IN4 w0.076: v5(286.32,17.94) 286.32,18.23 286.41,18.32 286.41,19.65 286.3,19.77 v5(286.3,20.06)
  BOTTOM w0.095: U21.K4 286.52,18.14 v5(286.32,17.94)
TBT_C_LSTX_R: length 1.6
  BOTTOM w0.095: U21.L4 286.52,19.36 287.02,19.85 R5790.2
TBT_CIO_PLUG_EVENT#: length 140.3
  IN1 w0.076: v8(131.27,54.62) 131.21,54.68 130.47,54.68 130.3,54.51 130.3,53.52 129.99,53.22 125.75,53.22 124.73,54.23 124.73,57.32 124.17,57.88 124.17,59.06 124.23,59.13 124.23,60.87 123.76,61.34 123.76,62.69 123.4,63.05 123.13,63.05 121.93,64.24 119.48,64.24 119.15,64.57 117.48,64.57 117.23,64.33 112.57,64.33 110.81,66.09 110.81,66.83 110.2,67.44 105.6,67.44 105.38,67.22 99.62,67.22 99.2,67.64 98.03,67.64 97.68,67.29 94.04,67.29 92.91,68.42 92.91,69.16 90.3,71.77 86.8,71.77 84.71,69.68 79.42,69.68 77.74,71.36 58.21,71.36 57.77,70.92 51.87,70.92 51.66,70.71 45.53,70.71 45.03,71.21 43.85,71.21 43,70.37 43,68.87 43.61,68.26 43.85,68.26 44.58,67.54 v7(44.58,65.4) v9(44.58,64.05)
  GND1 w0.095: v9(44.58,64.05) 44.19,64.05 v3(44.18,64.03)
  GND3 w0.095: v6(43.79,64.03) v3(44.18,64.03)
  IN4 w0.076: v6(43.79,64.03) 33.04,64.03 30.47,61.46 30.47,56.33 29.68,55.54 29.68,55.17 29.5,54.99 27.9,54.99 v5(27.52,54.6)
  BOTTOM w0.095: RT29.2 27.53,54.12 26.64,53.23 26.64,52.38 UT2.W2
  BOTTOM w0.112: UCPU1.AB12 130.93,54.96 v8(131.27,54.62)
TBT_DDC_CLK: length 3.3
  BOTTOM w0.095: UT2.Y2 27.1,52.38 27.1,52.79 28.8,54.48 RT11.2
TBT_DDC_DATA: length 2.5
  BOTTOM w0.095: UT2.Y1 26.87,52.95 28.17,54.24 RT13.2
TBT_DP_AUX_N: length 317.1
  GND1 w0.102: v3(276.32,23.93) 276.15,24.1 v1(276.03,24.1)
  IN3 w0.076: v3(26.85,44.58) 26.65,44.58 26.55,44.48 26.55,44.4 26.35,44.2 26.35,44 26.55,43.8 26.55,43.44 27.76,42.24 27.76,41.01 28.08,40.69 28.08,40.3 28.3,40.09 28.3,39.21 29.62,37.9 31.89,37.9 32.11,37.67 33.87,37.67 36.46,35.09 36.46,31.78 36.12,31.44 36.12,26.14 37.45,24.8 37.45,23.01 37.97,22.49 37.97,20.07 37.58,19.68 37.58,18.27 38.09,17.77 38.09,12.57 37.78,12.26 37.78,9.26 38.03,9 47.1,9 48.34,7.76 58.21,7.76 58.82,7.15 71.04,7.15 71.44,6.75 75.86,6.75 78.51,9.4 108.53,9.4 112.17,13.05 116.13,13.05 117.08,14 145.63,14 145.96,13.66 150.45,13.66 151.38,12.73 156.59,12.73 157.75,11.58 157.75,10.58 159.08,9.25 159.08,7.68 159.54,7.21 163.44,7.21 164.58,6.07 165.84,6.07 166.25,5.67 167.83,5.67 168.36,6.2 183.46,6.2 185.04,4.62 218.15,4.62 220.86,7.33 225.21,7.33 227.8,4.74 258.07,4.74 264.51,11.18 264.83,11.18 266.68,13.03 266.68,15.72 267.95,16.99 267.95,17.65 268.66,18.37 268.66,20.7 269.23,21.26 272.28,21.26 273.84,22.82 273.84,23.24 274.43,23.82 275.65,23.82 275.9,23.58 275.97,23.58 v3(276.32,23.93) 276.55,23.69 276.88,23.69 277.34,23.23 278.77,23.23 279.37,22.63 281.81,22.63 283.25,21.19 283.25,19.88 282.81,19.44 v3(282.81,19.4)
  GND3 w0.102: v3(26.85,44.58) 26.87,44.58 27.09,44.36 v4(27.09,44.3) ; v4(282.61,19.13) 282.61,19.2 v3(282.81,19.4)
TBT_DP_AUX_N_C: length 4.2
  TOP w0.102: R44.2 276.56,23.67 275.81,23.67 275.66,23.82 275.44,24.04 C65.2 275.1,23.73 275.09,23.74 274.91,23.74 274.17,24.48 U30.25
TBT_DP_AUX_P: length 317.1
  GND1 w0.102: v1(276.05,22.98) 276.26,23.2 v3(276.3,23.2)
  IN3 w0.076: v3(26.18,44.56) 26.18,43.94 26.39,43.73 26.39,43.37 27.59,42.17 27.59,40.94 27.92,40.62 27.92,39.06 29.46,37.52 31.73,37.52 31.95,37.29 33.71,37.29 36.08,34.93 36.08,31.94 35.73,31.6 35.73,25.98 37.07,24.65 37.07,22.85 37.59,22.33 37.59,20.23 37.2,19.84 37.2,18.12 37.71,17.61 37.71,12.73 37.4,12.41 37.4,9.1 37.88,8.62 46.94,8.62 48.19,7.38 58.05,7.38 58.66,6.77 70.88,6.77 71.29,6.37 76.02,6.37 78.67,9.02 108.69,9.02 112.33,12.67 116.29,12.67 117.24,13.62 145.47,13.62 145.8,13.28 150.29,13.28 151.22,12.35 156.43,12.35 157.37,11.42 157.37,10.42 158.7,9.1 158.7,7.52 159.38,6.83 163.28,6.83 164.42,5.69 165.69,5.69 166.09,5.29 167.99,5.29 168.52,5.82 183.31,5.82 184.89,4.24 218.31,4.24 221.01,6.95 225.05,6.95 227.64,4.36 258.23,4.36 264.67,10.79 264.98,10.79 267.06,12.87 267.06,15.57 268.33,16.83 268.33,17.49 269.04,18.21 269.04,20.54 269.38,20.88 272.44,20.88 274.22,22.66 274.22,23.08 274.58,23.44 275.49,23.44 275.74,23.2 v3(276.3,23.2) 276.41,23.31 276.72,23.31 277.19,22.85 278.61,22.85 279.21,22.25 281.65,22.25 282.87,21.04 282.87,20.03 282.42,19.59 282.27,19.59 282.07,19.79 282.07,19.9 v3(282.28,20.11)
  GND3 w0.102: v3(282.28,20.11) 282.33,20.15 v4(282.61,20.15) ; v4(26.44,44.3) v3(26.18,44.56)
TBT_DP_AUX_P_C: length 4.2
  TOP w0.102: U30.24 274.17,24.08 v10(274.68,23.58) 274.84,23.41 275.02,23.41 C64.2 275.44,23.05 275.78,23.39 276.57,23.39 R45.2
TBT_DP_HPD: length 371.3
  TOP w0.095: v7(113.05,13.28) 113.89,12.44 115.97,12.44 v2(115.99,12.45) 116.5,12.96 120.98,12.96 122.61,14.59 130.18,14.59 130.56,14.2 137.99,14.2 138.81,15.03 146,15.03 v7(146.21,14.82) ; v1(280.7,28.29) 280.7,28.35 280.6,28.45 279.68,28.45 R5833.2 278.91,29.84 276.17,32.58 275.05,32.58 274.68,32.94 273.92,32.94 272.43,31.44 R50.1 267.91,31.29 267.49,30.87 v1(266.45,30.87)
  IN1 w0.076: v9(31.03,15.07) 31.8,14.29 31.8,12.89 32.27,12.42 35.3,12.42 35.86,11.87 48.15,11.87 52.57,7.44 60.47,7.44 61.06,6.85 65.95,6.85 66.36,6.45 70.49,6.45 70.98,5.95 72.66,5.95 72.94,6.24 75.8,6.24 80.17,10.62 103.82,10.62 105.72,12.52 108.3,12.52 109.36,13.57 112.76,13.57 v7(113.05,13.28) ; v9(25.06,56.37) 25.06,56.88 25.74,57.56 28.36,57.56 29.2,56.72 29.2,56.43 30.15,55.48 30.15,51.74 29.08,50.67 29.08,46.06 29.82,45.32 29.82,43.61 25.64,39.43 25.64,37.91 24.37,36.64 23.92,36.64 23.59,36.31 23.59,35.91 22.96,35.28 22.96,34.61 23.57,34 23.57,33.3 23.76,33.11 23.76,30.97 23.52,30.74 23.3,30.74 21.49,28.92 21.49,27.21 21.98,26.72 21.98,26.34 v9(21.38,25.74) ; v9(173.9,16.5) 173.87,16.5 173.6,16.23 163.49,16.23 163.14,15.88 156.82,15.88 156.43,15.49 153.51,15.49 153.12,15.09 147.07,15.09 146.79,14.82 v7(146.21,14.82)
  GND1 w0.095: v3(30.77,15.7) 30.77,15.58 31.03,15.32 v9(31.03,15.07) ; v3(280.88,27.98) 280.88,28.11 v1(280.7,28.29) ; v9(21.38,25.74) 20.99,25.74 v3(20.87,25.61) ; v1(266.45,30.87) 266.22,30.87 265.89,31.19 v3(265.77,31.19) ; v3(173.73,16.85) 173.73,16.68 v9(173.9,16.5) ; v9(25.06,56.37) 24.85,56.37 v3(24.67,56.19)
  GND3 w0.095: v6(266.27,31.04) 265.92,31.04 v3(265.77,31.19) ; v3(24.67,56.19) 24.6,56.19 24.45,56.34 v4(24.33,56.34) ; v3(20.87,25.61) v6(20.87,25.23) ; v6(173.91,17.42) 173.73,17.24 v3(173.73,16.85) ; v3(280.88,27.98) 280.91,27.96 281.18,27.96 v6(281.28,27.86) ; v6(30.92,16.11) 30.92,15.85 v3(30.77,15.7)
  IN4 w0.076: v6(20.87,25.23) 20.49,24.85 20.49,24.59 20.49,24.59 20.49,23.96 21.76,22.69 23.55,20.9 27.61,20.9 28.76,19.74 28.76,19.34 30.92,17.18 v6(30.92,16.11) ; v5(295.12,16.21) 295.25,16.34 295.25,17.99 294.77,18.47 293.64,18.47 290.62,21.49 290.62,23.68 290.44,23.87 289.61,23.87 288.97,24.51 288.97,25.41 287.81,26.58 286.32,26.58 285.1,27.8 281.34,27.8 v6(281.28,27.86) ; v6(173.91,17.42) 173.91,18.12 174.23,18.45 176.46,18.45 181.6,13.31 182.73,13.31 184.17,11.86 185.54,11.86 187.81,9.6 194,9.6 194.27,9.87 199.84,9.87 201.09,11.12 203.16,11.67 205.49,11.67 207.27,13.45 208.43,13.45 210.78,15.79 224.67,15.79 227.97,12.49 231.32,12.49 233.07,10.74 245.46,10.74 245.97,11.25 247.33,11.25 247.67,11.59 250.68,11.59 252.1,13.01 253.08,13.01 257.68,17.61 260.26,17.61 262.55,19.9 262.55,23.71 264.45,25.62 264.45,28.66 265.09,29.29 265.09,29.86 v6(266.27,31.04)
TBT_DP_HPD_R: length 5.6
  TOP w0.095: U30.32 271.51,27 271.96,27.44 271.96,28.3 272.49,28.84 272.49,29.38 273.29,30.18 RC393.2 R50.2
TBT_DP_ML0_N: length 315.2
  TOP w0.102: C53.1 266.12,18.73 266.12,18.1 v10(267.57,16.65) 268.28,15.94 268.28,15.46 v8(268.46,15.27)
  IN3 w0.076: v8(268.46,15.27) 268.36,15.16 268.36,13.03 265.3,9.98 264.98,9.98 258.6,3.6 227.27,3.6 225.65,5.21 221.68,5.21 219.94,3.47 184.57,3.47 183,5.04 178.61,5.04 178.21,4.65 168.43,4.65 168.31,4.53 165.58,4.53 165.23,4.88 164.15,4.88 163.03,6.01 159.12,6.01 157.11,8.02 153.53,8.02 153.1,8.44 153.1,9.66 152.21,10.55 150.34,10.55 148.46,12.43 145.58,12.43 145.16,12.85 122.47,12.85 121.53,11.9 112.64,11.9 108.76,8.02 78.75,8.02 76.33,5.61 70.97,5.61 70.61,5.97 58.38,5.97 57.76,6.59 47.75,6.59 46.93,7.41 38.02,7.41 36.62,8.8 36.62,9.91 35.88,10.65 35.88,24.44 34.97,25.35 34.97,32.03 35.16,32.22 35.16,32.74 34.87,33.04 34.87,33.96 35.18,34.28 35.18,34.75 33.73,36.2 29.08,36.2 26.32,38.96 23.62,38.96 23.21,38.55 22.3,38.55 21.66,39.19 21.66,41.07 23.94,43.35 23.94,44.98 24.07,45.1 24.07,45.29 24.8,46.03 24.8,49.1 25.27,49.57 25.27,52.4 24.27,53.41 24.27,53.96 v3(24.05,54.18)
  GND3 w0.102: v3(24.05,54.18) v4(24.05,53.81)
  BOTTOM w0.076: v4(24.05,53.81) 24.14,53.81 24.39,53.56 24.39,52.94 24.34,52.9 24.34,52.53 24.42,52.46 24.49,52.46 24.57,52.54 UT2.R1
TBT_DP_ML0_N_C: length 4.4
  TOP w0.102: C53.2 266.1,19.68 266.1,20.12 267.28,21.3 268.2,21.3 268.71,21.81 U30.10
TBT_DP_ML0_P: length 315.4
  TOP w0.102: v8(267.85,15.29) 268,15.44 268,15.82 v10(266.25,17.57) 265.84,17.99 265.84,18.6 C52.1
  IN3 w0.076: v8(267.85,15.29) 267.97,15.17 267.97,13.19 265.14,10.36 264.82,10.36 258.44,3.98 227.42,3.98 225.81,5.59 221.52,5.59 219.78,3.85 184.73,3.85 183.15,5.42 178.45,5.42 178.06,5.03 168.28,5.03 168.15,4.91 165.74,4.91 165.39,5.26 164.31,5.26 163.19,6.39 159.28,6.39 157.27,8.4 153.68,8.4 153.48,8.6 153.48,9.82 152.37,10.93 150.49,10.93 148.62,12.81 145.74,12.81 145.31,13.23 122.31,13.23 121.37,12.29 112.49,12.29 108.6,8.4 78.59,8.4 76.17,5.99 71.13,5.99 70.77,6.35 58.54,6.35 57.92,6.97 47.9,6.97 47.09,7.79 38.17,7.79 37,8.96 37,10.07 36.26,10.8 36.26,24.6 35.35,25.51 35.35,31.88 35.54,32.07 35.54,32.9 35.25,33.2 35.25,33.8 35.56,34.12 35.56,34.9 33.89,36.58 29.24,36.58 26.48,39.34 23.46,39.34 23.05,38.93 22.46,38.93 22.04,39.35 22.04,40.91 24.32,43.19 24.32,44.95 24.23,45.04 24.23,45.22 24.96,45.96 24.96,49.03 25.43,49.5 25.43,52.47 24.43,53.47 24.43,54.46 24.54,54.57 24.93,54.57 25.04,54.46 25.04,54.26 v3(24.84,54.06)
  GND3 w0.102: v4(24.58,53.79) 24.58,53.81 v3(24.84,54.06)
  BOTTOM w0.076: UT2.R2 24.79,52.36 24.79,52.81 24.55,53.05 24.55,53.76 v4(24.58,53.79)
TBT_DP_ML0_P_C: length 4.4
  TOP w0.102: U30.9 268.31,21.81 268.08,21.58 267.17,21.58 v10(266.2,20.61) 265.82,20.24 265.82,19.79 C52.2
TBT_DP_ML1_N: length 317.4
  TOP w0.102: v8(269.31,17.39) 268.99,17.71 268.99,18.25 268.53,18.7 268.53,19.62 C56.1
  IN3 w0.076: v8(269.31,17.39) 270.07,17.39 270.55,16.92 270.55,14.12 263.85,7.42 263.52,7.42 258.93,2.83 226.9,2.83 225.33,4.4 222.09,4.4 220.39,2.71 184.2,2.71 182.67,4.23 179.09,4.23 178.71,3.85 169.03,3.85 168.87,3.69 165.06,3.69 164.66,4.09 163.83,4.09 162.67,5.24 158.81,5.24 157.03,7.01 155.52,7.01 154.65,6.14 153.67,6.14 148.14,11.67 139.57,11.67 139.36,11.88 129.76,11.88 129.48,11.6 122.3,11.6 121.84,11.14 112.98,11.14 109,7.16 79.03,7.16 76.71,4.84 59.34,4.84 58.97,5.21 52.36,5.21 51.74,5.83 49.14,5.83 48.74,5.43 47.83,5.43 46.66,6.6 37.74,6.6 35.11,9.24 35.11,23.05 34.17,23.99 34.17,28.46 33.73,28.9 33.73,30.87 32.85,31.76 31.58,31.76 30.71,32.63 30.71,34.49 29.82,35.38 28.65,35.38 26.24,37.78 21.99,37.78 20.86,38.91 20.86,41.45 21.93,42.52 21.93,43.91 22.05,44.03 22.05,44.76 21.75,45.06 21.75,45.84 23.32,47.41 23.32,50.56 23.82,51.07 23.82,51.85 23.08,52.59 23.08,53.42 22.66,53.84 v3(22.6,53.84)
  GND3 w0.102: v4(22.95,53.84) v3(22.6,53.84)
  BOTTOM w0.076: v4(22.95,53.84) 23.12,53.84 23.45,53.5 23.45,53.09 23.43,53.06 23.43,52.56 23.5,52.48 23.6,52.48 23.65,52.54 UT2.N1
TBT_DP_ML1_N_C: length 2.6
  TOP w0.102: U30.13 269.91,21.67 269.21,20.97 268.89,20.97 268.64,20.72 268.64,20.57 C56.2
TBT_DP_ML1_P: length 317.4
  TOP w0.102: v8(268.72,17.33) 268.71,17.34 268.71,18.13 v10(268.44,18.4) 268.25,18.59 268.25,19.74 C54.1
  IN3 w0.076: v3(23.32,54.15) 23.28,54.15 22.95,54.47 22.8,54.47 22.7,54.37 22.7,54.27 22.99,53.98 22.99,53.74 23.25,53.49 23.25,52.66 23.99,51.92 23.99,51 23.48,50.49 23.48,47.34 21.91,45.77 21.91,45.13 22.22,44.83 22.22,43.98 22.32,43.89 22.32,42.36 21.24,41.29 21.24,39.06 22.15,38.16 26.4,38.16 28.81,35.76 29.98,35.76 31.09,34.65 31.09,32.78 31.73,32.14 33,32.14 34.11,31.03 34.11,29.06 34.55,28.62 34.55,24.14 35.49,23.21 35.49,9.39 37.9,6.98 46.81,6.98 47.98,5.81 48.58,5.81 48.98,6.21 51.89,6.21 52.52,5.59 59.13,5.59 59.5,5.22 76.55,5.22 78.87,7.54 108.84,7.54 112.82,11.52 121.69,11.52 122.14,11.98 129.32,11.98 129.6,12.26 139.51,12.26 139.73,12.05 148.3,12.05 153.83,6.52 154.49,6.52 155.36,7.4 157.19,7.4 158.96,5.63 162.83,5.63 163.99,4.47 164.82,4.47 165.22,4.07 168.71,4.07 168.87,4.23 178.55,4.23 178.93,4.61 182.83,4.61 184.36,3.09 220.23,3.09 221.93,4.78 225.49,4.78 227.06,3.21 258.77,3.21 263.36,7.8 263.7,7.8 270.17,14.27 270.17,16.76 269.93,17 269.05,17 v8(268.72,17.33)
  GND3 w0.102: v4(23.52,53.87) 23.52,53.95 v3(23.32,54.15)
  BOTTOM w0.076: UT2.N2 23.87,52.37 23.87,52.9 23.62,53.16 23.62,53.57 23.52,53.66 v4(23.52,53.87)
TBT_DP_ML1_P_C: length 2.5
  TOP w0.102: U30.12 269.51,21.67 269.09,21.25 269.01,21.25 268.78,21.25 268.36,20.83 268.36,20.67 C54.2
TBT_DP_ML2_N: length 323.3
  TOP w0.102: C59.1 270.87,19.97 270.87,19.48 v8(270.92,19.44)
  IN3 w0.076: v3(21.8,53.43) 21.8,53.48 21.96,53.64 22.03,53.64 22.17,53.5 22.17,52.36 22.63,51.9 22.63,50.73 22.29,50.4 22.29,49.87 20.68,48.26 20.68,46.42 20.62,46.35 20.62,45.24 20.72,45.14 20.72,43.54 20.07,42.89 20.07,38.5 21.55,37.02 25.79,37.02 26.49,36.31 26.49,34.69 26.33,34.53 26.33,31.43 27.24,30.51 29,30.51 29.43,30.94 31.83,30.94 32.81,29.96 32.81,28.63 33.41,28.04 33.41,23.56 34.34,22.63 34.34,17.39 33.76,16.81 33.76,15.56 34.05,15.28 34.05,8.75 35.71,7.08 35.71,5.68 36.44,4.95 47.23,4.95 47.6,4.58 48.96,4.58 49.45,5.07 51.42,5.07 52.04,4.45 58.65,4.45 59.02,4.08 77.08,4.08 79.36,6.35 109.27,6.35 113.3,10.38 134.51,10.38 135.01,10.88 147.85,10.88 154.25,4.48 160.52,4.48 162.16,2.84 169.2,2.84 169.45,3.09 179.33,3.09 179.7,3.45 182.35,3.45 183.86,1.94 220.71,1.94 222.31,3.55 225.11,3.55 226.59,2.07 259.94,2.07 266.49,8.63 268.03,8.63 269.48,10.08 269.48,11.46 271.31,13.29 271.31,16.17 271.73,16.59 271.73,17.63 270.79,18.57 270.79,19.32 v8(270.92,19.44)
  GND3 w0.102: v4(22.17,53.43) v3(21.8,53.43)
  BOTTOM w0.076: UT2.L1 22.75,52.59 22.75,52.48 22.67,52.4 22.57,52.4 22.5,52.47 22.5,52.83 22.59,52.92 22.71,52.92 22.77,52.97 22.77,53.08 22.67,53.17 22.67,53.46 22.48,53.65 22.35,53.65 22.17,53.47 v4(22.17,53.43)
TBT_DP_ML2_N_C: length 1.7
  TOP w0.102: U30.16 271.11,21.85 271.06,21.79 271.06,21.21 270.87,21.03 270.87,20.84 C59.2
TBT_DP_ML2_P: length 323.2
  TOP w0.102: v8(270.28,19.44) 270.45,19.6 C58.1
  IN3 w0.076: v3(22.07,54.2) 21.56,54.2 21.48,54.12 21.48,53.95 21.62,53.82 22.09,53.82 22.34,53.57 22.34,52.43 22.8,51.97 22.8,50.67 22.46,50.33 22.46,49.8 21.65,48.99 21.65,48.68 21.07,48.11 21.07,46.26 21,46.19 21,45.4 21.1,45.3 21.1,43.39 20.45,42.73 20.45,38.66 21.71,37.4 25.95,37.4 26.87,36.47 26.87,34.53 26.71,34.37 26.71,31.58 27.4,30.89 28.84,30.89 29.27,31.33 31.98,31.33 33.19,30.12 33.19,28.79 33.79,28.2 33.79,23.72 34.72,22.79 34.72,17.23 34.14,16.65 34.14,15.72 34.43,15.44 34.43,8.9 36.1,7.24 36.1,5.84 36.6,5.33 47.39,5.33 47.76,4.96 48.8,4.96 49.3,5.45 51.58,5.45 52.2,4.83 58.81,4.83 59.18,4.46 76.92,4.46 79.2,6.73 109.11,6.73 113.14,10.76 134.35,10.76 134.85,11.26 148.01,11.26 154.41,4.86 160.68,4.86 162.31,3.22 169.05,3.22 169.29,3.47 179.17,3.47 179.54,3.83 182.51,3.83 184.02,2.33 220.55,2.33 222.16,3.93 225.26,3.93 226.74,2.45 259.78,2.45 266.33,9.01 267.87,9.01 269.1,10.24 269.1,11.62 270.93,13.45 270.93,16.33 271.35,16.75 271.35,17.48 270.41,18.41 270.41,19.3 v8(270.28,19.44)
  GND3 w0.102: v4(22.13,53.85) 22.07,53.92 v3(22.07,54.2)
  BOTTOM w0.076: v4(22.13,53.85) 22.16,53.82 22.54,53.82 22.84,53.53 22.84,53.26 22.95,53.15 22.95,52.37 UT2.L2
TBT_DP_ML2_P_C: length 1.7
  TOP w0.102: U30.15 270.71,21.85 270.78,21.79 270.78,21.32 270.59,21.14 270.59,20.84 C58.2
TBT_DP_ML3_N: length 324.6
  TOP w0.102: v8(273.42,17.72) 273.58,17.88 273.85,17.88 274.12,18.14 274.12,18.85 273.84,19.14 273.84,19.41 C61.1
  IN3 w0.076: v3(20.86,53.57) 20.33,53.57 19.27,52.5 19.27,50.59 18.56,49.88 18.56,47.06 19.48,46.14 19.48,43.44 19.27,43.23 19.27,38.17 21.2,36.25 25.37,36.25 25.73,35.88 25.73,35.01 25.57,34.84 25.57,31.05 27.09,29.52 30.15,29.52 31.19,28.49 31.19,27.16 32.32,26.02 32.32,23.6 31.95,23.23 31.95,19.63 32.62,18.96 32.62,17.48 32.43,17.29 32.43,15.62 31.78,14.96 31.78,13.42 32.9,12.3 32.9,8.67 34.62,6.94 34.62,5.7 36.2,4.12 46.98,4.12 47.29,3.81 49.28,3.81 49.77,4.31 50.94,4.31 51.56,3.68 58.34,3.68 58.71,3.32 77.4,3.32 79.65,5.57 109.6,5.57 113.62,9.59 134.79,9.59 135.27,10.07 143.45,10.07 144.2,9.32 148.22,9.32 153.82,3.72 160.14,3.72 161.87,1.99 169.58,1.99 169.9,2.31 182.3,2.31 183.43,1.18 221.25,1.18 222.84,2.77 224.81,2.77 226.35,1.23 262.05,1.23 269.45,8.64 270.37,8.64 270.92,9.18 270.92,11.09 272.58,12.75 272.58,16.83 272.49,16.92 272.49,17.62 272.73,17.86 273.08,17.86 273.22,17.72 v8(273.42,17.72)
  GND3 w0.102: v4(21.34,53.45) 21.16,53.45 21.04,53.57 v3(20.86,53.57)
  BOTTOM w0.076: v4(21.34,53.45) 21.52,53.45 21.65,53.32 21.65,53.06 21.81,52.9 UT2.J1
TBT_DP_ML3_N_C: length 3.2
  TOP w0.102: U30.19 272.31,21.95 272.2,21.84 272.2,21.69 272.31,21.58 272.78,21.58 v10(273.33,21.03) 273.76,20.6 273.76,20.2 C61.2
TBT_DP_ML3_P: length 324.7
  TOP w0.102: v8(273.44,18.56) 273.3,18.42 273.3,18.27 273.41,18.16 273.74,18.16 273.84,18.26 273.84,18.74 273.56,19.02 273.56,19.15 273.55,19.16 273.55,19.26 C60.1
  IN3 w0.076: v3(20.87,52.98) 20.87,53.11 20.8,53.18 20.49,53.18 19.65,52.34 19.65,50.43 18.94,49.72 18.94,47.22 19.86,46.3 19.86,43.29 19.65,43.07 19.65,38.33 21.35,36.63 25.52,36.63 26.11,36.04 26.11,34.85 25.95,34.68 25.95,31.2 27.25,29.9 30.31,29.9 31.57,28.64 31.57,27.32 32.7,26.18 32.7,23.45 32.33,23.07 32.33,19.79 33,19.12 33,17.32 32.81,17.14 32.81,15.46 32.16,14.8 32.16,13.58 33.28,12.46 33.28,8.82 35,7.1 35,5.85 36.36,4.5 47.14,4.5 47.45,4.2 49.12,4.2 49.61,4.69 51.1,4.69 51.72,4.06 58.5,4.06 58.86,3.7 77.24,3.7 79.5,5.95 109.45,5.95 113.46,9.97 134.64,9.97 135.12,10.45 143.61,10.45 144.36,9.7 148.38,9.7 153.98,4.1 160.3,4.1 162.02,2.37 169.42,2.37 169.74,2.69 182.46,2.69 183.59,1.56 221.09,1.56 222.68,3.15 224.97,3.15 226.5,1.61 261.89,1.61 269.29,9.02 270.21,9.02 270.54,9.34 270.54,11.24 272.2,12.91 272.2,16.68 272.11,16.77 272.11,17.78 272.58,18.24 273.24,18.24 273.33,18.16 273.74,18.16 273.86,18.28 273.86,18.42 273.72,18.56 v8(273.44,18.56)
  GND3 w0.102: v3(20.87,52.98) 20.98,52.98 21.05,53.05 v4(21.35,53.05)
  BOTTOM w0.076: UT2.J2 21.58,52.38 21.58,52.89 21.42,53.05 v4(21.35,53.05)
TBT_DP_ML3_P_C: length 3.1
  TOP w0.102: C60.2 273.43,20.16 273.43,20.53 272.67,21.3 272.2,21.3 271.92,21.57 271.92,21.77 271.91,21.78 U30.18
TBT_FORCE_PWR: length 264
  TOP w0.095: v8(139.88,66.23) 140.1,66.02 140.1,63.86 139.66,63.43 139,63.43 138.06,64.38 135.51,64.38 v2(135.07,64.81) 134.44,65.44 RC117.2
  GND1 w0.095: v3(20.54,52.02) 20.93,52.02 v1(20.99,51.96)
  GND3 w0.095: v3(20.54,52.02) 20.76,51.8 20.79,51.8 v4(20.82,51.77)
  IN4 w0.076: v5(32.46,23.67) 32.46,23.43 31.92,22.89 31.92,19.69 33.35,18.26 33.35,15.03 33.26,14.94 33.26,14.12 33.33,14.05 33.33,13.42 33.24,13.33 33.24,12.1 33.61,11.73 34.19,11.73 35.59,10.33 41.64,10.33 41.97,10 46.85,10 47.48,9.37 49.32,9.37 51.44,7.24 65.25,7.24 65.97,6.52 76.47,6.52 79.61,9.66 99,9.66 100.51,11.17 109.86,11.17 110.9,12.21 114.38,12.21 115.05,12.89 118.12,12.89 118.38,12.63 119.91,12.63 120.26,12.97 125.61,12.97 125.72,13.09 129.75,13.09 129.88,12.96 139.15,12.96 139.67,13.48 144.73,13.48 145.64,12.56 146.53,12.56 146.72,12.38 149.26,12.38 149.62,12.73 149.62,13.17 152.25,15.8 153.04,15.8 153.57,16.32 153.57,25.32 155.05,26.8 155.05,31.68 153.65,33.08 153.65,34.46 152.48,35.63 152.48,38.43 152.81,38.76 152.81,48.06 150.18,50.69 150.18,53.5 148.73,54.95 148.73,55.96 148.15,56.54 148.15,63.43 147.15,64.43 144.09,64.43 141.33,67.19 140.13,67.19 139.88,66.94 v8(139.88,66.23) ; v4(20.82,51.77) 23.59,51.77 23.8,51.98 25.65,51.98 25.93,52.26 25.93,53.34 26.49,53.91 28.04,53.91 28.31,54.17 30.15,54.17 30.86,54.88 32.66,54.88 34.16,53.38 34.16,53.25 35.5,51.91 35.5,39.53 36.08,38.95 36.08,34.03 36.51,33.6 36.51,31.27 36.73,31.05 36.81,31.05 37.61,30.25 37.61,28.03 36.69,27.1 36.69,26.51 35.57,25.4 v5(35.57,24.42)
  BOTTOM w0.076: v4(20.82,51.77) 20.85,51.77 21.17,51.45 UT2.H4
  BOTTOM w0.095: v5(32.46,23.67) 34.83,23.67 v5(35.57,24.42)
TBT_I2C_CLK: length 51
  TOP w0.076: v1(20.32,33.66) 20.32,33.51 20.22,33.41 20.22,33.12 19.98,32.87 U19.D2
  GND1 w0.095: v3(32.17,35.04) v1(32.52,35.04) ; v1(20.32,33.66) 20.51,33.66 20.86,34.02 v3(20.92,34.02)
  IN2 w0.064: v3(32.17,35.04) 32.17,35.08 32.07,35.17 31.62,35.17 31.36,34.92 31.36,32.85 29.87,31.36 29.15,31.36 28.55,30.77 26.32,30.77 24.98,32.11 24.1,32.11 23.97,32.24 22.44,32.24 21.05,33.64 21.05,33.89 v3(20.92,34.02)
  IN3 w0.064: v3(20.92,34.02) 20.5,33.6 19.78,33.6 19.35,34.03 19.35,37.16 18.28,38.23 18.28,39.33 18.6,39.66 18.6,43.49 17.54,44.56 17.54,51.73 21.02,55.21 22.39,55.21 22.78,55.59 23.79,55.59 24.06,55.33 24.35,55.33 v3(24.73,54.95)
  GND3 w0.095: v3(24.73,54.95) 24.99,54.69 v4(24.99,54.6)
  BOTTOM w0.095: UT2.U2 25.54,52.15 25.72,52.33 25.72,53.44 24.99,54.17 v4(24.99,54.6)
TBT_I2C_DATA: length 49.7
  TOP w0.076: v1(19.92,33.69) 19.98,33.63 U19.D1
  GND1 w0.095: v3(20.26,34.12) 19.92,33.78 v1(19.92,33.69) ; v1(32.52,35.54) 32.72,35.34 v3(32.88,35.34)
  IN2 w0.064: v3(20.26,34.12) 20.52,34.38 21.07,34.38 21.33,34.12 21.33,33.63 22.52,32.44 24.05,32.44 24.18,32.3 25.06,32.3 26.4,30.96 28.47,30.96 29.07,31.55 29.79,31.55 31.17,32.93 31.17,35 31.59,35.41 32.65,35.41 32.75,35.31 32.85,35.31 v3(32.88,35.34)
  IN3 w0.064: v3(24.18,54.94) 23.71,55.4 22.85,55.4 22.47,55.02 21.1,55.02 17.73,51.65 17.73,44.63 18.8,43.57 18.8,39.58 18.47,39.25 18.47,38.31 19.54,37.24 19.54,34.11 19.85,33.79 20.15,33.79 20.26,33.9 v3(20.26,34.12)
  GND3 w0.095: v3(24.18,54.94) 24.36,54.76 v4(24.36,54.6)
  BOTTOM w0.095: UT2.U1 25.49,53.36 24.64,54.21 24.64,54.32 v4(24.36,54.6)
TBT_JTAG_TCK: length 3.8
  TOP w0.095: v2(26.89,53.3) 26.54,52.95 25.22,52.95 v1(24.62,52.35)
  GND1 w0.095: v1(24.62,52.35) 24.91,52.06 24.91,51.84 v3(24.9,51.83)
  GND3 w0.095: v3(24.9,51.83) 25.14,51.59 v4(25.14,51.45)
TBT_JTAG_TDI: length 3.1
  TOP w0.095: v2(28.84,50.39) 28.84,50.88 RT6.2 28.23,51.37 v1(27.7,50.83)
  GND1 w0.095: v1(27.7,50.83) 27.6,50.93 v3(27.6,51.24)
  GND3 w0.095: v3(27.6,51.24) 27.6,51.31 27.47,51.45 v4(27.09,51.45)
TBT_JTAG_TDO: length 2.6
  TOP w0.095: RT3.2 27.45,51.37 v1(26.87,50.79) 27.28,50.39 v2(27.55,50.39)
  GND1 w0.095: v3(26.49,51.03) 26.72,50.79 v1(26.87,50.79)
  GND3 w0.095: v3(26.49,51.03) 26.44,51.07 v4(26.44,51.45)
TBT_JTAG_TMS: length 1.6
  GND1 w0.254: v3(26.1,52.1) 26.53,51.67 v1(26.53,51.49)
  GND3 w0.254: v3(26.1,52.1) 26.1,51.76 v4(25.79,51.45)
TBT_LDO_BMC_A: length 2.2
  TOP w0.076: U19.E1 19.41,33.37 19.41,33.83 19.46,33.88 19.46,33.88 19.73,34.15 19.73,34.15 19.79,34.2 20.09,34.2
  TOP w0.095: CT96.1 20.44,34.55 20.09,34.2
TBT_LDO_BMC_B: length 2
  TOP w0.095: U20.E1 32.02,36.12 32.98,37.08 CT99.1
TBT_LDO_BMC_C: length 2.2
  BOTTOM w0.119: U21.E1 284.06,15.82 CT102.1
TBT_PERST_N: length 4
  TOP w0.095: v1(22.54,51.41) 22.57,51.43 22.57,53.14 R164.2 RT428.2
  GND1 w0.095: v3(22.18,51.09) 22.25,51.15 22.29,51.15 v1(22.54,51.41)
  GND3 w0.095: v4(22.54,51.45) v3(22.18,51.09)
TBT_PWR_EN: length 10.8
  TOP w0.095: v2(142.37,46.82) 142.37,46.83 141.74,47.45 140.93,47.45 v7(140.5,47.02)
  IN1 w0.076: v9(134.18,45.8) 134.01,45.97 134.01,46.57 134.4,46.96 135.17,46.96 135.51,47.3 140.22,47.3 v7(140.5,47.02)
  GND1 w0.095: v3(133.85,45.88) 133.93,45.8 v9(134.18,45.8)
  GND3 w0.095: v3(133.85,45.88) 133.81,45.84 v4(133.81,45.54)
TBT_RBIAS: length 1.1
  GND1 w0.095: v3(21.5,50.41) 21.53,50.41 21.56,50.44 22.17,50.44 v1(22.21,50.48)
  GND3 w0.095: v4(21.24,50.15) 21.24,50.16 v3(21.5,50.41)
TBT_RESET_N_EC: length 41.7
  TOP w0.095: v8(13.73,21.05) 13.72,21.04 RE132.1 ; RT69.1 v2(16.26,53.93) 15.88,53.93 v1(15.8,53.85)
  GND1 w0.095: v1(15.8,53.85) 15.73,53.93 v3(15.28,53.93)
  IN3 w0.064: v3(15.28,53.93) 14.68,53.33 14.68,52.21 13.28,50.81 13.28,47.7 12.56,46.98 12.56,44.74 11.37,43.55 11.37,40.5 10.47,39.6 10.47,38.36 10.13,38.02 10.13,36.8 9.77,36.44 9.77,30.73 9.24,30.19 9.24,27.12 12.04,24.32 12.04,23.05 13.24,21.86 13.24,21.65 13.71,21.17 13.71,21.06 v8(13.73,21.05)
TBT_RESET_N_EC_R: length 10.2
  TOP w0.095: v7(14.58,18.02) 14.59,18.03 14.59,19.75 14.22,20.12 RE132.2 RE162.1 11,20.12 v2(10.85,20.28)
  IN1 w0.076: v7(19.1,18.02) 19.09,18.03 18.11,18.03 18.1,18.02 v7(14.58,18.02)
TBT_RESET_N_R: length 6.2
  TOP w0.095: RT12.2 RT15.2 19.75,53.47 RT69.2 RT17.2 RT22.2 19.29,52.66 RT14.2 20.11,51.97 v2(20.13,51.95) 20.3,51.78 v1(20.3,51.55)
  GND1 w0.095: v3(20.32,51.18) 20.32,51.53 v1(20.3,51.55)
  GND3 w0.095: v4(20.59,51.45) 20.33,51.18 v3(20.32,51.18)
TBT_ROM_CLK: length 26.6
  IN3 w0.064: v3(29.54,53.84) 29.54,57 26.41,60.13 22.58,60.13 20.18,62.53 14.04,62.53 13.93,62.64 v3(13.93,63.91)
  GND3 w0.095: v4(13.53,63.91) v3(13.93,63.91) ; v3(29.54,53.84) 29.54,53.64 v4(29.35,53.45)
  BOTTOM w0.076: UT2.AB4 27.79,51.23 28.03,51.46 28.63,51.46 28.96,51.8 28.96,53.25 29.16,53.45 v4(29.35,53.45)
TBT_ROM_CS#: length 28
  TOP w0.095: RT45.2 20.6,66.4 v2(20.77,66.4) 21.06,66.4 v8(21.43,66.77)
  IN3 w0.064: v3(30.65,55) 30.41,55.24 30.41,57.04 26.69,60.76 23.22,60.76 21.13,62.85 21.13,63.47 20.15,64.45 20.15,66.11 20.46,66.42 21.07,66.42 v8(21.43,66.77)
  GND3 w0.095: v4(30.09,55.18) 30.16,55.1 30.55,55.1 v3(30.65,55)
  BOTTOM w0.076: 29.47,53.99 28.79,53.32 28.79,52.04 28.44,51.69 UT2.AC3
  BOTTOM w0.095: UT3.1 21.11,66.45 v8(21.43,66.77) ; v4(30.09,55.18) 30.16,55.1 30.16,54.75 29.95,54.54 29.95,54.34 29.72,54.1 29.57,54.1 29.47,53.99
TBT_ROM_DI: length 28.5
  IN3 w0.064: v3(14.39,63.06) 14.89,63.06 14.95,63.13 20.46,63.13 23.02,60.57 26.6,60.57 30.19,56.98 v3(30.19,54.64)
  GND3 w0.095: v4(29.86,54.87) 30.04,54.69 30.14,54.69 v3(30.19,54.64) ; v3(14.39,63.06) 14.39,62.8 v4(14.56,62.63)
  BOTTOM w0.076: UT2.AB3 28.02,51.92 28.4,51.92 28.59,52.1 28.59,53.44 29.15,53.99
  BOTTOM w0.095: 29.15,53.99 29.48,54.32 29.62,54.32 29.73,54.43 29.73,54.74 v4(29.86,54.87) ; v4(14.56,62.63) 14.55,62.64 UT3.5 13.34,62.32 v2(13.34,61.21)
TBT_ROM_DO: length 24.4
  TOP w0.095: v1(20.59,65.36) 20.46,65.23 RT46.2
  GND1 w0.095: v1(20.59,65.36) 20.59,64.8 v3(20.6,64.79)
  IN3 w0.064: v3(31.03,55.4) 30.63,55.8 30.63,57.09 26.77,60.96 23.36,60.96 21.43,62.9 21.43,63.63 20.6,64.46 v3(20.6,64.79)
  GND3 w0.095: v4(20.6,65.18) v3(20.6,64.79) ; v3(31.03,55.4) 30.37,55.4 30.37,55.43 v4(30.39,55.43)
  BOTTOM w0.076: 29.87,53.94 29.69,53.77 29.69,53.36 29.15,52.81 29.15,51.59 28.78,51.23 UT2.AC4
  BOTTOM w0.095: v4(30.39,55.43) 30.39,54.49 v2(30.32,54.41) 30.19,54.29 30.19,54.26 29.87,53.94 ; UT3.2 v4(20.6,65.18)
TBT_ROM_HOLD#: length 8.2
  TOP w0.095: v8(14.11,67.14) v2(14.82,66.43) 15.88,65.37 RT44.2
  BOTTOM w0.095: UT3.7 12.25,65.18 11.98,65.45 11.98,66.67 12.32,67.01 13.98,67.01 v8(14.11,67.14)
TBT_ROM_WP#: length 16.9
  TOP w0.095: RT47.2 20.02,63.79 v1(20.23,63.57) v2(20.23,62.74) 20.23,61.82 v8(20.38,61.67)
  GND1 w0.095: v1(20.23,63.57) 20.23,63.75 v3(20.07,63.91)
  IN3 w0.064: v3(25.9,54.82) 25.9,56.68 23.67,58.9 21.77,58.9 21.23,59.44 21.23,60.82 v8(20.38,61.67)
  GND3 w0.095: v4(25.57,54.11) 25.57,54.46 25.9,54.79 v3(25.9,54.82) ; v4(20.45,63.91) v3(20.07,63.91)
  BOTTOM w0.095: UT2.V1 25.95,53.72 v4(25.57,54.11) ; UT3.3 v4(20.45,63.91)
TBT_RSENSE: length 1.1
  GND1 w0.095: v3(21.63,49.89) 21.84,49.89 v1(22.2,49.53)
  GND3 w0.095: v3(21.63,49.89) 21.63,49.91 21.65,49.92 21.65,49.93 21.86,50.15 v4(21.89,50.15)
TBT_SLP_S3_N: length 6.8
  BOTTOM w0.095: UT2.D2 19.74,52.37 19.74,53.18 19.99,53.44 19.99,54.1 20.78,54.89 v2(21.01,54.89) 21.11,54.89 21.62,55.39 21.77,55.39 21.97,55.6 RT84.2 RT16.1
TBT_SNK0_DDC_CLK: length 18.5
  IN4 w0.076: v5(27.09,50.8) 26.8,50.51 26.8,49.7 27.5,49 27.5,47.28 27.61,47.16 27.61,43.34 29.89,41.07 30.77,41.07 v5(31.18,41.48)
  BOTTOM w0.095: v5(31.18,41.48) 31.2,41.5 v2(31.64,41.5) 32.51,41.5 33.05,40.96 33.05,38.93 RT80.2 32.18,38.27 31.77,38.27 RT91.1
TBT_SNK0_DDC_DATA: length 4.1
  TOP w0.095: RT92.1 RT81.2 25.44,53.43 24.81,52.8 24.09,52.8 23.97,52.68 v1(23.97,52.2)
  GND1 w0.095: v3(24.36,51.94) 24.22,51.94 v1(23.97,52.2)
  GND3 w0.095: v4(24.49,51.45) 24.49,51.78 24.38,51.9 24.38,51.93 v3(24.36,51.94)
TBT_SNK1_DDC_CLK: length 10
  IN4 w0.076: v5(31.28,54.26) 30.99,54.26 30.68,53.96 30.68,53.3 30.49,53.1 27.59,53.1 26.8,52.32 26.8,51.33 26.99,51.14 27.17,51.14 27.38,50.92 27.38,50.54 v5(27.34,50.5)
  BOTTOM w0.076: v5(27.34,50.5) 27.38,50.46 27.38,49.79 27.2,49.6 UT2.Y8
  BOTTOM w0.095: v5(31.28,54.26) RT82.2 RT93.1
TBT_SNK1_DDC_DATA: length 10.2
  IN4 w0.076: v5(23.84,51.45) 24.17,51.77 25.73,51.77 26.15,52.19 26.15,53.28 26.58,53.7 28.13,53.7 28.39,53.97 29.85,53.97 v5(30.39,53.42)
  BOTTOM w0.095: v5(30.39,53.42) 30.81,53 RT83.2 RT94.1
TBT_SRC_CFG1: length 3
  BOTTOM w0.076: 28.68,53.99 27.33,52.65 UT2.AA1
  BOTTOM w0.095: R165.1 29.38,54.54 29.02,54.19 28.87,54.19 28.68,53.99
TBT_SRC_HPD: length 5.5
  BOTTOM w0.095: UT2.G1 21.03,52.74 21.03,53.57 21.2,53.75 21.6,53.75 22.08,54.24 22.39,54.24 22.82,54.67 R166.1 23.17,54.91 23.75,55.49 RT8.1
TBT_SVR_IND:
  vias: v2(18.59,53.87)
TBT_TEST_EN: length 5.8
  BOTTOM w0.095: UT2.E1 19.97,53.05 20.27,53.34 20.27,54.06 20.77,54.56 21.14,54.56 21.75,55.17 21.86,55.17 22.38,55.69 v2(22.38,56.17) 22.38,56.84 RT18.2
TBT_TEST_PWRG: length 2.4
  BOTTOM w0.076: UT2.AB5 28.03,51.01 28.47,51.01
  BOTTOM w0.095: RT21.2 29.64,51.3 29.38,51.04 28.5,51.04 28.47,51.01
TBT_TMU_CLK_OUT: length 3.2
  BOTTOM w0.095: 26.18,54.64 26.18,52.38 UT2.V2 ; 26.18,54.64 26.15,54.6 RT32.2 ; 26.18,54.64 C1083.1
TBT_USB3_RX0_N: length 12.8
  TOP w0.102: v8(13.84,42.75) 13.84,42.69 13.7,42.5 arc(13.67,42.49) 13.64,42.49 12.44,42.49 arc(11.66,42.65) 10.99,43.09 10.15,43.93 arc(10.1,44) 10.09,44.09 D27.1 arc(9.93,44.4) 9.8,44.49 9.65,44.63 arc(9.44,44.78) 9.18,44.83 7.57,44.83 7.54,44.84 JUSBC1.A10
  BOTTOM w0.089: 17.11,42.87 17.13,42.87 17.16,42.87 17.4,43.02 arc(17.4,43.03) 17.41,43.04 arc(17.54,43.16) 17.67,43.29 17.72,43.33 arc(17.74,43.37) 17.75,43.41 arc(17.77,43.45) 17.8,43.49 17.92,43.61 arc(17.96,43.63) 18.01,43.64 18.13,43.64 arc(18.25,43.55) 18.19,43.42 arc(18.17,43.41) 18.15,43.41 UT2.A21
  BOTTOM w0.102: v8(13.84,42.75) 13.97,42.62 arc(14.01,42.58) 14.06,42.55 14.23,42.51 15.9,42.51 arc(16.53,42.6) 17.11,42.87
TBT_USB3_RX0_P: length 12.8
  TOP w0.102: v8(13.83,42.09) 13.72,42.2 13.65,42.26 12.44,42.26 arc(11.57,42.44) 10.83,42.93 9.97,43.79 9.97,43.79 arc(9.81,43.89) D25.1 9.68,43.97 9.68,44.06 arc(9.64,44.26) 9.53,44.44 9.49,44.47 arc(9.35,44.57) 9.18,44.6 8.22,44.6 arc(8.11,44.58) 8.02,44.52 7.88,44.37 arc(7.84,44.35) 7.81,44.34 JUSBC1.A11
  BOTTOM w0.089: 17.23,42.68 17.25,42.68 17.26,42.72 17.27,42.73 17.49,42.88 arc(17.51,42.88) 17.52,42.89 arc(17.52,42.9) 17.53,42.9 arc(17.61,42.98) 17.7,43.06 arc(17.83,43.15) 17.98,43.18 18.17,43.18 arc(18.35,43.21) 18.5,43.31 UT2.B21
  BOTTOM w0.102: v8(13.83,42.09) arc(14.04,42.23) 14.28,42.28 15.91,42.28 arc(16.6,42.38) 17.23,42.68
TBT_USB3_RX1_N: length 14.4
  TOP w0.102: JUSBC1.B10 6.44,48.59 arc(6.53,48.57) v8(6.62,48.52)
  BOTTOM w0.089: UT2.B15 18.48,46.06 arc(18.34,45.97) 18.18,45.93 17.88,45.93 arc(17.83,45.94) 17.79,45.97 arc(17.76,45.99) 17.74,46.01 arc(17.72,46.02) 17.71,46.03 arc(17.67,46.04) 17.64,46.04 arc(17.63,46.04) 17.62,46.04 17.17,46.04 arc(16.86,46.07) 16.56,46.15 arc(16.55,46.16) 16.55,46.16 16.4,46.25 16.37,46.24 16.35,46.24
  BOTTOM w0.102: v8(6.62,48.52) 6.79,48.69 arc(6.86,48.73) 6.93,48.75 7.21,48.75 arc(7.45,48.8) 7.66,48.94 7.93,49.2 arc(8.03,49.27) 8.14,49.3 arc(8.32,49.27) 8.48,49.18 D32.1 arc(8.77,49.28) 9.05,49.35 9.22,49.35 arc(9.47,49.3) 9.68,49.16 10.44,48.4 11.4,47.43 arc(11.9,47.1) 12.48,46.99 13.7,46.99 arc(15.08,46.8) 16.35,46.24
