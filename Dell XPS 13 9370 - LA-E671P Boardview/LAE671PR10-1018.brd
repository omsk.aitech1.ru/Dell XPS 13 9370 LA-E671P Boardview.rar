# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VALWP: length 24.3
  TOP w0.102: PC506.1 v11(48.85,36.47)
  IN4 w0.254: v5(47.77,27.7) 47.77,28.16 46.93,29 46.93,31.27 46.69,31.52 46.69,36.6 47.09,37 v8(47.09,37.16) ; v8(47.68,37.14) 47.68,37.05 47.07,36.43 47.07,31.79 47.32,31.54 47.32,29.17 48.16,28.33 48.16,27.21 v5(47.77,26.81)
  BOTTOM w0.254: PU500.14 48.29,27.23 47.95,26.89 47.85,26.89 v5(47.77,26.81)
  vias: v8(53.48,36.43) v8(53.56,35.82)
+3VLP: length 271
  TOP w0.254: RE152.2 28.08,10.17 28.8,10.17 29.13,10.5 30.89,10.5 31.83,11.45 31.83,12.99 v7(32.3,13.46) ; v7(50.92,19.88) 51.07,19.73 51.07,17.26 50.73,16.91 48.86,16.91 48.64,16.69 48.64,16.32 48.07,15.74 42.58,15.74 v7(40.14,13.3)
  TOP w0.508: 157.75,7.84 154.35,7.84 153.01,6.49 153.01,4.04 151.26,2.3 132.17,2.3 131.63,2.84 129.14,2.84 128.54,2.24 94.27,2.24 86.06,10.45 85.45,10.45 v2(82.92,12.98) 81.73,14.17 80.49,14.17 78.17,16.49 v7(78.17,17.07)
  IN1 w0.254: 47.83,27.95 47.83,25.13 48.11,24.85 48.11,24.45 48.21,24.36 48.21,21.1 49.43,19.88 v7(50.92,19.88) ; v7(32.3,13.46) 32.71,13.46 32.81,13.36 34.01,13.36 34.61,13.96 37.44,13.96 38.1,13.3 v7(40.14,13.3)
  IN1 w0.508: v7(78.17,17.07) 78.17,19.67 77.44,20.4 77.44,23.15 76.82,23.77 75.44,23.77 73.52,25.7 73.52,27.97 72.78,28.71 63.8,28.71 63.53,28.98 60.4,28.98 60.06,29.32 58.75,29.32 58.41,28.98 58.33,28.98 57.9,28.54 57.9,28.34 57.51,27.95 47.83,27.95 47.81,27.96 v8(47.81,29.66)
  GND3 w0.508: v6(158.68,9.36) v3(158.29,8.97)
  IN4 w0.508: v6(158.68,9.36) 159.57,10.25 161.14,10.25 162.35,11.46 164.64,11.46 166.45,13.28 174.97,13.28 175.66,12.59 178.29,12.59 179.5,11.38 181,9.88 184.02,9.88 186.59,7.32 195.85,7.32 196.02,7.49 200.15,7.49 202.08,9.43 203.08,9.69 206.56,9.69 211.41,14.54 219.04,14.54 219.41,14.17 223.78,14.17 226.91,11.04 v5(229.13,11.04) 229.81,11.04 v5(229.81,11.04)
  BOTTOM w0.457: v5(229.81,11.04) 231.25,11.04 232.42,9.87 245.65,9.87 245.72,9.95
  BOTTOM w0.508: v8(47.81,29.66) 47.86,29.62 PC509.1
  vias: v1(158.84,8.95) v1(159.12,8.95)
+3VS: length 276.1
  TOP w0.381: 31.87,43.54 31.92,43.59 32.15,43.36 33.64,43.36 34.58,44.3 PR1012.1
  TOP w0.508: 143.51,51.47 143.51,50.72 143.4,50.61 143.4,48.15 ; UC10.5 132.21,34.23 132.8,33.65 134.14,33.65 134.48,33.99 139.54,33.99 140.38,34.83 140.39,34.83 v8(140.72,35.16) ; v7(142.03,62.31) 142.04,62.3 RC7.2 RC5.2 ; v8(141.96,63.24) 141.05,64.15 141.05,66.9 140.26,67.69 137.36,67.69 ; 145.09,53.81 147.96,53.81 148.98,52.79 RH64.1 149.87,47.92 RH65.1
  TOP w1.27: 34.89,19.05 35.57,18.37 35.57,16.19 35.12,15.74 35.12,14.09 33.17,12.13 33.17,7.98 32.27,7.08 32.27,6.32 ; 31.87,57.39 31.87,42.8
  IN1 w0.254: v7(32.62,42.4) 30.53,44.48 30.53,45.59 29.8,46.33 v7(29.8,49.44)
  IN1 w0.381: v8(159.12,40.48) 159.09,40.51 158.31,40.51 156.99,41.84 156.99,43.79 153.76,47.02 152.09,47.02 151.36,47.74 ; 143.3,47.01 143.3,45.57 141.83,44.1 141.83,42.55 142.32,42.06 v7(142.32,40.72)
  IN1 w0.635: 145.43,59.55 147.68,59.55 148.92,60.78
  GND1 w0.305: v1(141.39,38.8) 140.9,38.31 140.79,38.31 v3(140.78,38.29)
  GND1 w2.54: 92.43,5.95 92.48,5.95 ; 92.48,5.95 92.5,5.98 108.6,5.98 ; 92.48,5.95 90.34,8.1
  IN3 w0.508: 21.14,6.79 19.41,8.53 14.38,8.53 14.12,8.26 12.77,8.26 12.03,7.52 12.03,6.13 v8(10.96,5.06)
  GND3 w0.305: v4(140.9,37.86) 140.9,38.16 140.78,38.28 v3(140.78,38.29)
  GND3 w0.381: v4(112.54,3.74) 112.54,4.52 v3(112.69,4.67)
  IN4 w0.254: v8(218.56,6.43) 218.56,7.31 215.19,10.68 213.29,10.68 210.34,7.73 210.34,7.45 208.49,5.59 204.98,5.59 204.57,5.19 203.63,5.19 201.49,3.04 199.64,3.04 v5(199.63,3.05)
  IN4 w0.381: v5(104.04,6.85) 108.38,6.85 110.18,5.05 111.8,5.05 112.54,4.32 v4(112.54,3.74)
  IN4 w0.508: v4(140.9,37.86) 140.9,35.34 v8(140.72,35.16)
  IN4 w0.762: 294.38,29.41 294.38,34.46 294.84,34.93 294.84,36.46 294.78,36.52 ; 156.86,18.22 156.86,25.9 155.85,26.91 155.85,32.21 154.74,33.32 154.74,34.5 153.02,36.21 153.02,37.87 153.77,38.61 153.77,41.16 154.01,41.41 154.01,42.69 154.24,42.92 154.24,48.23 154.74,48.72 154.74,50.34 153.26,51.81 153.26,52.93 150.93,55.26 150.93,56.81 149.61,58.13 149.61,61.16 v8(149.81,61.37)
  BOTTOM w0.305: R39.2 200.95,8.64 200.24,7.93 R40.2 198.85,7.17 198.85,5.85 199.35,5.35 199.35,3.29 199.59,3.05 v5(199.63,3.05) ; v4(140.9,37.86) 140.88,37.84 136.1,37.84 135.5,38.44 RC16.1
  BOTTOM w0.381: PR805.2 153,64.07 152.54,63.6 152.05,63.6 v8(149.81,61.37) ; RH82.1 137.74,70.54 137.44,70.25 137.44,69.52 v8(136.51,68.59) ; v4(112.54,3.74) PR601.2 ; v8(159.12,40.48) 159.3,40.48 R34.1 ; RE241.1 113.13,12.27 109.46,12.27 v5(104.04,6.85)
  BOTTOM w0.508: 157.15,15.51 161.42,15.51 162.68,16.77 R5838.1 163.5,16.22 RC179.1 ; v8(259.37,8.11) 259.37,9.49 255.64,13.22 R36.2 R37.2
  vias: v1(26.96,7.69) v1(31.26,5.37) v1(31.55,5.37) v1(31.69,58.05) v1(31.76,57.61) v1(31.89,5.37) v1(32.02,58.05) v1(32.07,57.74) v1(33.56,41.54) v1(33.78,41.37) v1(33.8,41.65) v1(34.01,41.49) v1(34.02,41.23) v1(35.52,24.04) v1(35.64,23.8) v1(35.83,24.05) v1(35.93,23.78) v1(36.1,24.05) v1(36.19,23.81) v1(143.3,47.52) v1(143.57,47.53) v1(266.56,31.49) v1(266.87,31.49) v1(267.17,31.49) v1(267.4,40.19) v1(267.53,39.97) v1(267.68,40.2) v1(267.97,40.2) v1(268.25,40.2) v1(268.52,40.21) v3(21.91,7.48) v3(22.4,7.21) v3(22.87,7.45) v3(23.19,7.14) v3(23.51,7.53) v3(31.34,58.01) v3(31.37,57.57) v3(160.54,8.41) v3(160.97,8.41) v4(21.15,7.64) v4(21.24,7.97) v4(21.46,7.59) v4(21.63,7.96) v4(21.88,7.92) v4(22.33,7.92) v4(22.46,7.64) v4(22.83,7.92) v4(23.25,7.92) v4(23.75,7.91) v4(30.85,58.12) v4(30.85,57.74) v4(31.76,58.15) v4(31.79,57.69) v4(160.53,8.79) v4(160.84,8.8) v5(156.52,17.58) v5(156.8,17.58) v5(157.08,17.58) v5(292.69,28.41) v5(292.94,28.41) v7(19.6,57.11) v7(19.6,56.73) v7(19.98,57.11) v7(20.11,56.73) v7(150.56,47.85) v7(150.91,47.86) v8(142.87,51.72) v8(145.33,54.39) v8(145.43,58.17) v8(219.13,6.6) v8(294.6,37.64) v8(294.62,37.05) v8(294.9,38.16) v8(295.22,37.66) v8(295.2,37.04) v11(276.42,39.53)
+3VS_AUDIO: length 266.5
  TOP w0.127: RC110.1 v11(156.33,39.6) 156.63,39.9 159.2,39.9 162.84,36.26 162.84,28.26 161.24,26.67 161.24,16.34 162.5,15.08 162.5,14.18 161.08,12.77 161.08,9.77 162.55,8.3 162.55,5.3 v1(162.73,5.12)
  TOP w0.508: v8(259.01,11.29) 259.01,11.57 258.66,11.92 257.87,11.92 257.55,11.59 C96.1 257.55,9.11 R93.2 ; LA4.1 273.14,63.89 273.06,63.81 269.98,63.81 268.84,62.68 v8(267.97,62.68)
  IN1 w0.508: v9(285.22,27.23) 292.92,19.53 292.92,13.83 293.13,13.63 293.13,9.95 291.84,8.66 v7(291.84,6.18)
  GND1 w0.127: v1(162.73,5.12) 162.55,4.95 162.55,4.86 162.42,4.73 v3(162.38,4.73)
  GND1 w0.508: v9(285.22,27.23) 285.22,27.26 v3(284.77,27.71)
  IN3 w0.508: v8(267.97,62.68) 268.01,62.64 268.01,62.59 272.35,58.25 272.35,45.25 274.46,43.14 274.46,34.74 v8(274.43,34.71)
  GND3 w0.127: v6(162.49,5.08) 162.38,4.97 v3(162.38,4.73)
  GND3 w0.508: v6(284.23,28.25) v3(284.77,27.71)
  IN4 w0.127: v5(259.57,6.56) 256.58,6.56 254.66,4.64 219.86,4.64 219.44,5.07 213.06,5.07 212.5,5.63 209.74,5.63 209.39,5.28 205.11,5.28 204.7,4.87 203.76,4.87 201.48,2.59 199.22,2.59 199.21,2.6 196.44,2.6 195.71,3.33 184.74,3.33 183.76,4.31 179.28,4.31 178.65,3.68 169.13,3.68 169.01,3.55 164.02,3.55 v6(162.49,5.08)
  IN4 w0.508: v6(284.23,28.25) 282.43,28.25 281.04,29.64 277.42,29.64 276.66,30.4 276.66,32.84 274.79,34.71 v8(274.43,34.71)
  BOTTOM w0.127: v5(259.57,6.56) 259.57,7.28 259.91,7.62 259.91,10.39 v8(259.01,11.29)
  BOTTOM w0.508: v8(259.01,11.29) 259.01,13.51 264.01,18.51 264.01,22.8 266.09,24.88 266.09,28.82 268.55,31.29 270.54,31.29 272.76,32.32 273.57,33.13 274.03,34.43 v8(274.43,34.71) ; LA2.1 268.27,62.38 v8(267.97,62.68)
+3VS_CAM: length 2
  BOTTOM w0.127: v11(284.93,30.33) 284.77,30.18 R98.2
+3VS_CR: length 13.7
  IN4 w0.508: 292.24,32.95 292.24,31.39 v5(290.73,29.88)
  IN4 w1.016: 291.81,36.71 291.82,36.72 291.82,37.3 289.8,39.33 285.96,39.33 284.99,38.36 284.94,38.36
  BOTTOM w0.102: v11(291.23,37.29) 292.36,37.29 RT70.2
  vias: v5(283.83,34.44) v5(283.83,34.16) v5(292.44,36.52) v5(292.43,35.99) v5(292.66,36.2) v5(292.69,36.52) v5(293.04,33.22) v5(293.04,32.65)
+3VS_FP: length 12.6
  TOP w0.095: R281.1 v11(261.84,8.15)
  IN4 w0.508: 275.07,7.97 275.1,7.94 276.85,7.94 277.18,7.61 277.18,6.88 277.9,6.17 279.19,6.17 280.76,7.73
  IN4 w0.762: 266.92,9.36 264.35,6.79
  vias: v1(262.68,6.61) v1(262.94,6.61) v3(263.28,6.61) v5(281.24,8.58) v5(281.23,8.21) v6(263.6,6.78) v6(263.61,6.5)
+3VS_MUX: length 34
  TOP w0.381: v7(272.09,17.67) 271.39,17.67 R5801.1 271.1,17.38 271.1,16.96 270.85,16.72 R5798.1 ; 266.93,28.92 266.5,28.49 265.51,28.49 265.09,28.07 R5808.1 264.56,27.9 264.17,27.52 R5797.2 264.17,26.63 263.98,26.44 263.76,26.44 263.58,26.25 263.58,26.03 263.58,26.03 263.58,25.6 263.23,25.26 262.61,24.07 262.42,23.62 262.42,22.05 263.06,21.42 R48.1
  TOP w0.508: R5807.2 271.34,18.47 R5801.1
  IN1 w0.381: v7(272.09,17.67) 272.09,17.45 272.62,16.91 274.26,16.91 274.82,17.47 v7(274.82,18.13)
  GND1 w0.254: v1(277.55,24.08) 277.55,23.76 v3(277.56,23.75)
  IN3 w0.508: v3(277.18,21.37) 278.12,21.37 278.75,20.74 278.75,18.69 277.01,16.95 277.01,14.51 v3(276.99,14.48)
  GND3 w0.381: v4(277.07,13.83) 276.93,13.97 276.93,14.42 v3(276.99,14.48)
  IN4 w0.381: v4(277.07,13.83) 276.31,13.83 v5(276.11,14.03)
  IN4 w0.508: 266.34,22.92 266.26,22.99 266.52,23.25 266.52,26.58 267.19,27.25
  vias: v1(265.86,23.49) v1(267.12,28.12) v1(267.12,27.85) v1(273.52,21.57) v1(273.53,21.3) v1(274.49,29.22) v1(274.49,28.96) v1(277.62,21.81) v1(277.67,21.53) v2(265.98,22.31) v3(266.11,23.12) v3(267.22,28.64) v3(273.89,28.79) v3(273.91,21.82) v3(273.9,21.39) v4(265.95,22.8) v4(266.29,22.81) v4(273.52,22.03) v4(273.52,21.77) v4(273.89,28.45) v4(273.9,28.19) v4(277.03,21.67) v4(277.23,23.86) v4(277.31,21.67) v6(267.25,28.07) v6(267.25,27.79)
+3VS_NGFF: length 160.8
  TOP w0.102: U24.D2 v7(174.4,19.33)
  IN1 w0.095: v7(174.4,19.33) 174.46,19.39 175.53,19.39 181,13.92 181.51,13.92 183.45,11.98 184.86,11.98 186.9,9.95 206.14,9.95 211.07,14.88 211.08,14.88 211.19,15 224.92,15 226.64,13.27 227.81,13.27 231.35,9.73 249.1,9.73 251.08,11.71 253.33,11.71 254.94,13.32 258.89,13.32 259.81,14.23 259.81,17.68 262.56,20.43 262.56,23.28 263.25,24.93 263.67,25.53 264.17,26.64 265.18,27.65 265.18,30.04 265.49,30.35 v9(265.49,38.48)
  GND1 w0.102: v3(270.41,44.3) 270.41,44.3 v1(270.77,44.3) ; v9(265.49,38.48) 265.49,38.54 v3(265.71,38.76)
  IN2 w0.089: v3(270.41,44.3) 270.32,44.2 270.32,43.37 v3(265.71,38.76)
  IN4 w0.254: v5(285.89,40.1) 285.61,40.38 282.64,40.38 281.87,41.15 280.48,41.15 280.07,40.75 280.07,39.61 279.76,39.29 279.76,32.24 279.15,31.63 277.43,31.63 277.18,31.88 v5(277.18,33.28)
  BOTTOM w0.254: RC182.2 286.23,39.52 285.89,39.86 v5(285.89,40.1) ; 271.58,40.49 271.58,40.18 275.19,36.57 275.19,34.58 276.48,33.28 v5(277.18,33.28)
  vias: v1(270.78,42.51) v1(271.04,42.51) v1(271.44,42.5) v3(271.23,42.23) v3(271.22,41.8) v3(271.66,42.22) v4(271.25,41.44) v4(271.55,41.74) v4(271.51,41.45) v4(271.83,55.74) v4(285.95,54.69) v11(271.9,42.73)
+3VS_NGFF_IN+: length 131
  TOP w0.102: U24.D3 v7(174.4,19.83) ; 269.61,45.6 v2(270.54,45.6)
  IN1 w0.095: v9(265.41,39.13) 265.13,38.85 265.13,30.5 264.82,30.19 264.82,27.8 263.87,26.85 263.36,25.71 262.94,25.1 262.23,23.42 262.21,23.35 262.21,20.58 259.45,17.83 259.45,14.38 258.75,13.67 254.79,13.67 253.19,12.07 250.94,12.07 248.95,10.08 231.5,10.08 227.95,13.63 226.79,13.63 225.07,15.36 211.04,15.36 210.93,15.24 210.93,15.24 205.99,10.3 187.04,10.3 185.01,12.34 183.59,12.34 181.66,14.27 181.15,14.27 175.68,19.75 174.48,19.75 v7(174.4,19.83)
  GND1 w0.102: v1(269.45,44.31) 269.46,44.3 269.8,44.3 v3(269.87,44.22) ; v9(265.41,39.13) 265.48,39.13 v3(265.7,39.35)
  IN2 w0.089: v3(269.87,44.22) 269.96,44.14 269.96,43.51 265.8,39.35 v3(265.7,39.35)
+3VS_PWRM: length 12.8
  TOP w0.381: RE233.2 RE240.2 176.99,19.03 177.29,18.73 177.29,17.63 176.92,17.27 171.82,17.27 v2(171.65,17.43) 171.13,17.95 C1076.1
  IN1 w0.254: v7(172.86,19.33) 172.76,19.23 171.23,19.23 v7(171.06,19.4)
+3VS_TP: length 199.3
  TOP w0.356: v8(13.32,5.07) 13.32,4.57 12.95,4.2 RE236.1 RE235.1
  TOP w0.508: v1(164.6,4.03) 165.55,4.98 v11(165.55,10.55) v7(165.55,11.52)
  IN1 w0.508: v7(165.55,11.52) 168.19,11.52 169.22,10.5 175.09,10.5 v9(176.08,11.49)
  GND1 w0.356: v9(176.08,11.49) 176.22,11.36 v3(176.62,11.36)
  GND1 w0.508: v1(164.6,4.03) 164.6,3.97 v3(164.3,3.66)
  IN2 w0.356: v8(13.32,5.07) 13.32,5.94 12.44,6.83 12.44,7.91 13.74,9.21 19.51,9.21 20.67,8.05 22.25,8.05 22.32,7.97 22.77,7.97 22.84,8.05 24.02,8.05 24.96,7.11 26.2,7.11 26.81,6.49 28.8,6.49 29.68,5.61 29.68,5.06 30.26,4.49 33.55,4.49 33.69,4.35 45.84,4.35 46.32,3.87 49.01,3.87 49.55,4.41 50.72,4.41 51.34,3.78 53.27,3.78 53.27,3.79 77.23,3.79 80.03,6.58 111.3,6.58 114.03,9.31 135.21,9.31 136.03,10.14 143.21,10.14 143.61,9.73 143.61,8.44 144.24,7.82 144.24,4.8 145.38,3.66 153.56,3.66 154.6,4.7 161.06,4.7 162.09,3.66 v3(164.3,3.66)
  GND3 w0.356: v4(176.69,10.87) 176.69,11.29 v3(176.62,11.36) ; v4(164.31,2.95) 164.31,3.65 v3(164.3,3.66)
  IN4 w0.356: v4(164.31,2.95) 164.55,3.18 v5(167.12,3.18)
  BOTTOM w0.305: 178.52,9.06 178.58,9 JTP1.1
  BOTTOM w0.356: R268.2 164.29,2.72 C1069.1 165.22,1.73 C1072.1 ; R114.2 167.12,3.18 v5(167.12,3.18)
  BOTTOM w0.508: 178.52,9.06 178.42,9.15 177.9,9.15 177.51,9.54 C122.1
+3VS_TPM: length 15.1
  IN4 w0.508: v5(174.78,16.64) 176,16.64 177.19,15.45 v5(177.19,14.79)
  BOTTOM w0.508: C29.1 177.19,14.18 v5(177.19,14.79) ; R5838.2 164.52,16.61 RE27.1 165.64,16.96 RC178.1 169.31,16.96 171.06,18.71 R19.2 172.76,18.71
  vias: v2(174.03,18.51)
+3VS_TS: length 5.4
  TOP w0.102: R73.2 v11(50.56,59.44)
  TOP w0.508: v8(49.29,57.74) 48.66,58.37 C74.1 49.16,58.88 R73.2
  BOTTOM w0.508: RC184.1 RC183.1 C131.1
+5VALW: length 296.2
  TOP w0.203: U12.4 v8(220.74,9.52)
  TOP w0.508: R5823.1 51.87,59.64 v1(49.97,57.74) ; UZ3.3 141.77,70.51 142.11,70.86 142.11,72.31 v8(142.28,72.47) ; 2.05,25.6 1.6,25.15 1.6,22.44 2.04,22 ; 2.05,25.6 1.63,26.01 1.63,28.77 v8(1.76,28.9) 2.06,29.2 LED1.2 ; 2.05,25.6 LED2.2 ; C146.1 17.48,26.23 v8(17.48,27.34) ; LED4.2 2,18.4 ; 2,18.4 1.58,17.99 1.58,15.16 1.95,14.8 LED5.2 ; 2,18.4 1.57,18.82 1.57,21.53 2.04,22 ; v7(282.16,43.36) 281.48,43.36 279.55,45.3 279.55,50.53 285.25,56.23 R288.1 ; UZ5.3 123.36,36.71 v11(125.94,34.14) 128.64,31.43 140.41,31.43 141,32.02 142.72,32.02 143.43,31.31 144.94,31.31 145.54,30.71 145.54,29.74 146.15,29.13 148.75,29.13 149,28.88 149,25.5 149.69,24.8 149.69,23.39 149.45,23.15 149.45,20.82 v7(150.02,20.25) 150.64,19.64 150.64,14.33 149.19,12.88 149.19,11.43 150.63,10 ; C159.1 29.82,28.52 v8(29.82,29.06) ; LED3.2 2.04,22 ; v11(218.68,5.62) 219.88,5.62 v8(220.08,5.41) ; v8(150.93,4.2) 151.59,4.86 151.59,9.29
  IN1 w0.254: v8(17.48,27.34) 17.48,27.49 17.98,27.99 v7(17.98,28.81)
  IN1 w0.305: v8(29.82,29.06) 29.78,29.1 29.78,30.3 v7(30.52,31.04)
  IN1 w0.508: v9(153.22,58.95) 153.22,58.43 153,58.21 153,52.07 156.18,48.89 159.13,48.89 161.98,46.04 161.98,39.92 163.09,38.81 163.72,38.81 166.09,36.43 167.37,36.43 169.35,34.45 169.35,29.3 166.18,26.14 163.41,26.14 162.87,25.6 155.42,25.6 151.19,21.37 151.19,20.96 150.49,20.25 v7(150.02,20.25) ; v7(282.16,43.36) 282.16,39.77 282.03,39.64 282.03,26.83 282.38,26.48 284.75,26.48 290.5,20.72 290.5,17.26 291.1,16.66 v8(291.1,13.82) ; v8(22.44,8.71) 23.79,8.71 25.24,7.26 25.81,7.26 26.53,6.55 29.86,6.55 30.52,5.89 32.28,5.89 32.94,5.22 33.75,5.22 34.33,4.64 38.27,4.64 38.85,5.22 39.22,5.22 v9(39.84,5.85)
  GND1 w0.508: v9(153.22,58.95) v3(153.22,60.05) ; v1(49.97,57.74) v3(49.97,57.29) ; v9(39.84,5.85) v3(39.51,5.85)
  IN2 w0.508: v3(49.97,57.29) 49.97,55.74 49.47,55.24 48.12,55.24 47.18,56.18 46.69,56.18 44.6,54.08 44.6,51.49 43.83,50.72 43.83,42.74 42.34,41.25 v8(42.34,41)
  GND3 w0.254: v4(289.52,17.33) v3(290.07,17.33)
  GND3 w0.508: v6(152.73,60.05) v3(153.22,60.05)
  IN4 w0.508: v8(142.28,72.47) 143.41,73.6 144.81,73.6 148.45,72.44 151.63,69.26 151.63,63.4 152.78,62.26 152.78,61.62 152.71,61.56 152.71,60.07 v6(152.73,60.05) ; 18.37,25.32 18.35,25.31 18.35,25.04 17.63,24.31 15.96,24.31 14.53,25.74 13.49,25.74 11.98,27.25 7.76,27.25 7.66,27.14 6.49,27.14 4.74,28.9 v8(1.76,28.9)
  BOTTOM w0.305: UZ4.3 147.78,11 148.14,10.64 148.68,10.64 148.77,10.55
  BOTTOM w0.381: CZ4.1 149.81,10.95 149.41,10.55 148.77,10.55
  BOTTOM w0.508: CZ4.1 150.37,10.6 150.88,10.09 v8(151.44,10.09)
  vias: v8(19.92,26.96) v8(20.24,27.47) v8(20.86,27.55) v8(23.11,27.11) v8(23.51,27.57) v8(23.81,27.03) v8(23.97,26.44) v8(24.19,27.49) v8(32.3,29.92) v8(32.3,29.29) v8(32.37,28.71) v8(34.53,30.03) v8(34.54,29.42) v8(36.52,30.41) v8(36.52,29.8) v8(36.51,29.18) v8(36.54,28.58) v8(36.57,27.99) v8(42.29,40.4) v8(42.87,40.41) v8(43.57,40.4) v8(44.16,40.39) v8(45.15,40.98) v8(45.12,40.39) v8(45.43,38.55) v8(45.63,39.71) v8(45.62,39.11) v8(45.76,40.98) v8(45.76,40.34) v8(46.03,38.55) v8(46.29,39.74) v8(46.28,39.13) v8(46.39,40.98) v8(46.39,40.34) v8(46.64,38.6) v8(46.93,39.73) v8(46.92,39.12) v8(47.01,40.98) v8(46.98,40.36) v8(219.88,11.72) v8(220.47,11.72) v8(220.67,5.42) v8(291.11,13.23) v8(291.12,12.62) v8(291.11,12.03) v8(291.11,11.41) v8(292.46,13.33) v8(292.45,12.71) v8(292.45,12.08) v11(220.11,6.64)
+5VALWP: length 13.7
  TOP w0.102: 40.82,34.64 41.81,34.64 v11(41.9,34.73)
  IN3 w0.305: v8(39.66,37.68) 38.49,36.5 38.49,27.36 v3(37.99,26.85)
  GND3 w0.254: v3(37.99,26.85) 37.86,26.98 v4(36.98,26.98)
  vias: v8(39.66,36.28) v8(39.66,35.39) v8(39.7,37)
+5VS: length 342.6
  TOP w0.381: PR1049.2 v1(46.52,53.8)
  TOP w0.508: v8(63.96,40.46) 64,40.49 64.03,40.49 64.07,40.53 PC1150.2 ; JUART1.1 162.74,40.16 163.33,39.57 164.73,39.57 166.99,37.31 v8(166.99,34.02) 167.39,33.62 167.39,31.02 166.58,30.21 166.58,26.21 164.5,24.12 v11(164.5,20.63) 164.5,15.58
  IN1 w0.508: v9(62.61,57.57) 62.59,57.55 62.59,51.57 63.15,51.01 63.15,47.77 v8(62.13,46.75) 62.7,46.18 62.7,41.88 63.96,40.62 v8(63.96,40.46)
  GND1 w0.381: v1(46.52,53.8) v3(46.52,53.26)
  GND1 w0.508: v9(62.61,57.57) 62.54,57.5 62.33,57.5 v3(62.27,57.56)
  GND1 w0.762: 64.64,40.6 69.18,40.6 69.55,40.22 69.55,39.03 71.06,37.52 71.92,37.52 73.3,36.14 77.99,36.14 81.07,33.06 81.07,28.75 81.53,28.29 81.53,17.76 83,16.29 83,13.63 83.94,12.69 89.25,12.69 93.44,8.5 108.34,8.5 112,12.15 116.8,12.15 117.54,11.42 122.94,11.42 123.99,10.37 129.45,10.37 130.09,11 131.48,11 132.85,12.37 134.53,12.37 135.9,11.01 150.12,11.01 151.4,12.29 152.96,12.29 153.57,12.9 162.25,12.9 163.67,14.32
  IN2 w0.508: v8(62.13,46.75) 61.23,47.66 57.98,47.66 v8(57.95,47.62) 57.89,47.62 57.29,47.02 51.32,47.02 49.47,48.88 47.41,48.88 46.6,49.68 v8(46.6,52.26) 46.6,53.18 v3(46.52,53.26)
  GND3 w0.508: v4(62.27,57.17) 62.27,57.56 v3(62.27,57.56)
  IN4 w0.508: 263.27,5.28 261.4,7.15 256.28,7.15 255.83,6.71 255.64,6.71 255.64,6.69
  IN4 w0.762: 253.54,5.81 253.18,5.46 230.14,5.46 230.1,5.42 ; 227,5.39 223.81,5.39 222.93,6.27 219.86,6.27 219.25,5.65 213.34,5.65 212.25,6.74 211.46,6.74
  BOTTOM w0.254: v8(63.96,40.46) 64.01,40.46 64.28,40.18 64.44,40.18 64.62,40.36 PU1150.14 ; PU1101.14 63.83,48.75 63.56,48.48
  BOTTOM w0.508: 209.88,7.06 208.38,7.06 204.97,10.47 200.68,10.47 200.52,10.3 199.43,10.3 199.14,10.59 197.45,10.59 197.38,10.52 189.29,10.52 188.02,11.78 185.49,11.78 183.98,13.29 182.56,13.29 173.13,22.72 173.13,24.98 171.28,26.83 171.28,30.83 168.07,34.04 167.01,34.04 v8(166.99,34.02) ; v8(46.6,52.26) 46.6,51.87 46.08,51.35 45.47,51.35 44.6,50.49 35.8,50.49 35.3,49.98 PR1001.1 35.3,47.62 35.66,47.25 36.19,47.25 36.66,47.72 36.66,47.79 37.55,48.67 43.22,48.67 43.77,48.13 43.77,47.11 44.77,46.11 PR1048.1 ; 63.56,48.48 63.56,48.36 62.86,47.66 PC1110.2 v8(62.13,46.75)
  vias: v1(164.23,14.82) v1(164.5,14.82) v4(210.6,5.97) v4(210.86,5.97) v5(254.96,6.16) v5(255.22,6.15) v5(264.24,5.44) v5(264.24,5.12) v8(227.9,5.21) v8(228.49,5.21)
+5VS_AUDIO: length 92.2
  TOP w0.102: 226.66,6.71 v11(226.66,5.43)
  TOP w0.762: 279.29,42.81 278.69,43.41 278.69,49.79 274.97,53.5 CA5.1 274.16,54.83 LA1.2 275.36,54.9 CA3.1 276.19,54.88 U4.1 277.69,56.39 LA3.2
  IN1 w0.762: 227.79,7.56 228.24,7.11 229.15,7.11 229.73,6.53 254.55,6.53 258.13,10.11 260.32,10.11 262.81,12.6 262.81,12.92
  IN4 w0.762: 278.46,32.67 279.07,33.28 279.07,39.78 279.38,40.09 ; 271.36,30.53 269.06,30.53 268.52,29.99 268.52,28.83 269.82,27.54 269.82,26.82 269.25,26.25 267.97,26.25 267.54,25.82 267.54,21.06 262.56,16.08
  BOTTOM w0.762: 277.05,32.21 277.01,32.17 275.06,32.17 273.46,30.58 273.06,30.58
  vias: v3(261.99,14.85) v3(262.4,14.85) v5(272.06,30.31) v5(272.33,30.32) v5(272.62,30.31) v5(277.77,32.61) v5(277.77,32.34) v5(277.78,32.05) v6(262.2,15.24) v6(262.46,15.23) v6(262.72,15.23) v7(226.52,8.08) v7(226.71,7.89) v8(279.39,41.62) v8(279.4,41.02) v9(262.66,13.98) v9(262.79,13.74) v9(262.93,13.98)
+8.4V_BATT+: length 15.1
  TOP w0.305: PR324.1 70.52,9.31 v2(71.4,10.18) 71.55,10.34 v7(71.55,10.61)
  IN1 w0.305: v7(71.55,10.61) 72.32,10.61 74.24,12.53 75.66,12.53 77.8,14.67 v8(77.8,15.04)
  BOTTOM w0.305: v8(77.8,15.04) 77.8,13.81 78.11,13.51 PR304.2
  vias: v8(81.88,11.63) v8(82.46,11.63)
+AVDD1: length 1.3
  IN2 w0.508: v3(279.32,58.23) 278.98,57.89 v3(278.2,57.89)
  vias: v1(279.27,58.61) v1(279.53,58.62) v2(280.13,56.28) v4(277.76,57.82) v4(277.99,57.61)
+AVDD2: length 2.2
  TOP w0.508: RA1.1 278.28,67.01 v1(278.44,66.86)
  GND1 w0.508: v1(278.44,66.86) 278.3,66.86 v3(277.99,66.55)
  GND3 w0.508: v4(277.51,66.2) 277.87,66.55 v3(277.99,66.55)
+DVDD: length 73.7
  TOP w0.508: v1(267.6,11.34) 267.6,12.5 268.31,13.21 RA30.1
  GND1 w0.254: v1(273.15,65.54) v3(272.79,65.54) ; v3(268.2,11.18) 268.12,11.18 267.96,11.34 v1(267.6,11.34)
  IN3 w0.508: v8(274.6,34.04) 274.67,34.04 275.12,34.48 275.12,43.82 273.19,45.76 273.19,59.07 v3(272.2,60.05) 270.93,61.32 270.93,64.9 271.57,65.54 v3(272.79,65.54)
  GND3 w0.508: v3(272.2,60.05) 272.15,60.1 v4(272.15,60.51)
  BOTTOM w0.508: RA11.1 273.27,56.32 272.71,56.88 272.71,57.36 272,58.07 272,60.03 ; v8(274.6,34.04) 274.6,33.26 273.08,31.74 270.58,30.59 268.81,30.59 266.75,28.53 266.75,24.61 264.69,22.55 264.69,17.53 v11(265.77,16.46) 268.73,13.49 CA49.1 ; RA10.1 RA9.1
  vias: v4(268.57,11.03) v4(268.82,11.03)
+DVDDIO: length 0.9
  TOP w0.102: 276.14,66.28 276.7,66.28 v2(276.95,66.02)
  vias: v1(276.18,66.02) v1(276.19,65.75) v3(276.54,65.98) v4(276.18,65.97) v4(276.19,65.67)
+PVDD2:
  vias: v1(274.04,56.22) v1(274.11,55.84) v1(274.32,55.68) v2(277.29,56.9) v3(274.68,55.75) v3(275.09,55.75) v5(277.41,55.98) v5(277.4,55.69) v5(277.68,55.98) v5(277.67,55.69) v6(274.37,55.88) v6(274.7,56.09) v6(274.96,56.09)
+V1.8S_EDRAM: length 16.7
  TOP w0.254: v7(106.74,66.78) 106.23,66.78 v11(104.21,64.77) 103.43,63.98 102.87,63.98 102.55,63.66 101.4,63.66 101.03,63.29 RC152.1
  IN1 w0.254: v7(106.74,66.78) 106.66,66.7 99.34,66.7 98.94,67.1 v7(98.49,67.1)
  BOTTOM w0.254: UCPU1.H63 101.86,61.61 101.52,61.95 v8(101.34,61.95)
+VBUS1_20V: length 35
  TOP w0.254: v8(32.94,13.9) 32.6,14.23 PR213.1 32.07,15.15 32.07,15.89 32.22,16.03 32.23,16.03 32.57,16.37 33.97,16.37 34.41,16.81 PC109.1 PR100.1
  TOP w0.508: 38.39,18.93 38.39,18.66 38.02,18.29 v11(38.02,15.81) 38.02,14.79 37.36,14.13 37.36,13.13 34.82,10.59 v11(34.82,7.93) 34.82,7.25 34.48,6.91 34.48,6.36 34.36,6.24 34.36,5.16 v11(33.11,3.92) 32.45,3.26 v8(32.14,3.26)
  BOTTOM w0.508: v8(32.94,13.9) 32.17,13.9 31.76,14.31 31.76,15.07 32.47,15.78 PQ133.3 32.47,16.76 32.07,17.16 32.07,17.76 32.77,18.46 35.54,18.46 PQ100.1 ; v8(32.14,3.26) 32.14,3 31.63,2.49 PD103.2
  vias: v8(38.28,18.93) v8(38.3,19.55) v8(39.51,19.54)
+VBUS1_PD_20V:
  vias: v1(5.58,45.6) v1(5.61,48.08) v1(5.92,48.09) v1(5.97,45.6) v1(7.24,47.85) v1(7.23,45.33) v1(7.67,47.84) v1(7.66,45.34) v2(33.82,21.51) v3(5.1,47.69) v3(5.11,47.16) v3(5.09,46.61) v3(5.63,47.71) v3(5.65,47.17) v3(5.62,46.63) v4(5.46,46.21) v4(5.46,45.88) v4(5.79,46.2) v4(5.79,45.88) v4(6.11,46.19) v4(6.11,45.87) v8(6.57,45.68) v8(6.62,47.9) v8(6.71,41.14) v8(7.32,41.14) v8(13.21,24.76) v8(13.21,24.17) v8(13.79,24.75) v8(14.38,24.73) v8(14.73,23.73) v8(15.32,23.73) v8(32.74,21.99) v8(32.74,21.41) v8(32.74,20.82) v8(33.32,21.99) v8(33.32,21.41) v8(33.32,20.82)
+VBUS2_20V: length 25.2
  TOP w0.508: 40.59,18.63 40.04,18.08 40.04,15.42 38.51,13.89 38.51,13.07 35.68,10.23 35.68,6.67 35,5.99 35,4.9 32.63,2.54 31.92,2.54 31.32,3.13 v8(31.32,3.32)
  BOTTOM w0.254: PQ135.3 46,17.66 44.05,17.66 43.79,17.91 PQ113.3
  BOTTOM w0.508: PD106.2 31.32,4.18 v8(31.32,3.32)
  vias: v2(43.27,20.12) v8(40.38,19.56) v8(40.96,19.56) v8(41.59,19.56)
+VBUS2_PD_20V:
  vias: v1(5.57,64.55) v1(5.65,62.05) v1(5.96,64.55) v1(5.98,62.04) v1(7.25,64.29) v1(7.19,61.81) v1(7.58,61.79) v1(7.62,64.3) v3(4.91,64.04) v3(4.89,63.53) v3(4.89,63.09) v3(5.52,64.06) v3(5.54,63.53) v3(5.51,63.03) v4(5.35,62.58) v4(5.34,62.22) v4(5.71,62.23) v4(5.83,62.64) v4(6.06,62.23) v4(6.08,62.58) v8(6.52,64.37) v8(6.54,62.13) v8(11.65,61.75) v8(12.24,61.75) v8(12.84,61.76) v8(26.27,27.01) v8(26.29,27.68) v8(26.75,25.96) v8(27.33,25.96) v8(27.91,25.96) v8(28.22,26.49) v8(44.06,21.3) v8(44.64,21.3) v8(45.02,21.86) v8(45.23,21.3) v8(45.56,20.1) v8(45.95,19.64) v11(27.94,25.08) v11(44.73,20.72)
+VBUS3_20V: length 184.9
  GND1 w0.508: v3(31.35,6.41) 31.44,6.31 36.07,6.31 36.56,6.8 48.14,6.8 49,7.66 52.96,7.66 55.79,10.49 59.55,10.49 60.84,9.2 74.34,9.2 75.52,10.38 76.91,10.38 77.54,11.02 89.78,11.02 93.16,7.64 108.56,7.64 112.24,11.32 116.47,11.32 117.19,10.6 122.54,10.6 123.6,9.54 129.72,9.54 130.42,10.24 143.55,10.24 143.68,10.12 v3(144.5,10.12)
  IN2 w0.508: v3(162.85,4.33) 162.96,4.45 162.96,5.07 162.45,5.58 158.78,5.58 157.19,7.17 157.17,7.17 157.17,7.17 155.8,7.17 153.5,4.87 149.98,4.87 149.34,4.23 145.7,4.23 144.8,5.13 144.8,8.84 144.49,9.15 144.49,9.66
  GND3 w0.254: v4(31.26,5.94) 31.26,6.24 31.26,6.31 v3(31.35,6.41) 31.69,6.07 v4(31.69,5.93)
  GND3 w0.508: v6(162.85,3.92) v3(162.85,4.33)
  IN4 w0.635: 197.56,2.01 195.59,2.01 v5(195.44,2.16) 195.34,2.25 184.92,2.25 183.48,3.69 179.38,3.69 178.86,3.17 169.46,3.17 168.41,2.13 164.12,2.13 162.85,3.4 v6(162.85,3.92)
  vias: v2(198.96,2.94) v5(198.65,2.01) v5(198.91,2.01)
+VBUS3_PD_20V:
  vias: v1(288.95,51.56) v1(288.96,49.05) v1(289.37,51.56) v1(289.38,49.05) v3(265.09,2.49) v3(265.58,2.53) v3(266.07,2.53) v3(286.46,48.72) v3(286.45,48.3) v3(286.78,49.97) v3(286.78,50.83) v3(286.78,50.39) v3(286.79,49.53) v3(288.27,50.81) v3(288.29,50.35) v3(288.93,48.61) v3(288.91,48.04) v4(286.9,48.14) v4(287.01,48.39) v4(287.13,50.73) v4(287.14,50.45) v4(287.13,50.18) v4(287.38,50.73) v5(202.97,1.9) v5(203.08,1.64) v5(203.22,1.9) v5(203.37,1.65) v5(203.48,1.9) v5(203.65,1.63) v5(287.81,51.02) v5(287.78,48.28) v5(288.07,51.02) v5(288.05,48.28) v5(288.71,51.02) v5(288.69,48.28) v5(288.96,48.28) v5(288.99,51.02) v6(265.11,2.14) v6(265.39,2.15) v6(265.66,2.15) v6(265.94,2.15) v8(295.2,13.05) v8(295.2,12.46) v8(295.7,10.24) v8(295.79,13.05) v8(295.79,12.47) v8(295.79,11.87)
+VCC0V9_CIO: length 1.8
  TOP w0.102: v2(26.43,49.7) 25.97,50.16 25.33,50.16 v1(24.96,49.79)
  vias: v1(24.67,47.9) v1(24.88,49.19) v3(24.25,49.16) v3(24.2,48.52) v3(24.23,47.94) v4(24.49,49.5) v4(24.49,48.85) v4(24.49,48.2)
+VCC0V9_DP: length 2.2
  TOP w0.102: v2(27.55,48.98) 26.57,48.98 CT52.1
  GND1 w0.254: v1(22.8,47.73) 22.5,47.73 v3(22.34,47.89)
  vias: v1(22.97,50.34) v1(23.09,49.69) v1(23.15,49.13) v1(25.48,46.64) v1(25.74,48.18) v1(25.74,47.6) v1(26.11,47.3) v3(22.86,49.99) v3(22.85,49.37) v3(25.46,48.4) v3(25.45,47.88) v3(25.49,47.26) v4(22.54,50.15) v4(22.54,49.5) v4(22.54,48.2) v4(22.54,47.55) v4(23.19,50.15) v4(23.19,49.5) v4(25.14,48.2) v4(25.14,47.55) v4(25.79,48.2) v4(25.79,47.55) v4(25.79,46.9)
+VCC0V9_PCIE: length 4.9
  TOP w0.102: v2(22.56,41.22) 22.9,41.56 C1099.1
  BOTTOM w0.203: v8(22.87,44.62) UT2.M18 v8(22.87,45.27) UT2.M16 23.17,45.6 ; v8(22.87,44.62) UT2.L18 ; v8(22.87,44.62) UT2.L19 ; UT2.N19 v8(23.52,44.62) UT2.N18
  vias: v8(22.87,45.92)
+VCC0V9_USB: length 1.6
  TOP w0.102: v2(23.5,45.79) 23.63,45.92 v8(24.17,45.92)
  BOTTOM w0.127: UT2.R15 v8(24.17,45.92) 24.49,45.6 UT2.R16
+VCC_CORE: length 119.3
  TOP w0.254: v1(50.61,52.36) 50.61,52.33 49.85,51.57 49.22,51.57 49.21,51.57 PR1106.1 ; v1(47.88,50.38) 47.88,50.54 46.96,51.46 PR1115.1
  TOP w0.356: PC1274.1 v8(115.71,57) 115.74,56.98 PC1272.1
  GND1 w0.254: v3(48.44,50.3) 47.96,50.3 v1(47.88,50.38) ; v3(50.71,52.81) 50.61,52.72 v1(50.61,52.36)
  IN2 w0.254: v8(73.51,61.36) 73.41,61.26 73.41,59.92 72.19,58.7 70.17,58.7 68.8,57.32 67.7,57.32 66.54,58.48 64.38,58.48 62.84,56.94 62.84,53.43 61.63,52.22 59.76,52.22 59.31,52.67 53.35,52.67 52.87,53.15 51.05,53.15 v3(50.71,52.81) ; v3(48.44,50.3) 48.9,50.3 49.57,49.63 50.75,49.63 52.52,51.4 55.43,51.4 57.19,49.64 60.99,49.64 63.07,51.72 63.07,52.18 64.08,53.19 68.38,53.19 69.59,51.99 71.87,51.99 72.01,51.85 72.79,51.85 73.04,52.1 v8(73.04,52.36)
  GND3 w0.254: v4(116.61,62.2) 116.43,62.2 v3(116.16,62.47) 116.16,62.45 115.91,62.2 v4(115.7,62.2)
  BOTTOM w0.127: 117,49.96 UCPU1.AM37 ; UCPU1.AM37 116.23,49.96 ; UCPU1.AM37 116.61,50.34 ; 114.33,61.35 UCPU1.J40 ; UCPU1.J40 113.95,61.73 ; UCPU1.J40 114.71,61.73 ; UCPU1.J40 114.33,62.12 ; 116.23,61.27 UCPU1.K37 ; UCPU1.K37 116.61,60.89 ; UCPU1.K37 117,61.27 ; UCPU1.K37 116.61,61.65 ; UCPU1.K35 117.53,61.65 ; UCPU1.K35 117.53,60.89 ; UCPU1.K35 117.15,61.27 ; UCPU1.K35 117.91,61.27 ; UCPU1.AK33 118.82,50.9 ; UCPU1.AK33 118.44,50.52 ; UCPU1.AK33 118.44,51.28 ; 115.7,61.82 v4(115.7,62.2) 116.08,62.2 ; 114.4,62.2 UCPU1.G40 114.79,61.82 ; UCPU1.AK38 115.32,50.9 ; UCPU1.AK38 115.7,50.52 ; UCPU1.AK38 115.7,51.28 ; UCPU1.K40 114.4,61.27 ; UCPU1.K40 114.79,60.89 ; UCPU1.K40 114.79,61.65 ; UCPU1.K40 115.17,61.27 ; 118.52,50.43 UCPU1.AL33 ; UCPU1.AL33 118.9,50.81 ; UCPU1.AL33 119.28,50.43 ; UCPU1.AL33 118.9,50.05 ; UCPU1.J37 116.54,61.73 ; UCPU1.J37 116.16,61.35 ; UCPU1.J37 115.78,61.73 ; UCPU1.J37 116.16,62.12 ; 115.32,49.96 UCPU1.AM38 ; UCPU1.AM38 116.08,49.96 ; UCPU1.AM38 115.7,50.34 ; 118.82,49.96 UCPU1.AM33 ; UCPU1.AM33 118.44,50.34 ; UCPU1.AM33 118.06,49.96 ; 113.87,61.82 UCPU1.G42 114.25,62.2 ; 113.34,61.27 UCPU1.K43 112.96,60.89 ; 117.07,50.05 UCPU1.AL37 ; UCPU1.AL37 117.45,50.43 ; UCPU1.AL37 116.69,50.43 ; UCPU1.AL37 117.07,50.81 ; UCPU1.K33 118.44,61.65 ; UCPU1.K33 118.82,61.27 ; UCPU1.K33 118.06,61.27 ; UCPU1.K33 118.44,60.89 ; 119.82,62.12 UCPU1.J30 119.43,61.73 ; 114.79,50.52 UCPU1.AK40 ; UCPU1.AK40 114.79,51.28 ; UCPU1.AK40 115.17,50.9 ; UCPU1.AK40 114.4,50.9 ; 119.36,61.82 UCPU1.G32 119.74,62.2 ; 116.23,62.2 v4(116.61,62.2) 116.61,61.82 ; UCPU1.AL40 115.24,50.81 ; UCPU1.AL40 114.86,50.43 ; UCPU1.AL40 115.62,50.43 ; UCPU1.AL40 115.24,50.05 ; UCPU1.K38 116.08,61.27 ; UCPU1.K38 115.7,61.65 ; UCPU1.K38 115.32,61.27 ; UCPU1.K38 115.7,60.89 ; 117.53,50.52 UCPU1.AK35 ; UCPU1.AK35 117.53,51.28 ; UCPU1.AK35 117.15,50.9 ; UCPU1.AK37 116.61,51.28 ; UCPU1.AK37 117,50.9 ; UCPU1.AK37 116.61,50.52 ; UCPU1.J33 117.61,61.73 ; UCPU1.J33 117.99,61.35 ; UCPU1.J33 117.99,62.12 ; UCPU1.J33 118.37,61.73 ; 113.87,60.89 UCPU1.K42 ; UCPU1.K42 113.49,61.27 ; UCPU1.K42 114.25,61.27 ; UCPU1.K42 113.87,61.65 ; 118.44,61.82 UCPU1.G33 118.06,62.2 ; 117.91,49.96 UCPU1.AM35 ; UCPU1.AM35 117.53,50.34 ; UCPU1.AM35 117.15,49.96 ; 117.91,62.2 UCPU1.G35 117.53,61.82 ; 119.36,50.34 UCPU1.AM32 118.98,49.96
  BOTTOM w0.203: 119.85,66.18 119.88,66.18 120.13,66.43 ; UCPU1.A44 112.41,67.06
  BOTTOM w0.254: PL1100.2 v8(73.51,61.36) ; UCPU1.G30 120.04,62.43 v8(119.84,62.43) 119.59,62.43 UCPU1.G32 ; PL1103.2 72.61,53.15 73.04,52.71 v8(73.04,52.36) ; UCPU1.A39 115.11,66.11 115.11,66.34 115.38,66.62 117.01,66.62 v8(117.09,66.55) 117.09,66.18 UCPU1.A34 ; UCPU1.A30 119.85,66.18 ; 120.13,66.43 v8(120.13,66.68)
  BOTTOM w0.381: 112.14,69.66 112.14,67.39 112.41,67.13 112.41,67.06
  vias: v1(112.37,70.2) v1(112.63,70.09) v3(112.63,70.42) v4(112.12,70.54) v4(112.12,70.27) v8(72.38,63.63) v8(72.47,62.46) v8(72.39,57.5) v8(72.57,63.05) v8(72.51,58.15) v8(72.99,63.63) v8(73,57.51) v8(73.18,63.07) v8(73.09,62.48) v8(73.15,58.87) v8(73.13,58.18) v8(73.61,63.63) v8(73.61,57.52) v8(73.73,62.47) v8(73.72,59.43) v8(73.75,58.83) v8(73.71,58.19) v8(73.79,63.07) v8(74.23,63.63) v8(74.2,57.52) v8(74.37,63.05) v8(74.32,62.39) v8(74.33,60.66) v8(74.35,60.05) v8(74.37,59.46) v8(74.34,58.79) v8(74.33,58.2) v8(74.81,63.62) v8(74.79,57.56) v8(74.91,62.4) v8(74.92,60.67) v8(74.94,60.09) v8(74.97,59.46) v8(74.96,58.79) v8(74.95,58.2) v8(75.41,63.63) v8(75.53,57.81) v8(75.6,59.04) v8(75.86,58.3) v8(76.22,58.93) v8(76.26,57.79) v8(76.6,58.28) v8(76.88,58.89) v8(77.01,57.82) v8(77.26,58.41) v8(77.62,57.89) v8(78.08,58.47) v8(78.09,60.29) v8(78.1,59.65) v8(78.09,59.07) v8(78.25,57.85) v8(78.73,60.29) v8(78.71,59.66) v8(78.71,59.07) v8(78.7,58.47) v8(78.87,57.85) v8(79.34,60.29) v8(79.34,59.67) v8(79.34,58.46) v8(79.39,59.07) v8(79.47,57.87) v8(79.9,59.41) v8(82.3,64.12) v8(82.67,64.58) v8(82.92,63.91) v8(83.22,63.38) v8(83.66,62.98) v8(84.11,62.6) v8(85.15,61.05) v8(85.77,61.05) v8(86.36,61.06) v8(86.97,61.06) v8(87.57,61.04) v8(88.17,61.04) v8(88.78,61.05) v8(89.96,61.08) v8(91.17,61.03) v8(92.42,61.03) v8(113.37,60.62) v8(113.77,60.09) v8(113.74,56.38) v8(113.74,55.79) v8(113.87,56.99) v8(114.28,60.73) v8(114.32,62.45) v8(114.44,58.5) v8(114.78,60.09) v8(114.78,54.04) v8(115.06,55.64) v8(115.23,60.66) v8(115.21,52.71) v8(115.66,58.5) v8(115.74,60.09) v8(115.74,52.09) v8(116.1,54.06) v8(116.16,49.52) v8(116.18,60.66) v8(116.29,52.72) v8(116.56,52.09) v8(116.63,60.09) v8(116.88,58.5) v8(117.07,60.6) v8(117.04,52.71) v8(117.07,51.52) v8(117.07,49.54) v8(117.37,54.06) v8(117.39,52.09) v8(117.51,60.09) v8(117.65,56.3) v8(117.83,52.72) v8(118.02,60.6) v8(118.02,52.09) v8(117.98,49.54) v8(118.1,58.5) v8(118.47,51.65) v8(118.54,54.04) v8(118.59,60.09) v8(118.64,52.71) v8(118.97,55.33) v8(118.9,52.06) v8(119.1,60.6) v8(119.18,54.19) v8(119.41,58.33) v8(119.38,56.58) v8(119.41,55.74) v8(119.38,54.78) v11(77.61,62.49)
+VCC_CORE_G0: length 1.2
  GND1 w0.254: v3(119.9,61.22) 119.9,61.19 119.78,61.06 v1(119.78,60.89)
  GND3 w0.254: v4(119.65,60.96) 119.9,61.21 v3(119.9,61.22)
  BOTTOM w0.254: v4(119.65,60.96) 119.36,61.25 UCPU1.K32
+VCC_CORE_G1: length 1.3
  TOP w0.254: T30.1 119.28,51.28 v8(119.28,51.6)
  BOTTOM w0.254: UCPU1.AK32 119.36,51.52 v8(119.28,51.6)
+VCC_EDRAM: length 10.4
  IN3 w3.048: 81.67,42.08 81.67,45.78 83.45,47.56 83.45,51.74
  vias: v8(63.68,38.02) v8(63.74,37.43) v8(63.76,36.84) v8(64.3,37.95) v8(65.26,36.92) v8(65.27,36.27) v8(102.83,55.48) v8(103.47,57) v8(103.47,56.42) v8(103.44,55.48) v11(102.27,55.46)
+VCC_EDRAM_P: length 13.3
  IN2 w0.254: v8(61.67,35.87) 61.06,36.48 59,36.48 57.83,35.32 57.83,32.48 59.22,31.09 59.22,30.62 60.22,29.63 v3(61.85,29.63)
  GND3 w0.254: v4(62.2,29.79) 62.19,29.79 62.02,29.63 v3(61.85,29.63)
  vias: v2(63.01,36.48) v8(62.49,38.01) v8(63.08,38.03)
+VCC_EOPIO: length 15.2
  TOP w0.102: v8(76.14,37.22) v2(76.14,36.52)
  IN4 w2.54: 81.18,38.06 83.54,40.43 83.54,51.62
  vias: v8(76.13,38.4) v8(76.11,37.81) v8(76.7,37.8) v8(76.72,37.21) v8(102.87,52.78) v8(103.07,52.18) v8(103.47,52.8) v8(103.66,52.18)
+VCC_EOPIO_P: length 12.3
  TOP w0.102: v2(73.45,36.27) 73.15,36.56 PC1516.1
  TOP w0.508: PC1516.1 72.13,35.63 v8(72.13,35.63)
  BOTTOM w0.254: PR1519.1 72.8,30.3 73.32,30.81 75.81,30.81 76.39,31.39 76.39,35.83 76.25,35.97 75.28,35.97 75.06,36.19
+VCCGT: length 152.7
  TOP w0.254: PR1154.1 44.76,41.35 v1(44.76,42.05)
  GND1 w0.254: v1(44.76,42.05) v3(44.76,41.62)
  IN2 w0.254: v8(75.3,42.07) 75.18,41.95 75.18,41.42 74.25,40.49 64.61,40.49 63.91,41.19 62.63,41.19 61.21,39.77 52.91,39.77 50.26,42.42 48.3,42.42 47.63,41.75 44.9,41.75 v3(44.76,41.62)
  IN3 w0.254: v8(75.82,49.31) 75.74,49.22 75.74,48.36 74.63,47.25 70.62,47.25 69.64,46.26 69.64,42.06 68.78,41.21 67.68,41.21 66.89,40.42 64.7,40.42 63.91,41.21 61.83,41.21 60.12,39.51 53.57,39.51 50.34,42.74 48.25,42.74 48.18,42.66 v8(47.56,42.66)
  IN4 w0.508: v8(91.26,49.59) 91.35,49.5 91.35,46.36 92.89,44.82 v5(92.89,37.44)
  BOTTOM w0.127: UCPU1.AL53 107.93,50.81 ; UCPU1.AL53 107.55,50.43 ; UCPU1.AL53 107.93,50.05 ; UCPU1.AL56 106.48,50.43 ; UCPU1.AL56 106.1,50.81 ; UCPU1.AL56 105.72,50.43 ; UCPU1.AL56 106.1,50.05 ; UCPU1.AK53 107.85,50.9 ; UCPU1.AK53 107.47,51.28 ; UCPU1.AK53 107.47,50.52 ; 102.14,56.04 UCPU1.W63 ; UCPU1.W63 102.52,56.42 ; UCPU1.W63 102.14,56.8 ; UCPU1.W63 101.76,56.42 ; UCPU1.AK60 103.81,51.28 ; UCPU1.AK60 103.81,50.52 ; UCPU1.AK60 104.19,50.9 ; 102.6,59.24 UCPU1.M62 ; UCPU1.M62 102.99,59.62 ; UCPU1.M62 102.6,60 ; UCPU1.M62 102.22,59.62 ; UCPU1.J55 106.1,61.35 ; UCPU1.J55 106.48,61.73 ; UCPU1.J55 105.72,61.73 ; 102.22,55.96 UCPU1.Y62 102.6,56.34 ; 104.35,61.27 UCPU1.K58 ; UCPU1.K58 105.11,61.27 ; UCPU1.K58 104.73,61.65 ; UCPU1.K58 104.73,60.89 ; 104.35,49.96 UCPU1.AM58 ; UCPU1.AM58 104.73,50.34 ; UCPU1.AM58 105.11,49.96 ; 107.47,60.89 UCPU1.K53 ; UCPU1.K53 107.09,61.27 ; UCPU1.K53 107.47,61.65 ; UCPU1.AK55 106.56,51.28 ; UCPU1.AK55 106.56,50.52 ; UCPU1.AK55 106.18,50.9 ; 103.43,61.27 UCPU1.K60 ; UCPU1.K60 103.81,61.65 ; UCPU1.K60 104.19,61.27 ; UCPU1.K60 103.81,60.89 ; UCPU1.K56 106.02,61.27 ; UCPU1.K56 105.64,61.65 ; UCPU1.K56 105.64,60.89 ; UCPU1.K56 105.26,61.27 ; 101.76,59.16 UCPU1.N63 ; UCPU1.N63 102.14,59.54 ; UCPU1.N63 102.52,59.16 ; 103.36,61.35 UCPU1.J60 ; UCPU1.J60 103.74,61.73 ; UCPU1.J60 103.36,62.12 ; UCPU1.AL60 104.27,50.81 ; UCPU1.AL60 104.27,50.05 ; UCPU1.AL60 103.89,50.43 ; UCPU1.AL60 104.65,50.43 ; 104.73,50.52 UCPU1.AK58 ; UCPU1.AK58 104.73,51.28 ; UCPU1.AK58 104.35,50.9 ; UCPU1.J53 107.01,61.35 ; UCPU1.J53 106.63,61.73 ; UCPU1.J53 107.39,61.73 ; 106.18,61.27 UCPU1.K55 ; UCPU1.K55 106.56,61.65 ; UCPU1.K55 106.56,60.89 ; UCPU1.K55 106.94,61.27 ; 107.85,49.96 UCPU1.AM53 ; UCPU1.AM53 107.47,50.34 ; UCPU1.AM53 107.09,49.96 ; UCPU1.AA63 102.14,55.88 ; UCPU1.AA63 101.76,55.5 ; UCPU1.AA63 102.14,55.12 ; UCPU1.L62 102.99,60.53 ; UCPU1.L62 102.6,60.91 ; UCPU1.L62 102.6,60.15 ; UCPU1.L62 102.22,60.53 ; UCPU1.J56 105.18,61.35 ; UCPU1.J56 104.8,61.73 ; UCPU1.J56 105.57,61.73 ; UCPU1.AK56 105.64,51.28 ; UCPU1.AK56 105.64,50.52 ; UCPU1.AK56 106.02,50.9 ; 101.76,60.08 UCPU1.L63 ; UCPU1.L63 102.52,60.08 ; UCPU1.L63 102.14,59.69 ; UCPU1.L63 102.14,60.46 ; 103.89,61.73 UCPU1.J58 ; UCPU1.J58 104.27,61.35 ; UCPU1.J58 104.65,61.73 ; 102.22,57.79 UCPU1.T62 102.6,57.41 ; 101.76,58.25 UCPU1.R63 102.14,57.87 ; 105.64,50.34 UCPU1.AM56 105.26,49.96
  BOTTOM w0.178: UCPU1.AK70 96.2,51.08 v8(96.16,51.12)
  BOTTOM w0.203: UCPU1.A58 104.98,65.9 v5(104.98,66.71) ; UCPU1.A66 100.02,66.59 99.89,66.72 v5(99.89,66.9)
  BOTTOM w0.254: PL1150.2 77.98,42.07 v8(75.3,42.07) ; UCPU1.AU58 104.57,46.71 v8(104.27,47.01) ; PR1119.1 46.87,42.02 PR1118.1 47.52,42.66 v8(47.56,42.66) ; UCPU1.BB57 105.01,43.89 105.01,43.89 105.06,43.78 105.06,43.68 105.09,43.64 105.09,42.65 105.19,42.55 105.19,42.42 105.2,42.42 105.2,39.36 104.19,38.36 104.19,38.35 103.92,38.08 103.92,38.08 103.24,37.41 92.93,37.41 v5(92.89,37.44) ; UCPU1.BB66 100.01,43.9 100.01,43.45 v8(99.71,43.16) ; PL1107.2 v8(75.82,49.31) ; v8(101.53,47.01) 101.83,46.71 UCPU1.AU63
  vias: v4(102.5,65.9) v8(76.19,47.53) v8(76.22,46.89) v8(76.26,46.26) v8(76.26,45.58) v8(76.8,47.57) v8(76.83,46.92) v8(76.87,46.3) v8(76.87,45.62) v8(77.08,51.7) v8(77.09,51.09) v8(77.4,47.55) v8(77.43,46.91) v8(77.47,46.28) v8(77.46,45.6) v8(77.76,51.72) v8(77.8,51.12) v8(78.02,47.55) v8(78.04,46.91) v8(78.08,45.6) v8(78.08,46.28) v8(78.37,52.37) v8(78.37,51.71) v8(78.39,51.12) v8(78.65,47.54) v8(78.68,46.9) v8(78.72,46.27) v8(78.72,45.59) v8(79.05,51.77) v8(79.08,51.13) v8(79.1,52.42) v8(79.32,46.87) v8(79.36,46.25) v8(79.37,45.64) v8(79.66,54.11) v8(79.66,53.47) v8(79.69,52.8) v8(79.73,51.62) v8(79.72,50.99) v8(79.78,47.25) v8(80.04,52.2) v8(80.35,53.38) v8(80.33,52.79) v8(80.4,51.64) v8(80.4,51) v8(80.45,47.29) v8(80.65,47.86) v8(80.7,52.22) v8(80.96,53.41) v8(81,52.75) v8(81.05,51.64) v8(81.06,51.01) v8(81.32,52.23) v8(81.55,53.4) v8(81.65,52.78) v8(82.17,53.4) v8(83.26,55.44) v8(83.8,55.72) v8(83.81,55.13) v8(84.41,55.74) v8(84.42,55.14) v8(85.02,55.76) v8(85.03,55.16) v8(85.4,50.53) v8(85.39,49.93) v8(85.51,51.12) v8(85.65,55.75) v8(85.64,55.12) v8(86.11,51.17) v8(86.24,55.74) v8(86.24,55.14) v8(86.75,52.57) v8(86.7,51.14) v8(86.85,55.75) v8(86.87,55.14) v8(87.3,51.15) v8(87.44,55.76) v8(87.47,55.14) v8(87.41,52.55) v8(88.05,55.75) v8(88.07,52.55) v8(88.11,55.13) v8(88.66,55.74) v8(88.67,52.55) v8(88.7,55.14) v8(89.27,55.79) v8(89.29,55.15) v8(89.86,55.78) v8(90.48,55.78) v8(90.7,49.44) v8(91.09,55.78) v8(91.72,55.76) v8(97.31,57.78) v8(97.87,55.95) v8(97.91,57.79) v8(98.55,57.82) v8(98.56,55.05) v8(99.21,57.79) v8(99.81,58.73) v8(99.87,57.82) v8(99.84,55.9) v8(99.86,55.05) v8(100.47,58.76) v8(100.55,57.83) v8(101.13,58.76) v8(101.17,57.84) v8(101.75,55.96) v8(101.8,59.7) v8(101.8,55.06) v8(102.87,56.42) v8(103.11,60) v8(103.32,61.04) v8(103.77,59.29) v8(103.93,51.41) v8(104.23,51.92) v8(104.36,59.29) v8(104.33,49.58) v8(104.55,51.4) v8(104.85,58.3) v8(104.9,51.91) v8(105.17,61.1) v8(105.17,49.53) v8(105.48,58.31) v8(105.6,51.9) v8(106.08,58.3) v8(106.12,61.07) v8(106.13,51.34) v8(106.52,51.85) v8(106.72,58.34) v8(106.99,60.83) v8(107.04,49.58) v8(107.35,58.32) v8(107.39,51.86) v8(107.91,49.58) v8(108,58.33) v11(93.32,56.62)
+VCCIA_GT: length 23.6
  BOTTOM w0.127: 110.75,50.9 UCPU1.AK46 ; UCPU1.AK46 111.13,50.52 ; UCPU1.AK46 111.51,50.9 ; UCPU1.AK46 111.13,51.28 ; 109.3,50.52 UCPU1.AK50 ; UCPU1.AK50 109.3,51.28 ; UCPU1.AK50 109.68,50.9 ; 109.83,61.27 UCPU1.K48 ; UCPU1.K48 110.59,61.27 ; UCPU1.K48 110.21,60.89 ; UCPU1.K48 110.21,61.65 ; UCPU1.AK45 112.04,51.28 ; UCPU1.AK45 112.42,50.9 ; UCPU1.AK45 111.66,50.9 ; UCPU1.AK45 112.04,50.52 ; UCPU1.AL50 109.76,50.81 ; UCPU1.AL50 109.38,50.43 ; UCPU1.AL50 110.14,50.43 ; UCPU1.AL50 109.76,50.05 ; 111.05,61.73 UCPU1.J46 ; UCPU1.J46 110.29,61.73 ; UCPU1.J46 110.67,61.35 ; UCPU1.J45 111.59,61.35 ; UCPU1.J45 111.97,61.73 ; UCPU1.J45 111.2,61.73 ; UCPU1.AL43 113.41,50.81 ; UCPU1.AL43 113.8,50.43 ; UCPU1.AL43 113.41,50.05 ; UCPU1.AL43 113.03,50.43 ; 111.59,50.05 UCPU1.AL46 ; UCPU1.AL46 111.59,50.81 ; UCPU1.AL46 111.2,50.43 ; UCPU1.AL46 111.97,50.43 ; 112.5,61.35 UCPU1.J43 112.12,61.73 ; UCPU1.AK43 112.96,51.28 ; UCPU1.AK43 112.96,50.52 ; UCPU1.AK43 113.34,50.9 ; UCPU1.AK43 112.58,50.9 ; UCPU1.J48 109.76,61.35 ; UCPU1.J48 109.38,61.73 ; UCPU1.J48 110.14,61.73 ; 108.92,61.27 UCPU1.K50 ; UCPU1.K50 109.68,61.27 ; UCPU1.K50 109.3,60.89 ; UCPU1.K50 109.3,61.65 ; UCPU1.AK42 113.49,50.9 ; UCPU1.AK42 113.87,50.52 ; UCPU1.AK42 113.87,51.28 ; UCPU1.J50 108.84,61.35 ; UCPU1.J50 UCPU1.J52 ; UCPU1.J50 109.22,61.73 ; UCPU1.AK48 110.21,51.28 ; UCPU1.AK48 110.21,50.52 ; UCPU1.AK48 109.83,50.9 ; UCPU1.AK48 110.59,50.9
  BOTTOM w0.203: v8(109.95,66.75) 110.09,66.61 110.09,66.05 UCPU1.A48 ; UCPU1.A53 107.32,66.04 v8(107.32,66.61)
  vias: v8(109.58,51.98) v8(109.67,59.93) v8(109.74,51.33) v8(110.2,60.56) v8(110.24,51.98) v8(110.64,51.35) v8(110.68,59.87) v8(110.85,51.98) v8(111.09,60.64) v8(111.51,59.82) v8(111.53,51.98) v8(111.59,51.35) v8(112.17,52.01) v8(112.36,51.37) v11(109.36,64.55)
+VCCPLL_OC: length 7.8
  TOP w0.102: CZ6.1 125.67,40.86 125.67,39.48 v11(125.36,39.17)
  TOP w0.305: CC30.1 124.38,51.89 v8(124.05,51.89)
  TOP w0.508: v7(125.92,42.83) 125.92,42.67 125.2,41.95 CZ6.1 124.98,41.12 124.26,41.12 R103.2
  BOTTOM w0.254: v8(124.05,51.89) 124.39,51.55 UCPU1.AL23
+VCCSA: length 43.8
  TOP w0.254: v8(57.57,55.74) 57.57,56.05 57.3,56.32 56.72,56.32 56.43,56.62 56.43,58.16 55.43,59.15 52.1,59.15 50.11,57.17 44.9,57.17 44.38,56.65 43.43,56.65 42.13,57.95 37.1,57.95 35.22,56.07 PR1159.1
  BOTTOM w0.127: UCPU1.G25 123.02,61.82 ; UCPU1.G25 122.63,62.2 ; UCPU1.G25 123.4,62.2 ; 122.48,62.2 UCPU1.G27 ; UCPU1.G27 122.1,61.82 ; UCPU1.G27 121.72,62.2 ; 123.93,60.89 UCPU1.K23 ; UCPU1.K23 124.31,61.27 ; UCPU1.K23 123.93,61.65 ; UCPU1.K23 123.55,61.27 ; 120.27,60.89 UCPU1.K30 120.27,61.65 ; 122.1,61.65 UCPU1.K27 121.72,61.27 ; UCPU1.K28 121.19,61.65 ; UCPU1.K28 121.57,61.27 ; UCPU1.K28 121.19,60.89 ; UCPU1.J22 124.01,61.73 ; UCPU1.J22 124.39,61.35 ; UCPU1.J22 124.39,62.12 ; UCPU1.G28 120.92,62.2 120.85,62.14 ; UCPU1.G28 121.57,62.2 ; UCPU1.G28 121.19,61.82 ; UCPU1.K25 123.02,61.65 ; UCPU1.K25 123.02,60.89 ; UCPU1.K25 123.4,61.27 ; 121.64,61.35 UCPU1.J27 ; UCPU1.J27 121.64,62.12 ; UCPU1.J27 122.02,61.73 ; UCPU1.J27 121.26,61.73 ; UCPU1.J23 123.85,61.73 ; UCPU1.J23 123.47,61.35 ; UCPU1.J23 123.09,61.73 ; UCPU1.J23 123.47,62.12 ; 123.55,62.2 UCPU1.G23 123.93,61.82
  BOTTOM w0.33: v8(57.57,55.74) 57.63,55.8 PL1151.2
  vias: v8(56.66,54.66) v8(56.66,54.01) v8(56.98,57.53) v8(56.98,56.87) v8(57.03,58.14) v8(57.25,54.64) v8(57.25,54.01) v8(57.63,58.08) v8(57.6,57.49) v8(57.63,56.86) v8(57.84,54.62) v8(57.85,53.97) v8(112.89,73.13) v8(113.53,73.12) v8(120.65,62.54) v8(121.67,60.97) v8(121.74,62.52) v8(122.48,56.91) v8(122.71,54.94) v8(122.76,54.29) v8(123.11,51.91) v8(123.37,62.51) v8(123.83,60.59) v11(111.01,71.2)
AGND: length 3.6
  GND3 w0.254: 285.54,59.72 v3(285.54,60.1)
  BOTTOM w0.203: U5.22 278.06,66.57 CA12.2 ; v4(291.29,63.37) 291.42,63.24 JAUDIO1.3
  vias: v1(280.31,57.71) v1(280.63,57.75) v1(280.96,65.19) v1(281.01,63.81) v1(281.05,62.44) v1(281.64,60.53) v1(281.92,60.55) v1(282.22,63.33) v1(282.28,61.94) v1(283.35,60.99) v1(283.3,59.54) v1(283.36,58.15) v1(283.4,65.66) v1(283.43,63.3) v1(284.37,60.02) v1(284.43,58.64) v1(285.1,65.5) v1(285.19,64.57) v1(285.34,62.99) v1(285.39,61.6) v1(286.32,65.48) v1(286.37,64.09) v1(286.74,59.43) v1(286.8,58.04) v1(287.54,62.75) v1(287.6,61.36) v1(289.92,63.02) v1(289.98,61.63) v3(279.5,66.59) v3(279.71,63.05) v3(279.91,56.82) v3(280.9,64.51) v3(280.92,63.12) v3(280.97,59.31) v3(281.84,58.32) v3(282.34,59.47) v3(282.45,56.81) v3(284.43,62.18) v3(284.55,57.35) v3(286.6,57.52) v3(286.81,66) v3(287.1,58.8) v3(288.37,66.59) v3(289.24,66.07) v3(289.98,66.75) v3(290.77,68.64) v3(290.78,67.72) v3(290.86,62.7) v3(293.28,64.05) v3(293.41,69.13) v3(293.78,67.01) v3(293.73,65.11) v3(293.8,68.17) v4(277.41,67.22) v4(277.64,67.01) v4(279.8,58.38) v4(280.56,57.39) v4(280.76,57.56) v4(281.04,56.29) v4(281.34,56.57) v4(283.24,66.46) v4(283.3,59.98) v4(283.33,56.6) v4(284.76,59.45) v4(287.4,62.11) v4(287.43,60.33) v4(287.44,57.68) v4(287.86,63.44) v4(290.87,69.25) v8(279.44,59.14) v8(279.49,64.73) v8(280.89,66.61) v8(282.79,67.28) v8(284.46,61.19) v8(286.41,61.87) v8(286.54,62.89) v8(288.07,58.37) v8(288.04,57.72) v8(288.45,62.93) v8(288.4,61.69) v11(281.88,66.29) v11(283.19,64.24) v11(285.64,59.39)
DV12S: length 3.7
  IN4 w0.508: 284.7,32.32 284.7,33.02 284.38,33.34 284.38,34.84
  BOTTOM w0.095: CR21.1 v2(284.72,36.41)
  vias: v4(284.6,35.26) v4(284.85,35.4) v5(284.67,31.6) v5(285.09,31.66)
DV33_18: length 1.6
  BOTTOM w0.095: v2(288.19,38.39) 288.19,38.02 287.43,37.26 CR9.2
GND: length 2408.7
  TOP w0.203: U11.11 149.28,33.73 v1(149.28,33.73) ; v1(271.86,6.03) 271.54,5.71 U6.34 ; U6.20 269.1,9.45 269.22,9.32 v1(269.37,9.32) ; U6.45 275.06,7.05 v1(275.03,7.01) ; v1(275,10.26) 275.01,10.25 U6.53 ; U6.46 275.05,7.45 v1(275.04,7.46) ; U6.54 v1(274.99,10.65) ; v1(69.35,5.25) 69.35,5.74 68.85,6.25 PR333.2 ; v1(273.42,6.1) 273.54,5.99 U6.39 ; v8(268.17,45.25) U13.11 ; U6.33 271.14,5.85 v1(271.42,6.13) ; PD104.1 v1(98.62,9.18) ; v1(269.39,9.72) 269.26,9.85 U6.19 ; U12.11 v1(224.27,9.52)
  TOP w0.254: UD42.G4 88.51,20.75 v8(88.19,20.43) 88.51,20.1 UD42.G3 ; UD43.N4 143.41,20.75 v8(143.74,20.43) 144.06,20.1 UD43.P3 ; v1(8.17,54.88) v1(8.17,55.27) v1(8.59,55.27) ; UD44.T4 129.79,20.75 v8(129.46,20.42) 129.14,20.74 UD44.R4 ; v8(87.54,22.03) 87.21,21.7 UD42.E5 ; v8(87.54,22.03) 87.86,21.7 UD42.F5 87.86,21.55 v8(87.54,21.23) ; v8(87.54,22.03) 87.86,22.35 UD42.F6 ; v8(87.54,22.03) 87.21,22.35 UD42.E6 ; UD42.T6 94.36,22.4 94.04,22.07 v8(94.04,22.03) 93.71,22.35 UD42.R6 ; UD43.M12 142.76,27.31 142.99,27.54 v8(142.99,27.68) ; UD44.N5 127.84,21.55 127.53,21.23 v8(127.53,21.23) 127.53,21.23 127.55,21.21 127.55,21.17 127.84,20.88 UD44.N4 127.84,20.75 127.52,20.43 v8(127.52,20.43) 127.19,20.75 UD44.M4 ; UD41.J12 105.33,27.59 v8(105.57,27.82) ; UD42.R5 93.71,21.57 v8(94.04,21.24) 94.04,21.31 UD42.T5 ; CE79.2 v1(11.52,6.12) ; UD41.F12 103.38,27.33 103.84,27.79 v8(104.12,27.79) ; v8(138.54,22.03) 138.7,22.18 138.86,22.35 UD43.F6 ; v8(138.54,22.03) 138.21,21.7 UD43.E5 ; v8(138.54,22.03) 138.21,22.35 UD43.E6 ; v8(138.54,22.03) 138.86,21.7 UD43.F5 UD43.F4 UD43.E4 138.21,20.9 137.89,21.23 v8(137.89,21.24) ; v8(139.79,18.57) 139.79,18.61 140.16,18.99 UD43.H2 ; UD42.R4 93.71,20.8 ; 93.71,20.8 93.39,20.48 93.39,20.44 v8(93.39,20.43) 93.38,20.43 93.38,20.39 93.06,20.07 UD42.P3 ; 93.71,20.8 94.02,20.49 94.02,20.45 v8(94.04,20.43) ; v8(121.02,20.43) 121.15,20.3 121.2,20.25 121.2,20.17 UD44.C3 UD44.D3 ; UD44.B5 120.69,21.7 v8(120.37,22.03) 120.69,22.35 UD44.B6 ; v8(91.83,27.74) 91.76,27.67 UD42.M12 ; v8(145.69,27.63) 145.36,27.3 UD43.T12 ; UD42.N6 92.41,22.33 v8(92.09,22.01) ; v8(109.55,20.43) 109.88,20.75 UD41.T4 ; UD44.H2 124.59,18.74 v8(124.54,18.69) ; v1(8.57,60.04) v1(8.86,59.75) v1(9.16,59.45) ; UD42.H10 89.16,25.57 v8(88.84,25.24) 88.51,24.92 UD42.G9 ; UD44.B2 120.69,19.3 v8(121.02,19.63) ; JXDP1.7 v1(51.28,72.16) ; UD41.C3 101.43,20.1 v8(101.76,20.43) 101.88,20.3 102.08,20.1 UD41.D3 ; UD42.P12 93.06,27.46 v8(93.33,27.74) ; v8(130.12,27.63) 129.79,27.3 UD44.T12 ; v8(123.62,25.23) 123.94,24.9 UD44.G9 124.59,25.48 UD44.H10 ; UD41.E6 102.73,22.35 v8(103.06,22.03) ; UD42.B12 85.26,27.3 v8(84.94,27.62) ; v8(137.24,23.63) 137.56,23.95 UD43.D8 ; UD42.J4 89.81,20.76 v8(89.49,20.44) ; UD42.N4 92.41,20.76 v8(92.09,20.43) 91.76,20.76 UD42.M4 91.44,21.15 v8(91.44,21.23) ; v8(139.01,27.78) 138.86,27.63 UD43.F12 ; D46.2 v1(6.99,56.66) ; UD44.E4 122.64,20.9 v8(122.97,21.23) 123.29,20.9 UD44.F4 ; UD42.K10 90.46,25.54 91.11,24.89 UD42.L9 UD42.L8 91.11,23.66 v8(90.96,23.51) ; UD44.L8 126.54,24.1 v8(126.22,24.43) 126.54,24.75 UD44.L9 126.54,24.98 UD44.K10 ; v1(287.57,52.15) 287.76,52.15 288.08,51.84 288.08,51.66 v8(288.1,51.63) ; UD43.K2 141.46,18.67 v8(141.47,18.67) ; v1(10.94,41.5) v1(10.94,41.03) v1(10.94,40.61) ; v8(286.33,44.18) 286.11,44.4 v1(286.11,45.04) ; UD44.J4 125.24,20.9 v8(125.57,21.23) ; UD42.K2 v8(90.46,18.7) ; UD44.G6 123.94,22.51 123.62,22.83 v8(123.62,23.63) 123.94,23.95 UD44.G8 ; UD42.B6 85.26,22.35 v8(84.94,22.03) 85.26,21.7 UD42.B5 ; v8(136.59,19.63) 136.26,19.3 UD43.B2 ; UD44.C5 121.34,21.7 v8(121.02,22.03) 121.34,22.35 UD44.C6 ; v8(128.17,20.43) 128.29,20.3 128.49,20.1 UD44.P3 ; UD44.F12 123.61,27.54 v8(123.61,27.72) ; v8(103.06,22.03) 103.38,22.35 UD41.F6 UD41.G6 ; v8(103.06,22.03) 103.38,21.7 UD41.F5 ; v8(103.06,22.03) 102.73,21.7 UD41.E5 ; v8(139.18,25.22) 139.18,25.16 UD43.G9 139.6,24.91 139.68,24.99 139.68,25.14 UD43.H10 ; v8(85.59,19.63) 85.26,19.3 UD42.B2 ; v8(108.91,23.63) 108.58,23.95 UD41.P8 ; v1(16.62,52.29) 16.87,52.03 C1096.2 ; UD44.D8 121.99,23.76 v8(121.78,23.54) ; UD44.J12 125.24,27.8 v8(125.31,27.86) ; v8(120.37,27.63) 120.69,27.3 UD44.B12 ; UD42.T2 UD42.T3 94.39,20.02 94.66,20.3 94.66,20.41 v8(94.69,20.43) ; v1(10.97,64.05) 10.86,64.05 10.64,64.27 v1(10.64,64.35) 10.81,64.51 v1(11,64.51) ; v8(100.47,27.63) 100.68,27.41 100.78,27.32 UD41.B12 ; UD41.R6 109.23,22.35 v8(109.56,22.03) 109.88,22.35 UD41.T6 ; UD44.E5 122.64,21.7 v8(122.97,22.03) ; RC165.2 123.72,51.22 v8(123.58,51.37) ; v8(88.19,22.03) 88.51,22.35 UD42.G6 ; v8(107.61,22.03) 107.93,22.35 UD41.N6 ; v8(107.61,22.03) 107.93,21.7 UD41.N5 107.93,21.55 v8(107.61,21.23) 107.93,20.9 UD41.N4 ; v8(107.61,22.03) 107.28,22.35 UD41.M6 ; UD43.G6 139.51,23.3 v8(139.19,23.63) 139.51,23.95 UD43.G8 ; v1(287.57,53.6) 287.57,53.84 v8(287.21,54.19) ; v1(268.49,51.02) 268.17,50.71 R96.1 ; UD42.M6 91.76,22.37 v8(91.43,22.04) 91.11,22.36 UD42.L6 ; UD41.P12 108.58,27.95 v8(108.59,27.97) ; UD41.K10 105.98,25.48 UD41.L9 UD41.L8 106.63,23.95 v8(106.31,23.63) ; UD41.H10 104.15,25.1 104.15,25.04 104.03,24.92 UD41.G9 104.18,24.68 104.18,24.17 UD41.G8 104.03,23.89 v8(103.71,23.56) ; C87.2 144.65,33.61 v1(144.3,33.26) ; UD43.K10 141.46,25.48 UD43.L9 142.11,24.75 v8(141.79,24.43) 141.9,24.32 142.11,24.1 UD43.L8 ; v1(10.26,56.98) v1(10.66,56.98) ; v1(10.26,56.98) v1(10.26,57.45) ; v1(10.26,56.98) v1(10.26,56.53) ; v1(21.11,12.86) 20.76,13.21 UE3.E6 ; UD44.M12 127.19,27.77 v8(127.26,27.84) ; UD43.P12 144.06,27.8 v8(144.13,27.86) ; UD44.M6 127.37,22.25 127.37,22.16 v8(127.51,22.02) 127.51,22.07 127.84,22.4 UD44.N6 ; UD44.D12 121.99,27.47 v8(122.49,27.97) ; v8(104.36,21.23) 104.03,20.9 UD41.G4 UD41.G3 ; v8(87.54,21.23) 87.86,20.9 UD42.F4 ; v8(87.54,21.23) 87.21,20.9 UD42.E4 ; UD44.G3 UD44.G4 123.94,20.9 v8(124.27,21.23) ; v8(122.97,22.03) 123.29,21.7 UD44.F5 ; v8(122.97,22.03) 122.64,22.35 UD44.E6 ; v8(122.97,22.03) 123.29,22.35 UD44.F6 ; v1(28.75,38.08) 28.22,38.08 27.95,38.35 CT97.2 ; UD44.P12 128.49,27.72 v8(128.59,27.82) ; v1(12.3,48.23) 12.3,48.23 v1(12.59,48.52) ; v1(12.3,48.23) 12.3,48.23 v1(11.98,48.54) ; v1(12.3,48.23) v1(12.61,47.92) ; v8(85.88,28.4) 86.4,27.88 86.4,27.39 UD42.D12 ; v8(89.87,27.79) 89.87,27.29 UD42.J12 ; C142.2 18.66,36.35 v1(18.71,36.41) ; v1(287.5,45.04) 287.5,44.26 v8(287.44,44.2) ; UD43.R5 144.71,21.55 v8(145.04,21.23) 145.36,21.55 UD43.T5 ; RT60.2 26.99,34.57 v1(27.43,34.57) ; U19.L1 16.31,33.47 15.66,33.47 v8(15.42,33.72) ; v1(8.98,38.16) v1(8.98,37.73) v1(8.98,37.28) ; UD42.P8 93.06,23.95 v8(93.39,23.63) ; UD41.T5 109.88,21.55 v8(109.56,21.23) 109.23,21.55 UD41.R5 ; UD41.K2 105.98,18.21 v8(106.05,18.14) ; UZ5.5 124.7,39.82 v1(124.7,39.82) ; v1(10.03,63.77) v1(9.56,63.77) v1(9.16,63.77) ; v1(9.37,43.65) 9.63,43.38 v1(9.63,43.28) ; v1(9.37,43.65) v1(9.09,43.38) ; v1(9.37,43.65) v1(9.05,43.97) ; v1(11.8,63.99) 11.87,64.06 v1(11.87,64.42) 11.6,64.42 v1(11.46,64.27) ; UD41.C6 101.43,22.35 v8(101.11,22.03) 101.11,21.95 UD41.C5 ; UD42.M5 92.08,21.31 v8(92.08,21.22) 92.41,21.56 UD42.N5 ; v1(79.91,2.83) 79.56,2.48 U26.1 76.74,2.48 76.58,2.64 C1077.2 ; RE154.2 28.21,10.83 v1(28.49,10.55) ; UD43.T3 145.36,19.95 v8(145.04,19.63) 145.36,19.3 UD43.T2 ; 61.9,6.74 PR326.2 ; UD43.R4 144.71,20.75 v8(144.39,20.43) ; v8(94.68,21.24) 94.68,21.14 UD42.T4 ; v1(10.65,44.34) D27.2 10.36,44.64 v1(10.07,44.93) ; v1(13.26,65.17) 12.95,65.48 v1(12.95,65.5) ; v8(101.11,19.63) 100.78,19.3 UD41.B2 ; UD44.T5 129.79,21.54 129.47,21.22 v8(129.47,21.22) 129.14,21.54 UD44.R5 ; v1(9.54,41.03) v1(9.54,40.58) ; v1(9.54,41.03) v1(9.16,41.03) ; v1(9.54,41.03) v1(9.54,41.52) ; v8(87.86,27.89) 87.86,27.89 UD42.F12 ; v1(20.47,52.59) 20.49,52.57 20.98,52.57 RT33.1 ; UD43.C5 136.91,21.7 v8(136.59,22.03) 136.59,22.1 UD43.C6 ; UD43.M5 142.76,21.55 v8(142.44,21.23) 142.76,20.91 UD43.M4 ; UD42.D3 86.56,20.1 86.36,20.3 v8(86.24,20.43) 85.91,20.1 UD42.C3 ; R5761.2 34.98,38.91 34.53,39.37 33.46,39.37 v1(33.42,39.33) ; UD43.J4 141.14,20.5 v8(141.14,20.42) ; v8(110.21,27.63) 109.88,27.3 UD41.T12 ; UD41.T3 109.88,19.95 v8(109.56,19.63) 109.88,19.3 UD41.T2 ; v8(144.39,23.63) 144.06,23.95 UD43.P8 ; UC5.3 5.94,23.27 v1(6.29,23.62) ; v8(22.05,33.46) 22.04,33.45 21.62,33.45 U19.A1 ; UD43.B6 136.26,22.35 v8(135.94,22.03) 136.26,21.7 UD43.B5 ; UD43.C3 136.91,20.1 137.23,20.41 v8(137.24,20.41) 137.25,20.41 137.37,20.3 137.56,20.1 UD43.D3 ; UD43.G3 139.51,20.1 v8(139.19,20.43) 139.51,20.75 UD43.G4 ; PC335.1 v1(59.24,14.02) ; v1(10.23,61.11) 9.94,60.83 v1(9.94,60.83) v1(10.26,60.51) ; UD43.R6 144.71,22.35 v8(145.04,22.03) 145.36,22.35 UD43.T6 ; v1(8.59,56.6) 8.52,56.66 D45.2 v1(8.17,56.15) ; UD41.E4 102.73,20.9 v8(103.06,21.23) 103.38,20.9 UD41.F4 ; UD41.D12 102.03,27.23 101.6,27.65 101.6,28.43 100.91,29.12 CD17.2 ; UD42.C6 85.59,22.1 v8(85.59,22.03) 85.91,21.7 UD42.C5 ; UD41.B6 100.78,22.35 v8(100.46,22.03) 100.46,21.95 UD41.B5 ; R63.2 276.54,24.72 276.74,24.52 277.71,24.52 277.71,24.53 ; RE282.2 v1(11.94,26.8) ; v8(107.61,20.43) 107.28,20.75 UD41.M4 106.95,21.15 v8(106.95,21.24) 107.28,21.57 UD41.M5 107.16,21.74 107.16,21.89 UD41.L6 ; UD43.D12 137.56,27.26 137.41,27.41 v8(137.14,27.68) ; UD43.L6 142.11,22.35 v8(142.44,22.03) 142.76,22.35 UD43.M6 ; v1(12.58,65.85) 12.93,65.5 v1(12.95,65.5) ; v1(12.95,65.5) v1(13.23,65.78) ; R213.2 24.83,35.77 v1(24.49,35.43) ; UD44.T2 129.79,19.29 v8(129.47,19.61) 129.79,19.94 UD44.T3 ; v8(119.82,51.12) 119.82,51.15 119.84,51.17 CC55.2 ; v8(125.62,18.65) 125.62,18.8 125.89,19.08 UD44.K2 ; v1(11.63,46.92) 11.31,47.24 D33.2 11.31,47.24 v1(11.02,47.54) ; UD43.N6 143.41,22.35 v8(143.74,22.03) ; v8(108.26,20.43) 108.58,20.1 UD41.P3 ; UD43.N5 143.41,21.55 v8(143.74,21.23) ; v8(101.67,23.58) 102.08,23.99 UD41.D8 ; v8(126.54,51.98) CC78.2 ; v1(52.72,9.81) 52.22,9.31 52.22,7.88 51.15,6.81 48.33,6.81 47.82,6.29 PR177.2 ; v1(10.43,47.7) 10.16,47.43 D39.2 10.16,47.41 v1(10.48,47.09) ; UD43.J12 140.81,27.68 v8(140.9,27.76) ; UD41.M12 107.28,27.53 v8(107.11,27.7) ; v1(9.56,61.84) v1(9.56,62.25) v1(9.17,62.25) ; JXDP1.19 v1(47.68,71.94) ; UD43.B12 136.26,27.3 v8(135.94,27.63) ; UD44.R6 129.14,22.35 v8(129.47,22.03) 129.79,22.35 UD44.T6 ; UD41.R4 109.23,20.89 v8(108.91,21.21) ; UD44.M5 126.87,21.95 v8(126.87,22.03) 126.54,22.35 UD44.L6 ; v8(89.16,18.7) UD42.H2 ; v1(8.89,46.16) v1(9.17,46.44) v1(9.48,46.13) ; UD42.T12 94.36,27.3 94.36,27.3 v8(94.69,27.63) ; UD43.T4 145.36,20.74 v8(145.05,20.43) ; v1(8.85,56.98) 8.85,57.03 v1(8.53,57.35)
  TOP w0.305: CC37.2 124.03,44.49 124.89,43.63 RC11.2 ; CC53.2 119.77,51.08 v8(119.82,51.12) ; UD42.G8 88.51,23.52 v8(88.62,23.41) ; CC54.2 113.49,49.62 v8(113.41,49.54) ; CD30.2 134.19,25.72 v8(134.99,26.52) ; CC57.2 128.6,52.49 128.47,52.36 v8(128.47,51.98) ; v8(266.79,0.5) 267.12,0.83 CA66.1 ; JXDP1.59 35.68,72.57 v8(35.43,72.32) ; v8(273.17,27.78) 273.17,29 273.05,29.12 R5812.2 ; v8(92.09,22.01) 92.09,22.09 UD42.M6 ; v8(45.68,69.07) 45.68,69.15 45.58,69.25 JXDP1.26 ; PC1284.2 105.82,49.91 v8(106.11,49.62) ; v8(128.72,23.37) 128.72,23.45 128.49,23.67 UD44.P8 ; v8(49.18,69.09) JXDP1.14 ; v8(122.37,60.82) 122.51,60.95 PC1328.2 ; v8(121.56,51.21) 121.65,51.12 121.65,51.12 122.02,50.75 CC56.2 ; JXDP1.38 41.98,70.49 42.28,70.79 v8(42.28,71.97) JXDP1.37 ; v8(47.55,69.06) 47.38,69.23 JXDP1.20 ; v8(104.13,17.57) 104.23,17.67 104.24,17.67 104.55,17.97 104.55,19.09 UD41.H2 ; JXDP1.13 v1(49.48,72.19) ; v8(86.21,23.57) 86.21,23.67 UD42.D8 ; JUSBC3.A1 290.46,47.55 JUSBC3.B12 ; PD105.1 v1(101.35,11.45) ; v8(105.65,21.25) 105.65,21.15 UD41.J4 ; v8(44.08,71.95) JXDP1.31 ; JXDP1.32 43.78,69.22 v8(43.84,69.16) ; JXDP1.25 v8(45.88,72.03) ; JXDP1.50 v8(38.38,69.26)
  TOP w0.32: v8(147.55,27.18) 147.65,27.08 147.65,26.96 147.93,26.68 CD12.2 ; v8(112.3,45.34) 112.82,45.86 CC49.2 ; CC48.2 121.1,45.53 121.54,45.53 121.73,45.34 v8(122.24,45.34) 122.76,45.86 CC50.2 ; CC44.2 117.1,45.5 v8(117.26,45.34)
  TOP w0.33: PC1261.2 118.39,50.85 118.06,51.18 v8(117.99,51.18)
  TOP w0.356: CE56.2 13.27,19.55 v8(13.51,19.55) ; v8(108.79,51.25) 108.69,51.15 PC1343.2 108.7,50.72 PC1363.2 ; PC1261.2 118.38,50.62 PC1262.2 ; PC1323.2 121.27,61.42 120.9,61.05 v8(120.75,61.05) ; PC1305.2 116.55,50.62 PC1304.2 116.54,50.79 v8(116.16,51.17) ; PC1285.2 107.05,51.29 v8(107.01,51.33) ; CC30.2 125.39,51.46 CC77.2 125.93,51.86 v8(125.79,52) ; v8(105.2,51.26) 104.72,50.77 PC1286.2 ; PC1297.2 119.15,50.15 119.51,50.51 CC53.2 ; CC54.2 113.45,50.09 PC1287.2
  TOP w0.381: C141.2 15.56,36.04 v1(15.13,36.04) ; CD68.2 132.49,26.73 CD10.2 ; CC58.2 129.12,56.61 v8(129.12,57.01) ; RC47.2 137.04,54.89 136.29,55.63 v8(135.19,55.63) ; v8(108.82,49.58) 108.7,49.7 PC1363.2 ; CD48.2 CD59.2 96.65,27.24 v8(95.68,27.24) ; v8(129.81,49.63) 129.57,49.88 CC75.2 ; v8(271.97,29.73) 271.59,30.11 R5803.2 ; CD9.2 148.17,21.49 147.5,21.49 147.47,21.46 v8(146.95,21.46) ; v8(127.15,57.82) 127.15,58.03 CC64.2 ; v8(130.69,55.47) 130.69,55.8 131.17,56.27 CC59.2 ; v8(127.85,56.15) 127.7,56 CC67.2 ; v1(124.91,52.54) 124.87,52.58 PC1321.2 125.56,54.51 v8(125.85,54.51) 125.88,54.54 CC68.2 ; v1(17.72,35.68) 17.43,35.97 R186.1 ; PC1342.2 110.46,50.18 PC1364.2 111.03,50.17 PC1365.2 111.62,50.15 PC1341.2 111.63,49.62 v8(111.64,49.62) ; v8(125.12,59.64) 125.57,59.64 125.86,59.93 125.86,60.51 126.42,61.07 RC164.2 ; PC1366.2 112.2,49.84 v8(112.5,49.54) ; v8(98.63,21.71) 98.63,22.26 98.3,22.59 CD41.2 ; v8(136.12,50.32) 136.68,50.32 137.06,49.94 CC65.2 ; v1(128.7,54.45) 129.12,54.87 v8(129.12,55.34) ; CC71.2 131.37,59.09 v8(132.06,59.78) 131.73,60.11 RC2.1 ; CC79.2 125.6,57.75 126.49,58.63 v8(126.49,58.66) ; C97.2 257.63,7.96 258.12,8.44 258.12,11.13 v1(258.26,11.27) ; v8(134.62,24.35) 134.34,24.63 133.63,24.63 CD73.2 132.61,24.75 CD74.2 ; v8(269.39,29.77) 269.37,29.75 269.07,29.75 R5805.2 ; CA67.2 268.06,1.63 v8(268.06,0.5) ; v8(134.82,22.87) 134.59,23.1 133.47,23.1 RD8.2 133.26,22.89 132.75,22.89 CD1.2 ; v8(98.65,19.42) 98.47,19.24 CD45.2
  TOP w0.457: PC131.2 35.98,3.19 35.47,2.69 35.47,0.67 v8(35.65,0.5) ; v8(278.63,59.91) 278.43,60.1 CA18.2 ; v8(123.92,29.52) 124.33,29.93 CD77.2 ; CC29.2 124.3,65.5 124.84,64.95 v8(124.84,64.76)
  TOP w0.508: PC1312.2 126.3,58.85 v8(126.49,58.66) ; RE260.2 9.88,9.82 v8(9.82,9.89) ; CC96.2 126.42,65.34 CC28.2 127.28,64.81 127.13,64.66 127.13,63.72 v8(127.13,63.72) ; v8(87.17,29.64) 87.5,29.97 CD61.2 CD31.2 ; CC74.2 126.7,52.82 CC78.2 ; PC514.2 45.48,28.12 v8(45.68,28.32) ; RC121.1 93.69,67.52 93.07,66.9 v1(93.07,66.63) ; v8(138.11,52.97) 138.11,52.6 RC49.2 ; v8(91.73,29.32) 92.25,29.32 92.76,29.83 CD63.2 92.88,30.46 CD15.2 ; PC131.2 37.92,3.19 PR153.2 ; v8(122.23,29.6) 122.17,29.66 CD20.2 ; CD53.2 117.9,24.11 115.96,26.04 v8(114.74,26.04) ; v1(120.83,39.98) 120.51,39.66 CZ7.2 ; CC33.2 120.57,40.79 v1(120.76,40.98) ; v8(127.16,42.64) 127.14,42.64 127.05,42.74 127.05,42.8 126.77,43.08 RC13.2 ; PC1417.2 162.63,70.3 v8(162.64,70.29) ; v8(125.12,59.64) 124.88,59.88 CC31.2 ; CE63.2 11.66,12.34 12.06,11.95 v8(12.06,11.83) 12.55,12.32 RE164.2 ; v8(149.06,24.49) 148.92,24.63 148.77,24.77 148.46,24.77 CD66.2 ; v8(134.41,62.43) 134.36,62.43 133.53,61.6 133.53,61.43 ; RC11.2 RC12.2 RC13.2 ; v8(139.01,27.78) 139.12,27.88 139.12,28.2 139.9,28.98 CD75.2 ; v8(83.92,28.99) 83.92,29.64 CD22.2 82.21,29.5 CD51.2 ; v8(16.32,4.55) 16.66,4.21 17.03,4.21 17.52,4.7 CE52.2 ; CD8.2 118.07,29.67 CD52.2 117.35,29.5 115.3,27.44 v8(114.75,27.44) ; v8(119.2,22.9) 118.17,21.86 CD40.2 ; CT98.2 35.88,37.03 v8(36.9,37.03) ; v8(113.78,16.42) 113.6,16.6 CD46.2 ; v8(119.73,45.34) 119.79,45.28 CC36.2 CC45.2 ; v8(104.81,31.63) 104.31,31.63 103.78,31.1 103.78,30.7 104.14,30.34 CD35.2 ; v8(138.47,45.96) RH54.1 RH52.1 ; CD24.2 120.01,29.53 120.22,29.33 v8(120.22,29.34) ; PC1508.2 56.72,35.37 v8(56.72,35.37) ; RC151.2 121.96,66.07 122.33,65.7 124.26,65.7 CC29.2 ; CC38.2 114.48,44.06 CC35.2 115.47,44.64 v8(114.78,45.34) ; CC76.2 131.6,45.89 131.6,46.2 v8(131.76,46.36) ; C74.2 47.21,58.38 v1(47.03,58.55) ; v8(114.34,28.83) 114.49,28.98 114.49,30.59 113.91,31.17 CD13.2 113.46,31.12 CD54.2 ; CD29.2 80.58,23.1 v8(80.23,23.45) ; v8(134.94,16.27) 134.96,16.25 RD6.2 ; PC1513.2 67.93,35.9 v8(68.06,35.77) ; RC92.2 129.58,36.14 v8(129.91,35.8) ; CD47.2 80.92,21.27 81.28,20.92 CD42.2 RD3.2 81.16,19.55 80.92,19.31 v8(80.6,19.31) ; RD1.2 v8(80.63,17.76) ; v1(25.2,9.24) 25.2,8.54 25.62,8.12 CE66.2 ; CD37.2 89.41,29.99 v8(88.94,29.52) ; RC13.2 RC107.2 RC106.2 ; v8(116.31,19.54) 116.34,19.51 RD7.2 ; CD34.2 81.5,26.26 CD2.2 81.78,25.8 81.08,25.1 81.08,24.32 v8(80.68,23.92) ; CD107.2 136.96,16.45 v8(136.86,16.55) ; v8(141.51,31.22) 141.51,30.6 CD39.2 ; CD68.2 134.29,27.75 v8(135.08,28.54) 136.65,30.11 CD33.2 CD71.2 ; v8(124.74,45.33) 124.39,45.33 123.98,44.92 CC37.2 ; v8(108.5,13.27) 109.03,13.8 CD102.2 109.74,14.6 CD76.2 ; CD56.2 112.67,23.58 CD50.2 113.53,24.17 114.14,24.78 v8(114.76,24.78) ; v8(106.57,32.01) 106.55,31.99 CD25.2 ; CC73.2 CC72.2 129.99,45.03 129.77,45.25 v8(129.6,45.25) ; CD60.2 v8(80.57,18.65) ; RC9.2 129.92,65.13 v8(129.57,64.78) ; v8(16.56,25.33) 16.56,25.93 C148.2 ; v8(96.08,24.91) 96.36,24.63 CD18.2 CD64.2 ; v8(276.66,63.85) 276.4,63.58 CA27.1 ; v8(8.55,10.88) 8.28,11.15 QE10.3 ; CD4.2 115.28,18.28 114.58,18.97 v8(114.24,18.97) ; v8(101.98,29.02) 102.13,29.17 CD23.2 CD17.2 ; CD26.2 128.93,30.34 CD72.2 129.05,30.05 v8(129.45,29.66) ; v1(287.86,15.37) 287.45,15.78 R5796.1 ; R17.2 277.56,62.78 v8(278.63,63.85) ; CC43.2 112.17,45.2 v8(112.3,45.34) ; v1(102.03,12.86) 101.74,13.15 CD103.2 ; v8(114.15,20.71) 113.65,20.21 CD44.2 112.94,19.81 112.82,19.69 CD28.2 ; v8(115.77,20.09) 115.61,19.93 115.61,19.13 116.12,18.63 RD5.2 ; CD27.2 CD58.2 96.45,28.94 v8(96.04,29.36) 96.55,29.86 CD69.2 ; v1(267.07,16.11) 267.07,14.99 RA38.2 ; 133.53,61.43 RC4.1 ; 133.53,61.43 RC6.1 ; RC116.2 CC59.2 ; CD19.2 108.9,30.34 109.03,30.46 CD43.2 109.52,29.8 v8(110.21,29.11) ; v8(147.52,28.48) 148.27,28.48 CD67.2 ; v1(141.39,46.11) RH70.2 ; v8(129.96,61.87) 129.72,61.62 CC80.2 ; CD21.2 132.02,29.16 v8(129.97,29.16) ; CE86.2 RE160.2 ; PC524.2 v8(40.16,30.58)
  IN1 w0.254: v7(22.85,6.86) 22.19,6.86 v9(21.5,6.18)
  GND1 w0.203: JUSBC3.1 295.79,44.97 ; JUSBC3.1 295.79,45.7 ; JUSBC3.1 293.03,45.7 ; JUSBC3.1 293.03,46.43 ; JUSBC3.1 293.03,44.97 ; JUSBC3.1 295.79,46.43 ; JUSBC3.1 294.26,44.97 ; JUSBC3.1 294.26,46.43 ; 5.38,60.08 JUSBC2.6 ; JUSBC2.6 6.1,60.08 ; JUSBC2.6 6.82,58.07 ; JUSBC2.6 5.38,58.07 ; JUSBC2.6 6.82,60.08 ; JUSBC2.6 6.1,58.07 ; 290.03,47.5 JUSBC3.B12 ; JUSBC3.B12 290.9,47.11 ; JUSBC3.B12 290.12,47.89 ; JUSBC3.B12 290.51,47.98 ; JCR1.11 284.49,39.14 ; JCR1.11 282.23,39.14 ; JCR1.11 283.36,39.86 ; JCR1.11 283.36,38.42 ; JCR1.11 284.49,38.42 ; JCR1.11 282.23,39.86 ; JCR1.13 293.89,26.26 ; JCR1.13 292.76,24.82 ; JCR1.13 292.76,26.26 ; JCR1.13 291.63,26.26 ; JCR1.13 293.89,24.82 ; JCR1.13 293.89,25.54 ; JCR1.13 291.63,25.54 ; H3.1 90.25,69.37 ; H3.1 90.81,67.85 ; H3.1 87.21,69.37 ; H3.1 88.73,65.77 ; H3.1 90.25,66.33 ; H3.1 87.21,66.33 ; H3.1 86.65,67.85 ; H3.1 88.73,69.93 ; 5.38,67.17 JUSBC2.5 ; JUSBC2.5 6.82,68.27 ; JUSBC2.5 5.38,68.27 ; JUSBC2.5 6.82,66.26 ; JUSBC2.5 6.1,66.26 ; JUSBC2.5 6.1,68.27 ; JUSBC2.5 5.38,66.26 ; H4.1 90.25,41.23 ; H4.1 90.25,44.27 ; H4.1 88.73,44.83 ; H4.1 87.21,44.27 ; H4.1 87.21,41.23 ; H4.1 90.81,42.75 ; H4.1 86.65,42.75 ; H4.1 88.73,40.67 ; H9.1 219.92,19.81 ; H9.1 216.92,21.09 ; H9.1 216.46,19.81 ; H9.1 219.46,21.09 ; H9.1 218.19,18.09 ; H9.1 219.46,18.54 ; H9.1 218.19,21.54 ; H9.1 216.92,18.54 ; JUSBC1.6 6.82,41.62 ; JUSBC1.6 6.82,43.63 ; JUSBC1.6 6.1,43.63 ; JUSBC1.6 5.38,43.63 ; JUSBC1.6 5.38,41.62 ; JUSBC1.6 6.1,41.62 ; 293.03,54.17 JUSBC3.4 ; JUSBC3.4 295.79,55.63 ; JUSBC3.4 295.79,54.9 ; JUSBC3.4 293.03,55.63 ; JUSBC3.4 294.26,54.17 ; JUSBC3.4 294.26,55.63 ; JUSBC3.4 295.79,54.17 ; JUSBC3.4 293.03,54.9 ; H17.1 295.55,22.2 ; H17.1 295.18,21.13 ; H17.1 293.04,21.13 ; H17.1 295.18,23.27 ; H17.1 294.11,23.64 ; H17.1 292.67,22.2 ; H17.1 293.04,23.27 ; H17.1 294.11,20.76 ; JCR1.12 293.89,39.14 ; JCR1.12 293.89,38.42 ; JCR1.12 292.76,38.42 ; JCR1.12 291.63,38.42 ; JCR1.12 293.89,39.86 ; JCR1.12 292.76,39.86 ; JCR1.12 291.63,39.86 ; JCR1.12 291.63,39.14 ; H21.1 3.93,56.38 ; H21.1 5,53.87 ; H21.1 2.86,53.87 ; H21.1 3.93,53.5 ; H21.1 2.86,56.01 ; H21.1 5.37,54.94 ; H21.1 2.49,54.94 ; H21.1 5,56.01 ; 2.88,34.78 SW2.3 ; SW2.3 3.43,34.63 ; SW2.3 3.43,36.02 ; SW2.3 2.88,35.87 ; SW2.3 4.13,35.33 ; SW2.3 3.97,34.78 ; SW2.3 3.97,35.87 ; 290.03,45.7 JUSBC3.2 ; JUSBC3.2 291.26,46.43 ; JUSBC3.2 292.49,45.7 ; JUSBC3.2 291.26,44.98 ; JUSBC3.2 292.49,44.98 ; JUSBC3.2 292.49,46.43 ; 145.73,40.67 H6.1 ; H6.1 147.25,41.23 ; H6.1 144.21,44.27 ; H6.1 145.73,44.83 ; H6.1 147.25,44.27 ; H6.1 144.21,41.23 ; H6.1 147.81,42.75 ; H6.1 143.65,42.75 ; H23.1 293.38,43.59 ; H23.1 292.31,41.08 ; H23.1 291.94,42.15 ; H23.1 294.45,43.22 ; H23.1 293.38,40.71 ; H23.1 294.45,41.08 ; H23.1 294.82,42.15 ; H23.1 292.31,43.22 ; H2.1 59.15,60.9 ; H2.1 59.71,62.42 ; H2.1 56.11,60.9 ; H2.1 57.63,60.34 ; H2.1 55.55,62.42 ; H2.1 59.15,63.94 ; H2.1 57.63,64.5 ; H2.1 56.11,63.94 ; 76.76,24.87 H7.1 ; H7.1 78.28,25.43 ; H7.1 75.24,25.43 ; H7.1 74.68,26.95 ; H7.1 78.84,26.95 ; H7.1 75.24,28.47 ; H7.1 78.28,28.47 ; H7.1 76.76,29.03 ; JUSBC1.3 8.03,42.4 ; JUSBC1.3 5.37,42.4 ; JUSBC1.3 6.7,41.62 ; JUSBC1.3 8.03,43.17 ; JUSBC1.3 8.03,41.62 ; JUSBC1.3 5.37,41.62 ; JUSBC2.4 3.13,58.02 ; JUSBC2.4 3.13,58.85 ; JUSBC2.4 1.65,58.02 ; JUSBC2.4 1.65,59.68 ; JUSBC2.4 3.13,59.68 ; 1.56,72.47 H11.1 ; H11.1 3.7,72.47 ; H11.1 4.07,71.4 ; H11.1 2.63,72.84 ; H11.1 1.19,71.4 ; H11.1 2.63,69.96 ; H11.1 3.7,70.33 ; H11.1 1.56,70.33 ; 145.73,65.77 H5.1 ; H5.1 147.25,69.37 ; H5.1 144.21,69.37 ; H5.1 147.25,66.33 ; H5.1 144.21,66.33 ; H5.1 143.65,67.85 ; H5.1 145.73,69.93 ; H5.1 147.81,67.85 ; 214.24,7.05 H20.1 ; H20.1 214.24,9.71 ; H20.1 213.25,9.37 ; H20.1 213.25,7.39 ; H20.1 215.23,7.39 ; H20.1 215.57,8.38 ; H20.1 215.23,9.37 ; H20.1 212.91,8.38 ; H12.1 3.43,40.29 ; H12.1 4.87,38.85 ; H12.1 4.5,39.92 ; H12.1 2.36,37.78 ; H12.1 4.5,37.78 ; H12.1 1.99,38.85 ; H12.1 2.36,39.92 ; H12.1 3.43,37.41 ; H8.1 170.85,49.07 ; H8.1 168.31,46.53 ; H8.1 171.31,47.8 ; H8.1 168.31,49.07 ; H8.1 167.85,47.8 ; H8.1 170.85,46.53 ; H8.1 169.58,49.53 ; H8.1 169.58,46.07 ; JUSBC1.4 1.65,43.23 ; JUSBC1.4 3.13,41.57 ; JUSBC1.4 3.13,42.4 ; JUSBC1.4 1.65,41.57 ; JUSBC1.4 3.13,43.23 ; 2.61,7.73 H13.1 ; H13.1 4.75,7.73 ; H13.1 5.12,8.8 ; H13.1 2.24,8.8 ; H13.1 3.68,10.24 ; H13.1 3.68,7.36 ; H13.1 4.75,9.87 ; H13.1 2.61,9.87 ; 282.23,25.54 JCR1.10 ; JCR1.10 282.23,26.26 ; JCR1.10 283.36,26.26 ; JCR1.10 284.49,26.26 ; JCR1.10 284.49,24.82 ; JCR1.10 284.49,25.54 ; JCR1.10 283.36,24.82 ; JCR1.10 282.23,24.82 ; H1.1 24.62,66 ; H1.1 23.1,65.44 ; H1.1 22.54,63.92 ; H1.1 24.62,61.84 ; H1.1 26.15,62.4 ; H1.1 23.1,62.4 ; H1.1 26.15,65.44 ; H1.1 26.71,63.92 ; 5.37,68.27 JUSBC2.2 ; JUSBC2.2 8.03,66.72 ; JUSBC2.2 5.37,67.49 ; JUSBC2.2 6.7,68.27 ; JUSBC2.2 8.03,68.27 ; JUSBC2.2 8.03,67.49 ; 5.37,58.08 JUSBC2.3 ; JUSBC2.3 8.03,59.63 ; JUSBC2.3 8.03,58.85 ; JUSBC2.3 6.7,58.08 ; JUSBC2.3 5.37,58.85 ; JUSBC2.3 8.03,58.08 ; 6.1,49.81 JUSBC1.5 ; JUSBC1.5 5.38,50.71 ; JUSBC1.5 5.38,49.81 ; JUSBC1.5 6.1,51.82 ; JUSBC1.5 5.38,51.82 ; JUSBC1.5 6.82,51.82 ; JUSBC1.5 6.82,49.81 ; JUSBC1.2 8.03,50.26 ; JUSBC1.2 8.03,51.04 ; JUSBC1.2 6.7,51.81 ; JUSBC1.2 5.37,51.04 ; JUSBC1.2 8.03,51.81 ; JUSBC1.2 5.37,51.81 ; SW2.4 3.43,31.97 ; SW2.4 2.88,30.73 ; SW2.4 4.13,31.28 ; SW2.4 3.43,30.58 ; SW2.4 2.88,31.82 ; SW2.4 3.97,31.82 ; SW2.4 3.97,30.73 ; JUSBC3.3 292.49,54.18 ; JUSBC3.3 292.49,54.9 ; JUSBC3.3 292.49,55.63 ; JUSBC3.3 290.03,54.9 ; JUSBC3.3 291.26,55.63 ; JUSBC3.3 290.03,55.63 ; JUSBC3.3 291.26,54.18 ; JUSBC1.1 3.13,51.87 ; JUSBC1.1 1.65,51.87 ; JUSBC1.1 1.65,50.21 ; JUSBC1.1 3.13,51.04 ; JUSBC1.1 3.13,50.21 ; H16.1 294.63,59.69 ; H16.1 293.56,57.18 ; H16.1 295.7,57.18 ; H16.1 296.07,58.25 ; H16.1 293.19,58.25 ; H16.1 294.63,56.81 ; H16.1 295.7,59.32 ; H16.1 293.56,59.32 ; JUSBC2.1 3.13,68.32 ; JUSBC2.1 3.13,66.66 ; JUSBC2.1 1.65,66.66 ; JUSBC2.1 3.13,67.49 ; JUSBC2.1 1.65,68.32 ; JUSBC3.B1 290.9,53.49 ; JUSBC3.B1 290.12,52.71 ; JUSBC3.B1 290.51,52.62
  GND1 w0.254: v3(128.4,54.08) 128.7,54.38 v1(128.7,54.45) ; v3(109.91,62.43) 110.41,61.93 v1(110.82,61.93) ; v1(35.65,42.04) 35.94,42.04 36.4,42.51 v3(36.54,42.51) ; v1(40.63,17.57) 40.63,17.7 v3(40.86,17.94) 40.86,17.89 41.07,17.68 v1(41.07,17.57) ; v3(69.32,5.6) 69.32,5.28 69.35,5.25 v1(69.35,5.25) ; v1(263.84,17.34) 263.84,16.94 263.9,16.88 v3(263.9,16.71)
  GND1 w0.508: v3(30.32,6.27) 30.1,6.05 29.64,6.05 v1(29.63,6.04)
  GND2 w0.203: 1.99,38.85 H12.1 ; H12.1 4.5,37.78 ; H12.1 3.43,37.41 ; H12.1 3.43,40.29 ; H12.1 2.36,37.78 ; H12.1 4.87,38.85 ; H12.1 4.5,39.92 ; H12.1 2.36,39.92 ; 293.03,54.9 JUSBC3.4 ; JUSBC3.4 295.79,54.17 ; JUSBC3.4 295.79,54.9 ; JUSBC3.4 295.79,55.63 ; JUSBC3.4 293.03,55.63 ; JUSBC3.4 294.26,54.17 ; JUSBC3.4 294.26,55.63 ; JUSBC3.4 293.03,54.17 ; H11.1 4.07,71.4 ; H11.1 1.19,71.4 ; H11.1 3.7,72.47 ; H11.1 3.7,70.33 ; H11.1 2.63,69.96 ; H11.1 1.56,72.47 ; H11.1 2.63,72.84 ; H11.1 1.56,70.33 ; H16.1 294.63,59.69 ; H16.1 293.19,58.25 ; H16.1 293.56,59.32 ; H16.1 296.07,58.25 ; H16.1 294.63,56.81 ; H16.1 295.7,57.18 ; H16.1 293.56,57.18 ; H16.1 295.7,59.32 ; 5.37,41.62 JUSBC1.3 ; JUSBC1.3 8.03,42.4 ; JUSBC1.3 6.7,41.62 ; JUSBC1.3 5.37,42.4 ; JUSBC1.3 8.03,43.17 ; JUSBC1.3 8.03,41.62 ; 291.63,25.54 JCR1.13 ; JCR1.13 293.89,24.82 ; JCR1.13 291.63,26.26 ; JCR1.13 293.89,26.26 ; JCR1.13 292.76,26.26 ; JCR1.13 293.89,25.54 ; JCR1.13 292.76,24.82 ; 213.25,9.37 H20.1 ; H20.1 213.25,7.39 ; H20.1 212.91,8.38 ; H20.1 215.23,9.37 ; H20.1 214.24,9.71 ; H20.1 215.57,8.38 ; H20.1 215.23,7.39 ; H20.1 214.24,7.05 ; 144.21,66.33 H5.1 ; H5.1 144.21,69.37 ; H5.1 147.25,69.37 ; H5.1 145.73,69.93 ; H5.1 143.65,67.85 ; H5.1 145.73,65.77 ; H5.1 147.25,66.33 ; H5.1 147.81,67.85 ; H4.1 90.81,42.75 ; H4.1 90.25,41.23 ; H4.1 88.73,40.67 ; H4.1 88.73,44.83 ; H4.1 87.21,44.27 ; H4.1 86.65,42.75 ; H4.1 90.25,44.27 ; H4.1 87.21,41.23 ; JUSBC1.1 3.13,50.21 ; JUSBC1.1 1.65,51.87 ; JUSBC1.1 3.13,51.04 ; JUSBC1.1 1.65,50.21 ; JUSBC1.1 3.13,51.87 ; 5.38,51.82 JUSBC1.5 ; JUSBC1.5 6.82,51.82 ; JUSBC1.5 5.38,50.71 ; JUSBC1.5 6.82,49.81 ; JUSBC1.5 6.1,51.82 ; JUSBC1.5 6.1,49.81 ; JUSBC1.5 5.38,49.81 ; H1.1 24.62,66 ; H1.1 23.1,65.44 ; H1.1 24.62,61.84 ; H1.1 26.15,65.44 ; H1.1 26.71,63.92 ; H1.1 23.1,62.4 ; H1.1 26.15,62.4 ; H1.1 22.54,63.92 ; 268.68,34.48 H10.1 ; H10.1 271.68,35.75 ; H10.1 269.95,37.48 ; H10.1 269.95,34.02 ; H10.1 268.68,37.02 ; H10.1 271.22,37.02 ; H10.1 271.22,34.48 ; H10.1 268.22,35.75 ; SW2.3 4.13,35.33 ; SW2.3 2.88,34.78 ; SW2.3 3.97,34.78 ; SW2.3 3.43,36.02 ; SW2.3 3.43,34.63 ; SW2.3 2.88,35.87 ; SW2.3 3.97,35.87 ; 5.38,66.26 JUSBC2.5 ; JUSBC2.5 6.82,66.26 ; JUSBC2.5 6.1,68.27 ; JUSBC2.5 6.1,66.26 ; JUSBC2.5 6.82,68.27 ; JUSBC2.5 5.38,68.27 ; JUSBC2.5 5.38,67.17 ; JUSBC3.B12 290.9,47.11 ; JUSBC3.B12 290.51,47.98 ; JUSBC3.B12 290.12,47.89 ; JUSBC3.B12 290.03,47.5 ; H23.1 294.82,42.15 ; H23.1 294.45,43.22 ; H23.1 294.45,41.08 ; H23.1 292.31,43.22 ; H23.1 293.38,43.59 ; H23.1 292.31,41.08 ; H23.1 293.38,40.71 ; H23.1 291.94,42.15 ; H2.1 59.15,60.9 ; H2.1 56.11,63.94 ; H2.1 59.71,62.42 ; H2.1 59.15,63.94 ; H2.1 57.63,60.34 ; H2.1 55.55,62.42 ; H2.1 56.11,60.9 ; H2.1 57.63,64.5 ; 292.76,38.42 JCR1.12 ; JCR1.12 293.89,39.86 ; JCR1.12 291.63,39.86 ; JCR1.12 292.76,39.86 ; JCR1.12 293.89,38.42 ; JCR1.12 291.63,38.42 ; JCR1.12 291.63,39.14 ; JCR1.12 293.89,39.14 ; JUSBC2.1 3.13,66.66 ; JUSBC2.1 3.13,67.49 ; JUSBC2.1 1.65,66.66 ; JUSBC2.1 3.13,68.32 ; JUSBC2.1 1.65,68.32 ; 5.38,41.62 JUSBC1.6 ; JUSBC1.6 6.1,41.62 ; JUSBC1.6 6.1,43.63 ; JUSBC1.6 6.82,43.63 ; JUSBC1.6 5.38,43.63 ; JUSBC1.6 6.82,41.62 ; 5.37,58.08 JUSBC2.3 ; JUSBC2.3 5.37,58.85 ; JUSBC2.3 6.7,58.08 ; JUSBC2.3 8.03,58.85 ; JUSBC2.3 8.03,58.08 ; JUSBC2.3 8.03,59.63 ; H9.1 218.19,21.54 ; H9.1 219.46,21.09 ; H9.1 219.92,19.81 ; H9.1 218.19,18.09 ; H9.1 216.92,21.09 ; H9.1 216.92,18.54 ; H9.1 219.46,18.54 ; H9.1 216.46,19.81 ; 87.21,69.37 H3.1 ; H3.1 86.65,67.85 ; H3.1 88.73,69.93 ; H3.1 90.81,67.85 ; H3.1 90.25,69.37 ; 5.38,58.07 JUSBC2.6 ; JUSBC2.6 6.82,58.07 ; JUSBC2.6 6.82,60.08 ; JUSBC2.6 6.1,60.08 ; JUSBC2.6 6.1,58.07 ; JUSBC2.6 5.38,60.08 ; 282.23,26.26 JCR1.10 ; JCR1.10 283.36,24.82 ; JCR1.10 284.49,24.82 ; JCR1.10 284.49,26.26 ; JCR1.10 284.49,25.54 ; JCR1.10 282.23,25.54 ; JCR1.10 282.23,24.82 ; JCR1.10 283.36,26.26 ; 75.24,25.43 H7.1 ; H7.1 75.24,28.47 ; H7.1 76.76,29.03 ; H7.1 78.28,28.47 ; H7.1 78.84,26.95 ; H7.1 74.68,26.95 ; H7.1 76.76,24.87 ; H7.1 78.28,25.43 ; 168.31,46.53 H8.1 ; H8.1 170.85,49.07 ; H8.1 169.58,46.07 ; H8.1 169.58,49.53 ; H8.1 168.31,49.07 ; H8.1 170.85,46.53 ; H8.1 171.31,47.8 ; H8.1 167.85,47.8 ; H6.1 147.81,42.75 ; H6.1 144.21,44.27 ; H6.1 145.73,44.83 ; H6.1 147.25,44.27 ; H6.1 144.21,41.23 ; H6.1 145.73,40.67 ; H6.1 147.25,41.23 ; H6.1 143.65,42.75 ; 147.57,5.44 H19.1 ; H19.1 148.56,5.78 ; H19.1 146.58,5.78 ; H19.1 148.56,7.76 ; H19.1 146.58,7.76 ; H19.1 148.9,6.77 ; H19.1 146.24,6.77 ; H19.1 147.57,8.1 ; JUSBC2.4 3.13,59.68 ; JUSBC2.4 1.65,58.02 ; JUSBC2.4 3.13,58.85 ; JUSBC2.4 1.65,59.68 ; JUSBC2.4 3.13,58.02 ; JUSBC1.2 8.03,51.04 ; JUSBC1.2 8.03,50.26 ; JUSBC1.2 5.37,51.04 ; JUSBC1.2 8.03,51.81 ; JUSBC1.2 6.7,51.81 ; JUSBC1.2 5.37,51.81 ; 283.36,38.42 JCR1.11 ; JCR1.11 282.23,39.86 ; JCR1.11 284.49,39.14 ; JCR1.11 283.36,39.86 ; JCR1.11 282.23,39.14 ; JCR1.11 284.49,38.42 ; H17.1 294.11,23.64 ; H17.1 295.18,21.13 ; H17.1 293.04,23.27 ; H17.1 292.67,22.2 ; H17.1 294.11,20.76 ; H17.1 293.04,21.13 ; H17.1 295.55,22.2 ; H17.1 295.18,23.27 ; JUSBC3.2 292.49,44.98 ; JUSBC3.2 291.26,46.43 ; JUSBC3.2 291.26,44.98 ; JUSBC3.2 292.49,46.43 ; JUSBC3.2 290.03,45.7 ; JUSBC3.2 292.49,45.7 ; H13.1 3.68,10.24 ; H13.1 3.68,7.36 ; H13.1 2.24,8.8 ; H13.1 4.75,7.73 ; H13.1 2.61,7.73 ; H13.1 4.75,9.87 ; H13.1 2.61,9.87 ; H13.1 5.12,8.8 ; JUSBC2.2 8.03,68.27 ; JUSBC2.2 6.7,68.27 ; JUSBC2.2 5.37,68.27 ; JUSBC2.2 8.03,66.72 ; JUSBC2.2 8.03,67.49 ; JUSBC2.2 5.37,67.49 ; JUSBC3.3 292.49,54.9 ; JUSBC3.3 292.49,54.18 ; JUSBC3.3 290.03,54.9 ; JUSBC3.3 292.49,55.63 ; JUSBC3.3 290.03,55.63 ; JUSBC3.3 291.26,55.63 ; JUSBC3.3 291.26,54.18 ; 3.43,30.58 SW2.4 ; SW2.4 4.13,31.28 ; SW2.4 2.88,30.73 ; SW2.4 3.43,31.97 ; SW2.4 3.97,31.82 ; SW2.4 3.97,30.73 ; SW2.4 2.88,31.82 ; JUSBC3.1 295.79,46.43 ; JUSBC3.1 293.03,45.7 ; JUSBC3.1 293.03,46.43 ; JUSBC3.1 294.26,44.97 ; JUSBC3.1 295.79,45.7 ; JUSBC3.1 293.03,44.97 ; JUSBC3.1 295.79,44.97 ; JUSBC3.1 294.26,46.43 ; JUSBC1.4 3.13,42.4 ; JUSBC1.4 1.65,43.23 ; JUSBC1.4 1.65,41.57 ; JUSBC1.4 3.13,43.23 ; JUSBC1.4 3.13,41.57 ; 290.12,52.71 JUSBC3.B1 ; JUSBC3.B1 290.9,53.49 ; JUSBC3.B1 290.51,52.62 ; H21.1 5.37,54.94 ; H21.1 2.49,54.94 ; H21.1 3.93,56.38 ; H21.1 3.93,53.5 ; H21.1 5,56.01 ; H21.1 5,53.87 ; H21.1 2.86,53.87 ; H21.1 2.86,56.01
  VCC w0.203: 1.65,58.02 JUSBC2.4 ; JUSBC2.4 2.39,58.02 ; JUSBC2.4 2.39,59.68 ; JUSBC3.2 291.26,46.43 ; JUSBC3.2 292.49,45.7 ; JUSBC3.2 292.49,44.98 ; JUSBC3.2 292.49,46.43 ; JUSBC3.2 291.26,44.98 ; 88.73,40.67 H4.1 ; H4.1 87.21,44.27 ; H4.1 90.81,42.75 ; H4.1 87.21,41.23 ; H4.1 86.65,42.75 ; H4.1 88.73,44.83 ; H4.1 90.25,44.27 ; H4.1 90.25,41.23 ; JUSBC1.1 1.65,51.87 ; JUSBC1.1 3.13,51.04 ; JUSBC1.1 3.13,51.87 ; 293.03,44.97 JUSBC3.1 ; JUSBC3.1 294.26,44.97 ; JUSBC3.1 293.03,46.43 ; JUSBC3.1 295.79,45.7 ; JUSBC3.1 294.26,46.43 ; JUSBC3.1 293.03,45.7 ; 290.03,47.5 JUSBC3.B12 ; JUSBC3.B12 290.51,47.98 ; JUSBC3.B12 290.12,47.89 ; JUSBC3.B12 290.9,47.11 ; H21.1 5,53.87 ; H21.1 3.93,56.38 ; H21.1 2.86,56.01 ; H21.1 3.93,53.5 ; H21.1 2.86,53.87 ; H21.1 5.37,54.94 ; H11.1 4.07,71.4 ; H11.1 1.56,70.33 ; H11.1 3.7,72.47 ; H11.1 3.7,70.33 ; H11.1 2.63,69.96 ; H11.1 1.56,72.47 ; JUSBC3.4 295.79,54.9 ; JUSBC3.4 294.26,54.17 ; JUSBC3.4 293.03,55.63 ; JUSBC3.4 294.26,55.63 ; JUSBC3.4 293.03,54.17 ; JUSBC3.4 293.03,54.9 ; JUSBC3.4 295.79,55.63 ; JUSBC2.5 6.82,66.26 ; JUSBC2.5 5.38,66.26 ; JUSBC2.5 5.38,67.17 ; JUSBC2.5 6.1,68.27 ; JUSBC2.5 5.38,68.27 ; JUSBC2.5 6.1,66.26 ; H6.1 147.81,42.75 ; H6.1 144.21,41.23 ; H6.1 144.21,44.27 ; H6.1 145.73,40.67 ; H6.1 143.65,42.75 ; H6.1 147.25,41.23 ; H6.1 147.25,44.27 ; 293.56,57.18 H16.1 ; H16.1 295.7,57.18 ; H16.1 293.19,58.25 ; H16.1 294.63,59.69 ; H16.1 293.56,59.32 ; H16.1 294.63,56.81 ; H16.1 295.7,59.32 ; 5.37,51.04 JUSBC1.2 ; JUSBC1.2 5.37,51.81 ; JUSBC1.2 8.03,51.81 ; JUSBC1.2 6.7,51.81 ; JUSBC1.2 8.03,51.04 ; JUSBC2.1 3.13,68.32 ; JUSBC2.1 3.13,66.66 ; JUSBC2.1 1.65,68.32 ; JUSBC2.1 3.13,67.49 ; H23.1 293.97,43.54 ; H23.1 292.79,43.54 ; H23.1 293.38,43.59 ; 291.26,54.18 JUSBC3.3 ; JUSBC3.3 291.26,55.63 ; JUSBC3.3 292.49,55.63 ; JUSBC3.3 292.49,54.9 ; JUSBC3.3 290.03,55.63 ; JUSBC3.3 292.49,54.18 ; JUSBC3.3 290.03,54.9 ; JUSBC1.5 6.82,51.82 ; JUSBC1.5 6.1,51.82 ; JUSBC1.5 5.38,50.71 ; JUSBC1.5 5.38,51.82 ; 290.51,52.62 JUSBC3.B1 ; JUSBC3.B1 290.12,52.71 ; JUSBC3.B1 290.9,53.49 ; 5.37,68.27 JUSBC2.2 ; JUSBC2.2 5.37,67.49 ; JUSBC2.2 8.03,67.49 ; JUSBC2.2 8.03,66.72 ; H1.1 26.71,63.92 ; H1.1 22.54,63.92 ; H1.1 23.1,65.44 ; H1.1 26.15,65.44 ; H1.1 24.62,66
  IN3 w0.305: v3(289.03,62.28) 289.41,61.9 v8(292.24,61.9)
  GND3 w0.203: H20.1 215.23,7.39 ; H20.1 214.24,9.71 ; H20.1 215.23,9.37 ; H20.1 213.25,7.39 ; H20.1 215.57,8.38 ; H20.1 212.91,8.38 ; H20.1 213.25,9.37 ; H20.1 214.24,7.05 ; H17.1 295.55,22.2 ; H17.1 293.04,23.27 ; H17.1 295.18,21.13 ; H17.1 295.18,23.27 ; H17.1 294.11,23.64 ; H17.1 294.11,20.76 ; H17.1 293.04,21.13 ; H17.1 292.67,22.2 ; 24.62,61.84 H1.1 ; H1.1 23.1,65.44 ; H1.1 26.15,65.44 ; H1.1 26.15,62.4 ; H1.1 26.71,63.92 ; H1.1 23.1,62.4 ; H1.1 24.62,66 ; H1.1 22.54,63.92 ; 268.68,37.02 H10.1 ; H10.1 271.68,35.75 ; H10.1 268.22,35.75 ; H10.1 269.95,34.02 ; H10.1 268.68,34.48 ; H10.1 271.22,34.48 ; H10.1 271.22,37.02 ; H10.1 269.95,37.48 ; JUSBC1.3 8.03,41.62 ; JUSBC1.3 5.37,42.4 ; JUSBC1.3 8.03,43.17 ; JUSBC1.3 6.7,41.62 ; JUSBC1.3 5.37,41.62 ; JUSBC1.3 8.03,42.4 ; H13.1 4.75,9.87 ; H13.1 2.61,9.87 ; H13.1 4.75,7.73 ; H13.1 2.61,7.73 ; H13.1 5.12,8.8 ; H13.1 2.24,8.8 ; H13.1 3.68,10.24 ; H13.1 3.68,7.36 ; H19.1 148.56,7.76 ; H19.1 146.24,6.77 ; H19.1 148.9,6.77 ; H19.1 146.58,5.78 ; H19.1 146.58,7.76 ; H19.1 147.57,8.1 ; H19.1 148.56,5.78 ; H19.1 147.57,5.44 ; 283.36,24.82 JCR1.10 ; JCR1.10 284.49,25.54 ; JCR1.10 284.49,24.82 ; JCR1.10 284.49,26.26 ; JCR1.10 282.23,24.82 ; JCR1.10 282.23,26.26 ; JCR1.10 282.23,25.54 ; JCR1.10 283.36,26.26 ; JCR1.12 293.89,39.86 ; JCR1.12 293.89,39.14 ; JCR1.12 292.76,38.42 ; JCR1.12 291.63,39.86 ; JCR1.12 291.63,39.14 ; JCR1.12 291.63,38.42 ; JCR1.12 292.76,39.86 ; JCR1.12 293.89,38.42 ; 291.26,54.18 JUSBC3.3 ; JUSBC3.3 292.49,54.18 ; JUSBC3.3 290.03,54.9 ; JUSBC3.3 292.49,54.9 ; JUSBC3.3 290.03,55.63 ; JUSBC3.3 291.26,55.63 ; JUSBC3.3 292.49,55.63 ; H4.1 90.25,41.23 ; H4.1 90.25,44.27 ; H4.1 88.73,40.67 ; H4.1 90.81,42.75 ; H4.1 87.21,44.27 ; H4.1 88.73,44.83 ; H4.1 87.21,41.23 ; H4.1 86.65,42.75 ; 5.37,67.49 JUSBC2.2 ; JUSBC2.2 8.03,67.49 ; JUSBC2.2 6.7,68.27 ; JUSBC2.2 8.03,66.72 ; JUSBC2.2 5.37,68.27 ; JUSBC2.2 8.03,68.27 ; 75.24,25.43 H7.1 ; H7.1 78.84,26.95 ; H7.1 78.28,25.43 ; H7.1 76.76,29.03 ; H7.1 75.24,28.47 ; H7.1 76.76,24.87 ; H7.1 74.68,26.95 ; H7.1 78.28,28.47 ; 1.56,72.47 H11.1 ; H11.1 1.19,71.4 ; H11.1 4.07,71.4 ; H11.1 1.56,70.33 ; H11.1 2.63,69.96 ; H11.1 3.7,70.33 ; H11.1 3.7,72.47 ; H11.1 2.63,72.84 ; 5.37,58.85 JUSBC2.3 ; JUSBC2.3 8.03,58.08 ; JUSBC2.3 8.03,58.85 ; JUSBC2.3 8.03,59.63 ; JUSBC2.3 6.7,58.08 ; JUSBC2.3 5.37,58.08 ; JUSBC2.6 6.82,60.08 ; JUSBC2.6 5.38,58.07 ; JUSBC2.6 6.1,60.08 ; JUSBC2.6 5.38,60.08 ; JUSBC2.6 6.82,58.07 ; JUSBC2.6 6.1,58.07 ; H12.1 3.43,40.29 ; H12.1 2.36,39.92 ; H12.1 2.36,37.78 ; H12.1 4.5,39.92 ; H12.1 4.5,37.78 ; H12.1 4.87,38.85 ; H12.1 1.99,38.85 ; H12.1 3.43,37.41 ; H9.1 219.46,21.09 ; H9.1 218.19,21.54 ; H9.1 216.92,18.54 ; H9.1 219.46,18.54 ; H9.1 216.92,21.09 ; H9.1 216.46,19.81 ; H9.1 218.19,18.09 ; H9.1 219.92,19.81 ; JUSBC1.1 3.13,51.87 ; JUSBC1.1 1.65,51.87 ; JUSBC1.1 3.13,51.04 ; JUSBC1.1 3.13,50.21 ; JUSBC1.1 1.65,50.21 ; H5.1 147.81,67.85 ; H5.1 145.73,65.77 ; H5.1 147.25,69.37 ; H5.1 144.21,66.33 ; H5.1 144.21,69.37 ; H5.1 147.25,66.33 ; H5.1 145.73,69.93 ; H5.1 143.65,67.85 ; 5.38,49.81 JUSBC1.5 ; JUSBC1.5 6.82,49.81 ; JUSBC1.5 5.38,50.71 ; JUSBC1.5 6.1,51.82 ; JUSBC1.5 5.38,51.82 ; JUSBC1.5 6.82,51.82 ; JUSBC1.5 6.1,49.81 ; 2.88,35.87 SW2.3 ; SW2.3 3.97,35.87 ; SW2.3 3.97,34.78 ; SW2.3 4.13,35.33 ; SW2.3 3.43,34.63 ; SW2.3 2.88,34.78 ; SW2.3 3.43,36.02 ; 88.73,65.77 H3.1 ; H3.1 88.73,69.93 ; H3.1 90.25,66.33 ; H3.1 90.25,69.37 ; H3.1 86.65,67.85 ; H3.1 90.81,67.85 ; H3.1 87.21,66.33 ; H3.1 87.21,69.37 ; 292.31,41.08 H23.1 ; H23.1 293.38,40.71 ; H23.1 291.94,42.15 ; H23.1 294.45,43.22 ; H23.1 294.82,42.15 ; H23.1 292.31,43.22 ; H23.1 293.38,43.59 ; H23.1 294.45,41.08 ; JUSBC1.4 3.13,41.57 ; JUSBC1.4 1.65,41.57 ; JUSBC1.4 3.13,42.4 ; JUSBC1.4 3.13,43.23 ; JUSBC1.4 1.65,43.23 ; 167.85,47.8 H8.1 ; H8.1 170.85,46.53 ; H8.1 171.31,47.8 ; H8.1 168.31,46.53 ; H8.1 169.58,49.53 ; H8.1 168.31,49.07 ; H8.1 169.58,46.07 ; H8.1 170.85,49.07 ; 294.26,44.97 JUSBC3.1 ; JUSBC3.1 293.03,46.43 ; JUSBC3.1 295.79,45.7 ; JUSBC3.1 295.79,44.97 ; JUSBC3.1 293.03,45.7 ; JUSBC3.1 294.26,46.43 ; JUSBC3.1 295.79,46.43 ; JUSBC3.1 293.03,44.97 ; 145.73,40.67 H6.1 ; H6.1 144.21,44.27 ; H6.1 147.25,41.23 ; H6.1 145.73,44.83 ; H6.1 143.65,42.75 ; H6.1 147.25,44.27 ; H6.1 147.81,42.75 ; H6.1 144.21,41.23 ; 290.12,52.71 JUSBC3.B1 ; JUSBC3.B1 290.9,53.49 ; JUSBC3.B1 290.51,52.62 ; H21.1 5.37,54.94 ; H21.1 5,56.01 ; H21.1 2.86,56.01 ; H21.1 5,53.87 ; H21.1 3.93,56.38 ; H21.1 3.93,53.5 ; H21.1 2.86,53.87 ; H21.1 2.49,54.94 ; JUSBC2.1 3.13,67.49 ; JUSBC2.1 3.13,68.32 ; JUSBC2.1 1.65,66.66 ; JUSBC2.1 3.13,66.66 ; JUSBC2.1 1.65,68.32 ; H2.1 59.15,60.9 ; H2.1 56.11,63.94 ; H2.1 55.55,62.42 ; H2.1 59.15,63.94 ; H2.1 56.11,60.9 ; H2.1 57.63,64.5 ; H2.1 57.63,60.34 ; H2.1 59.71,62.42 ; JUSBC1.2 6.7,51.81 ; JUSBC1.2 8.03,50.26 ; JUSBC1.2 5.37,51.81 ; JUSBC1.2 8.03,51.81 ; JUSBC1.2 5.37,51.04 ; JUSBC1.2 8.03,51.04 ; 5.38,67.17 JUSBC2.5 ; JUSBC2.5 5.38,66.26 ; JUSBC2.5 6.1,66.26 ; JUSBC2.5 6.1,68.27 ; JUSBC2.5 6.82,68.27 ; JUSBC2.5 5.38,68.27 ; JUSBC2.5 6.82,66.26 ; 291.63,26.26 JCR1.13 ; JCR1.13 291.63,25.54 ; JCR1.13 293.89,24.82 ; JCR1.13 293.89,25.54 ; JCR1.13 293.89,26.26 ; JCR1.13 292.76,26.26 ; JCR1.13 292.76,24.82 ; H16.1 295.7,57.18 ; H16.1 294.63,59.69 ; H16.1 296.07,58.25 ; H16.1 293.56,59.32 ; H16.1 293.19,58.25 ; H16.1 295.7,59.32 ; H16.1 293.56,57.18 ; H16.1 294.63,56.81 ; 293.03,54.17 JUSBC3.4 ; JUSBC3.4 293.03,54.9 ; JUSBC3.4 293.03,55.63 ; JUSBC3.4 294.26,54.17 ; JUSBC3.4 294.26,55.63 ; JUSBC3.4 295.79,54.17 ; JUSBC3.4 295.79,54.9 ; JUSBC3.4 295.79,55.63 ; SW2.4 3.97,31.82 ; SW2.4 4.13,31.28 ; SW2.4 3.43,30.58 ; SW2.4 2.88,30.73 ; SW2.4 2.88,31.82 ; SW2.4 3.43,31.97 ; SW2.4 3.97,30.73 ; 5.38,43.63 JUSBC1.6 ; JUSBC1.6 6.1,41.62 ; JUSBC1.6 6.82,43.63 ; JUSBC1.6 5.38,41.62 ; JUSBC1.6 6.1,43.63 ; JUSBC1.6 6.82,41.62 ; JUSBC2.4 3.13,58.02 ; JUSBC2.4 1.65,58.02 ; JUSBC2.4 3.13,58.85 ; JUSBC2.4 3.13,59.68 ; JUSBC2.4 1.65,59.68 ; 291.26,44.98 JUSBC3.2 ; JUSBC3.2 292.49,46.43 ; JUSBC3.2 291.26,46.43 ; JUSBC3.2 290.03,45.7 ; JUSBC3.2 292.49,44.98 ; JUSBC3.2 292.49,45.7 ; JUSBC3.B12 290.51,47.98 ; JUSBC3.B12 290.12,47.89 ; JUSBC3.B12 290.03,47.5 ; JUSBC3.B12 290.9,47.11 ; JCR1.11 284.49,39.14 ; JCR1.11 282.23,39.14 ; JCR1.11 283.36,38.42 ; JCR1.11 284.49,38.42 ; JCR1.11 282.23,39.86 ; JCR1.11 283.36,39.86
  GND3 w0.254: v3(20.9,52.44) 21.06,52.44 v4(21.35,52.15) ; v3(21.8,52.82) 21.83,52.82 22.02,53.01 22.08,53.01 22.11,53.04 v4(22.21,53.04) ; 102.05,61.92 102.05,61.97 101.93,62.09 v4(101.93,62.26) ; v4(112.04,62.2) 111.95,62.2 v3(111.68,62.47) ; v4(24.04,53.39) 23.82,53.39 v3(23.66,53.23) ; v4(21.24,46.25) v3(21.57,46.57) ; v4(99.9,62.26) v3(99.9,61.91) ; 133.22,60.43 v3(133.17,60.43) ; v4(132.16,62.2) 132.11,62.2 v3(131.71,61.79) ; v4(130.33,62.85) 130.09,63.09 v3(129.8,63.09) ; v4(131.25,63.5) 131.41,63.5 v3(131.66,63.75) ; v3(127.27,50.43) 127.27,50.51 UCPU1.AK18 ; v3(125.53,50.26) 125.53,50.19 v4(125.76,49.96) ; v3(130.27,54.59) 130.28,54.58 v4(130.28,53.97) ; v4(112.96,62.2) 113.51,62.2 v3(113.76,62.45) ; v4(142,50.12) v3(142,49.65) v4(142,49.26) ; v4(111.13,63.5) 111.06,63.5 110.89,63.67 110.67,63.67 v3(110.62,63.72) ; v4(110.21,62.2) 110.15,62.2 v3(109.91,62.43) ; v3(22.71,53.15) 22.89,53.32 23.07,53.32 v4(23.14,53.39) ; v3(131.7,61.25) 131.36,60.9 v4(131.25,60.9) ; UCPU1.E6 133.99,63.36 v3(133.82,63.19) ; v4(128.79,54.08) v3(128.4,54.08) ; v4(107.46,64.23) v3(107.1,64.23)
  GND3 w0.457: v4(285.92,38.21) 286.24,38.21 v3(286.42,38.39)
  GND3 w0.508: v3(172.41,25.99) v6(172.49,26.36) ; v4(289.01,62.65) v3(289.03,62.28)
  BOTTOM w0.076: 116.76,63.86 116.71,63.82 116.54,63.82 116.31,63.59 116.31,63.4 116.61,63.1 UCPU1.F37 UCPU1.F35
  BOTTOM w0.127: UT2.A10 17.47,48.47 17.33,48.6 v4(17.21,48.6) ; UT2.A8 17.84,49.39 17.67,49.56 v4(17.41,49.56) ; v8(129.6,45.25) 129.19,45.25 129.16,45.22 128.84,45.22 128.39,45.67 UCPU1.AW16 ; v4(17.25,43.56) 17.56,43.87 UT2.A20 ; UT2.A18 16.96,44.79 v4(16.87,44.7) ; v4(17.39,45.65) 17.46,45.65 17.52,45.71 UT2.A16
  BOTTOM w0.152: v4(18.59,44.79) UT2.A18 ; v4(19.94,51.45) 19.92,51.45 19.58,51.79 18.94,51.79 UT2.B2 ; v4(27.79,52.15) UT2.AB1 ; v4(28.68,42.87) 28.6,42.95 UT2.AC22 UT2.AB22 ; v4(28.94,45.86) 28.79,45.71 UT2.AC16 UT2.AB16 ; UT2.B12 UT2.A12 17.54,47.55 17.46,47.63 v4(17.19,47.63) ; v4(18.59,46.63) UT2.A14 17.22,46.63 17.18,46.66 v4(17.16,46.66) ; UT2.P2 UT2.P1 ; UT2.J22 UT2.J23 21.81,42.06 21.86,42.02 v4(21.86,41.87) ; v4(28.99,50.45) 28.84,50.45 28.7,50.31 UT2.AC6 UT2.AB6 ; UT2.U23 v4(25.49,42.95) ; UT2.AB20 UT2.AC20 28.72,43.87 v4(28.75,43.84) ; v4(28.91,48.43) 28.87,48.47 UT2.AC10 UT2.AB10 ; v4(28.87,46.78) 28.72,46.63 UT2.AC14 UT2.AB14 ; UT2.AB8 UT2.AC8 28.72,49.39 28.87,49.54 v4(28.91,49.54) ; UT2.AA23 UT2.AA22 ; UT2.L22 UT2.L23 22.73,42.1 22.82,42.01 v4(22.82,41.87) ; v4(20.88,41.87) 20.88,42.07 20.89,42.08 UT2.G23 UT2.G22 ; v4(26.72,41.8) 26.41,42.11 UT2.W23 UT2.W22 ; UT2.A22 UT2.B22 UT2.C22 ; UT2.N22 UT2.N23 23.65,41.94 v4(23.79,41.8) ; UT2.T2 UT2.T1 25.03,52.98 v4(24.95,53.06) ; 135.52,47.46 135.09,47.03 134.62,47.03 134.45,47.21 v8(134.45,47.65) ; UT2.AB18 UT2.AC18 v4(28.72,44.79) ; v4(23.19,52.15) UT2.M1 ; v4(18.59,43.87) UT2.A20 ; UT2.R23 UT2.R22 ; v4(28.25,52.61) UT2.AC2 ; v4(18.59,45.71) UT2.A16 ; UT2.A8 UT2.B8 ; v4(21.35,52.15) UT2.H1 ; v4(22.27,52.15) UT2.K1 ; UT2.A10 UT2.B10
  BOTTOM w0.178: v4(17.38,50.49) 17.87,50.49 18.05,50.31 UT2.A6 v4(18.59,50.31) ; UCPU1.AM71 96.27,49.75 v4(96.19,49.67) ; v4(96.37,61.96) 96.41,62 UCPU1.H71 ; UT2.C22 UT2.C23 19.05,42.3 18.68,41.93 v8(18.17,41.93) ; v8(127.16,42.64) UCPU1.BB18 ; UCPU1.AT4 135.52,47.46
  BOTTOM w0.203: v4(24.04,53.39) 24.11,53.32 UT2.P1 ; 116.76,63.86 117.06,63.86 117.37,64.17 UCPU1.D34 ; UCPU1.F32 119.85,63.34 UCPU1.D30 ; UCPU1.AW60 104.19,45.87 104.22,45.9 104.52,45.9 104.55,45.87 UCPU1.AW57 105.47,45.87 105.5,45.9 105.79,45.9 105.82,45.87 UCPU1.AW55 106.7,45.87 106.73,45.9 107.02,45.9 107.05,45.87 v4(107.49,45.87) 107.92,45.87 107.95,45.9 108.25,45.9 108.28,45.87 UCPU1.AW51 109.09,45.87 109.12,45.9 109.41,45.9 109.44,45.87 UCPU1.AW49 110.34,45.87 110.37,45.9 110.67,45.9 110.7,45.87 UCPU1.AW47 111.51,45.87 111.54,45.9 111.83,45.9 111.86,45.87 UCPU1.AW45 112.74,45.87 112.77,45.9 113.06,45.9 113.09,45.87 UCPU1.AW43 113.89,45.87 113.94,45.92 114.22,45.92 114.27,45.87 UCPU1.AW41 114.78,45.89 v8(115.27,46.38) 115.78,45.87 UCPU1.AW38 116.46,45.87 116.49,45.9 116.79,45.9 116.82,45.87 UCPU1.AW36 117.69,45.87 117.72,45.9 118.02,45.9 118.05,45.87 UCPU1.AW34 118.9,46.24 v8(118.9,46.36) 119.39,45.87 UCPU1.AW32 120.22,45.87 120.25,45.9 120.54,45.9 120.57,45.87 UCPU1.AW30 121.45,45.87 121.48,45.9 121.77,45.9 121.8,45.87 UCPU1.AW28 122.67,45.87 122.7,45.9 123,45.9 123.03,45.87 UCPU1.AW26 123.9,45.87 123.93,45.9 124.22,45.9 124.25,45.87 UCPU1.AW23 125.22,45.87 125.26,45.9 125.55,45.9 125.58,45.87 UCPU1.AW21 126.03,45.93 126.85,45.93 126.91,45.87 UCPU1.AW18 ; 27.7,47.55 27.46,47.79 27.46,48.13 UT2.AB10 ; UT2.W20 UT2.Y20 27.09,43.19 UT2.AA22 UT2.AB22 ; UT2.M1 23.19,53.28 23.16,53.31 23.16,53.36 v4(23.14,53.39) ; UT2.V20 25.49,43.35 v4(25.49,42.95) ; v4(19.29,50.15) 18.75,50.15 v4(18.59,50.31) 18.66,50.31 19.15,50.8 v4(19.29,50.8) 19.62,50.47 ; UT2.E11 19.94,48.2 v8(19.62,47.87) UT2.D11 ; UT2.K1 22.27,52.98 v4(22.21,53.04) ; UT2.F20 20.59,43.57 UT2.E22 UT2.E23 ; 19.62,50.47 UT2.E6 ; 19.62,50.47 19.94,50.8 v4(19.94,50.8) ; UT2.D18 19.13,44.79 v4(18.59,44.79) ; UT2.D12 UT2.B12 ; 26.41,43.62 UT2.W22 ; 119.5,66.01 119.5,65.64 119.85,65.29 UCPU1.B30 ; UT2.R20 24.49,43.32 24.57,43.24 UT2.R22 ; v4(25.14,45.6) UT2.V15 26.11,46.56 26.11,46.59 26.13,46.59 UT2.W13 ; 19.94,48.85 v8(19.62,48.52) 19.29,48.85 UT2.D9 18.91,48.47 UT2.B10
  BOTTOM w0.254: v8(135.19,57.83) 134.83,58.19 UCPU1.R6 134.76,58.31 134.76,59.24 UCPU1.N6 ; UCPU1.AP10 132.45,48.37 132.59,48.37 v8(132.61,48.35) 132.95,48.01 UCPU1.AR8 ; v4(9.01,48.72) v4(8.55,48.72) v4(8.12,48.72) ; UT2.Y13 UT2.W13 ; UT2.Y13 27.09,46.99 27.65,47.55 27.7,47.55 ; UT2.Y13 27.36,46.63 UT2.AB14 ; UCPU1.E15 129.55,63.37 129.89,63.02 130.16,63.02 v4(130.33,62.85) ; v4(173.12,17.62) 173.55,17.2 U7.16 ; UCPU1.AW12 130.74,45.94 130,45.94 129.93,45.87 UCPU1.AW14 ; v4(21.89,46.9) v4(21.89,47.55) v4(21.24,47.55) v4(21.24,46.9) ; v4(21.89,46.9) v4(21.24,46.9) ; v4(21.89,46.9) v4(22.54,46.9) v4(22.54,46.25) ; v4(21.89,46.9) v4(21.89,46.25) v4(21.24,46.25) ; UCPU1.BA49 v8(109.89,45.34) UCPU1.AW49 ; v4(289.01,62.65) 288.79,62.43 288.03,62.43 287.62,62.83 287.29,62.83 DA6.2 ; UCPU1.B44 112.24,65.08 112.24,64.4 112.37,64.27 ; UCPU1.A67 99.35,66.33 98.93,66.74 98.93,66.79 v4(98.7,67.02) ; UCPU1.AM55 106.45,49.96 v8(106.11,49.62) ; UCPU1.AJ15 129.5,51.56 129.78,51.84 UCPU1.AH13 130.28,52.16 129.5,52.94 129.5,53.18 ; UT2.E8 20.25,49.19 ; UT2.E8 19.62,49.17 ; UT2.E8 19.63,49.81 v4(19.63,49.87) ; 20.25,49.19 UT2.F9 20.59,48.85 v8(20.27,48.52) 19.94,48.85 UT2.E9 ; 20.25,49.19 20.25,49.16 UT2.E9 ; UCPU1.AN23 v8(123.49,48.87) 123.7,48.66 UCPU1.AP23 ; UCPU1.T2 136.28,58.07 v8(136.1,57.89) 135.92,58.07 UCPU1.T4 ; UT2.D13 19.01,46.9 18.74,46.63 v4(18.59,46.63) ; UT2.D13 UT2.D12 v8(19.62,47.87) ; UT2.D13 UT2.D15 ; v4(9.06,66.53) v4(9.06,66.14) v4(9.5,66.14) ; UCPU1.AW14 129.58,45.87 129.33,46.12 129.33,46.59 129.42,46.68 UCPU1.AU15 ; UCPU1.AW14 129.48,45.77 129.48,45.38 v8(129.6,45.25) 129.48,45.13 129.48,44.75 UCPU1.BA14 ; v4(115.25,62.37) 115.7,62.83 UCPU1.F38 ; v4(115.25,62.37) 115.25,62.39 UCPU1.F40 114.67,62.97 113.99,62.97 UCPU1.F42 113.83,62.85 113.18,62.2 v4(112.96,62.2) 113.41,61.74 UCPU1.J42 ; v4(115.25,62.37) 115.24,62.37 UCPU1.J38 ; UT2.T5 v4(25.14,50.15) ; UT2.T5 v4(24.49,50.8) v4(23.84,50.8) v4(23.19,50.8) v4(22.54,50.8) UT2.J5 v4(21.24,50.8) v4(20.59,50.8) 20.27,50.48 20.26,50.48 ; UT2.T5 UT2.V5 ; v4(25.14,50.15) v4(25.14,49.5) ; v4(25.14,50.15) v4(25.79,50.15) ; v4(26.44,50.15) v4(26.44,49.5) ; v4(26.44,50.15) UT2.W5 UT2.V5 ; v4(26.44,50.15) v4(25.79,50.15) ; v4(26.44,49.5) UT2.W9 ; v4(26.44,49.5) v4(25.79,49.5) ; UCPU1.AB18 127.49,54.85 127.25,54.61 v8(127.14,54.5) 126.87,54.23 126.84,54.2 UCPU1.AD19 ; v8(125.79,52) 126.19,51.6 UCPU1.AJ20 ; v8(125.79,52) 126.19,52.39 UCPU1.AG20 126.52,52.07 126.52,52.01 v8(126.54,51.98) 126.84,52.27 UCPU1.AG19 UCPU1.AG18 ; v8(125.79,52) 125.54,52.26 UCPU1.AG21 124.84,51.71 UCPU1.AK22 125.36,50.9 UCPU1.AK21 ; v4(32.71,27.62) 32.88,27.78 QE2.1 ; v4(21.24,46.9) v4(21.24,46.25) ; RT80.1 32.7,37.58 v4(32.7,37.57) ; UCPU1.AR42 113.78,48.01 v8(113.41,47.65) 113.7,47.36 UCPU1.AT42 ; v4(21.52,11.62) 21.46,11.56 21.4,11.56 21.37,11.54 JDEG1.10 ; UT2.W20 26.41,43.62 ; UCPU1.AP20 126.62,48.66 v8(126.19,48.23) ; UT2.AB10 27.74,48.47 27.36,48.85 v4(27.09,48.85) UT2.W9 ; v8(111.64,49.62) 111.47,49.62 UCPU1.AM46 111.13,49.98 UCPU1.AL48 ; 129.5,53.18 129.96,53.18 130.28,53.5 v4(130.28,53.97) ; 129.5,53.18 UCPU1.AF15 ; v8(130.69,55.47) 130.69,55.48 130.28,55.89 UCPU1.W13 ; 18.53,39.7 CT38.2 16.7,40.91 16.71,40.92 ; v8(117.99,48.92) 118.05,48.92 UCPU1.AN33 ; v4(25.14,45.6) v4(25.14,44.95) v4(24.49,44.95) v4(24.49,44.3) UT2.R20 ; v8(121.56,51.21) 121.64,51.13 UCPU1.AL28 ; v4(177.12,9.09) 177.08,9.06 JTP1.4 ; UCPU1.K16 128.79,60.71 v8(129.13,60.37) 128.79,60.02 v4(128.79,59.95) v4(128.14,59.95) 127.99,59.8 127.63,59.8 UCPU1.L18 127.49,59.92 127.14,59.57 v8(127.14,59.54) 126.84,59.24 UCPU1.N19 126.49,58.76 v8(126.49,58.66) ; UCPU1.K16 128.37,61.2 127.97,61.2 127.62,61.55 UCPU1.H18 127.49,61.45 UCPU1.K18 ; UCPU1.K16 128.79,60.92 UCPU1.H15 129.56,61.55 129.88,61.87 v8(129.96,61.87) ; v4(131.25,63.5) 131.56,63.82 UCPU1.D11 132.2,64.27 UCPU1.D10 UCPU1.B10 ; v4(21.24,46.25) UT2.H16 ; 100.84,59.29 100.5,59.63 99.39,59.63 98.92,59.16 UCPU1.N68 ; 100.84,59.29 UCPU1.N65 ; 100.84,59.29 100.84,59.36 v8(101.19,59.71) ; v4(31.28,55.8) RT82.1 ; UCPU1.AU10 132.28,46.59 132.46,46.59 v8(132.65,46.41) 133.18,45.87 UCPU1.AW8 ; UCPU1.J13 v4(131.25,60.9) ; UCPU1.AK69 UCPU1.AK68 ; UCPU1.AK68 98.88,51.2 UCPU1.AH67 99.88,51.5 v8(99.88,51.39) ; UCPU1.AK68 98.88,51.02 99.28,50.63 99.28,50.24 99.21,50.17 UCPU1.AM68 ; v8(138.13,44) 138.01,44 137.95,44.06 UCPU1.BA1 137.1,44.06 UCPU1.BA2 136.93,44.27 136.32,44.88 UCPU1.AY3 ; v4(288.51,53.55) 288.51,53.82 288.14,54.19 v8(287.21,54.19) ; UCPU1.E21 125.53,63.5 UCPU1.D22 124.8,64.72 v8(124.84,64.76) 124.8,64.8 UCPU1.B22 ; v8(126.49,58.66) 126.19,58.36 UCPU1.P20 UCPU1.P21 ; v8(126.49,58.66) 126.49,58.62 UCPU1.P19 ; UCPU1.BA41 v8(114.78,45.34) UCPU1.AW41 ; UCPU1.AD8 133.53,54.3 v8(133.85,54.61) 133.53,54.92 UCPU1.AB8 ; v4(25.14,49.5) v4(25.14,48.85) UT2.V9 ; v4(25.14,49.5) v4(25.79,49.5) ; PU1101.11 65.33,48.58 v8(65.65,48.26) ; PQ121.4 44.94,4.85 44.4,4.31 v4(44.4,4.03) ; v4(18.91,49.14) 19.27,49.5 UT2.D8 ; v4(18.91,49.14) 19.2,48.85 UT2.D9 19.62,49.17 ; v4(18.91,49.14) 18.66,49.39 UT2.B8 ; UCPU1.AM60 103.75,49.96 v8(103.36,49.57) 102.96,49.96 UCPU1.AM61 ; v8(96.34,45.88) 96.46,46.01 UCPU1.AV71 UCPU1.AV70 UCPU1.AV69 98.42,46.01 v8(98.68,46.27) 98.76,46.2 UCPU1.AV68 ; v8(132.69,63.15) 132.72,63.13 132.72,63.1 132.97,62.85 UCPU1.F8 ; UCPU1.BA57 104.79,44.87 v8(104.79,45.25) 104.79,45.65 UCPU1.AW57 105.01,46.29 v8(105.11,46.39) ; UCPU1.AL55 v8(107.01,51.33) ; UCPU1.AG18 UCPU1.AJ18 127.63,51.42 127.63,50.87 UCPU1.AK18 ; UCPU1.AG18 UCPU1.AG17 128.14,52.32 128.38,52.08 v8(128.47,51.98) 128.79,52.3 UCPU1.AG16 ; UCPU1.AN28 120.92,49.04 120.85,49.04 v8(120.73,48.92) 120.99,48.66 UCPU1.AP28 ; UCPU1.AH63 102.14,51.71 v8(101.76,51.34) ; v8(133.23,55.72) 132.88,56.07 UCPU1.W9 132.6,56.39 132.51,56.39 132.23,56.67 UCPU1.U10 ; UCPU1.P19 126.84,58.14 v8(127.15,57.82) 127.15,57.76 UCPU1.T18 127.56,57.36 128.07,57.36 UCPU1.T17 ; UCPU1.P19 127.21,58.65 127.79,58.65 128.14,58.3 v4(128.14,58.27) ; UCPU1.AM43 113.37,49.54 v8(113.41,49.54) 113.64,49.31 UCPU1.AN42 ; UT2.V5 v4(25.79,50.15) ; v8(113.41,48.31) 113.77,48.66 UCPU1.AP42 ; v8(288.1,51.63) 288.51,52.04 v4(288.51,52.15) ; UCPU1.AK63 102.14,50.96 v8(101.76,51.34) ; 19.62,49.17 19.62,49.17 UT2.E9 ; 19.62,49.17 19.3,49.5 UT2.D8 ; 18.91,48.47 19.02,48.47 UT2.D11 19.62,48.52 v8(19.62,48.52) ; v8(138.11,52.97) 137.99,52.85 137.33,52.85 UCPU1.AF1 ; 84.19,72.21 85.25,72.21 86.11,73.07 RC257.2 ; UCPU1.AY71 96.87,44.71 v8(96.53,44.37) 96.84,44.06 UCPU1.BA71 96.93,43.86 v8(96.6,43.52) 97.33,43.52 UCPU1.BB70 ; v4(8.99,59.58) v4(8.55,59.58) v4(8.55,59.2) ; UCPU1.AR43 112.86,48.01 v8(112.5,47.65) ; PQ120.1 60.8,7.82 61.18,7.45 61.46,7.45 62.1,6.8 PQ120.4 62.1,6.09 v4(61.77,5.76) ; v4(31.63,20.89) 31.63,20.63 PQ106.3 ; v8(132.62,49.55) 133.03,49.96 UCPU1.AM8 133.53,50.42 UCPU1.AK8 ; UCPU1.AP32 119.03,48.33 v8(118.9,48.33) ; UT2.D15 UT2.E15 UT2.E16 ; UT2.D15 UT2.D16 ; UCPU1.T21 125.5,57.43 125.2,57.14 v8(125.2,56.99) ; UCPU1.AF4 135.84,52.77 136.05,52.56 v8(136.14,52.56) 136.35,52.77 UCPU1.AF2 ; UT2.L22 22.73,43.46 v4(22.54,43.65) ; UCPU1.AR48 110.13,48.01 v8(109.77,47.65) ; UCPU1.W6 134.83,55.98 v8(135.19,55.63) 135.4,55.42 UCPU1.AA4 UCPU1.AA2 ; v4(18.59,45.71) 18.77,45.71 18.88,45.6 UT2.D16 ; UT2.G22 20.89,43.13 21.24,43.48 v4(21.24,43.65) ; UCPU1.U69 98.23,57.23 v8(97.89,56.88) 97.58,57.19 UCPU1.U70 ; UT2.V9 v4(25.79,49.5) ; UT2.V9 UT2.W9 ; v4(25.79,49.5) v4(25.79,50.15) ; v4(52.21,3.33) 52.82,3.33 PQ125.1 ; v4(8.55,50.12) v4(8.12,50.12) ; v4(8.55,50.12) v4(8.98,50.12) ; v4(8.55,50.12) v4(8.55,50.5) ; UCPU1.B71 UCPU1.A70 ; UT2.N22 23.65,43.12 23.84,43.31 v4(23.84,43.65) ; v8(135.74,66.72) 135.74,66.66 UCPU1.A5 ; UCPU1.AR55 106.51,48.01 106.15,47.65 v8(106.08,47.65) 105.98,47.65 105.69,47.36 UCPU1.AT56 ; UCPU1.AW6 134.4,45.85 v8(134.4,45.31) 134.42,45.29 UCPU1.BA6 UCPU1.BB6 ; UCPU1.AM68 99.21,49.39 99.25,49.34 99.25,49.04 99.21,48.99 UCPU1.AP68 ; UCPU1.AM68 99.42,50.06 UCPU1.AL66 UCPU1.AL65 UCPU1.AL64 101.98,49.56 UCPU1.AN63 101.92,49.31 v8(101.53,48.92) 101.66,48.79 101.86,48.79 UCPU1.AP63 101.61,48.28 v8(101.53,48.28) 101.75,48.06 101.93,48.06 UCPU1.AR63 101.62,47.65 v8(101.53,47.65) 101.81,47.36 UCPU1.AT63 ; v8(108.75,63.87) 108.96,63.87 109.3,63.53 UCPU1.E50 ; UT2.D16 UT2.D18 ; UT2.D16 UT2.E16 ; v4(92.78,73.94) 92.4,74.33 91.07,74.33 90.79,74.05 RC217.2 90.78,73.32 RC244.2 ; UCPU1.AP68 v8(98.64,48.58) UCPU1.AP70 ; UCPU1.AP68 99.21,48.16 99.25,48.11 99.25,47.81 99.21,47.77 UCPU1.AT68 ; UCPU1.AL58 105.18,51.24 v8(105.2,51.26) ; v4(128.79,54.08) 128.42,53.72 128.42,53.53 UCPU1.AF17 ; v8(120.75,61.05) 120.73,61.07 UCPU1.J28 ; UCPU1.BA28 v8(122.24,45.34) UCPU1.AW28 ; UCPU1.AW62 102.11,45.87 102.07,45.91 102.04,45.91 102.02,45.93 101.32,45.93 UCPU1.AW64 101.19,45.93 100.23,45.93 UCPU1.AW66 100.16,45.35 UCPU1.AY66 UCPU1.BA66 ; UCPU1.AW62 102.95,45.87 102.99,45.91 103.02,45.91 103.04,45.93 103.75,45.93 UCPU1.AW60 ; UCPU1.AW62 v8(102.53,45.34) UCPU1.BA62 ; UCPU1.AR15 129.09,47.68 v8(128.97,47.68) ; 112.37,64.27 UCPU1.D44 ; 112.37,64.27 UCPU1.D45 111.74,64.11 v4(111.13,63.5) 110.61,64.02 UCPU1.D47 110.35,64.27 110.31,64.23 UCPU1.D48 109.99,64.28 109.99,65.07 109.98,65.08 109.98,65.09 109.97,65.11 109.97,65.16 109.94,65.2 UCPU1.B48 ; v8(99.22,55.04) 99.22,55.13 98.88,55.47 UCPU1.AA68 ; UCPU1.BB67 99.09,43.34 99.09,42.96 99.2,42.85 v8(99.2,42.78) ; UCPU1.AW16 128.33,45.93 127.22,45.93 UCPU1.AW18 127.16,45.36 v8(127.29,45.23) 127.16,45.1 UCPU1.BA18 ; UCPU1.AU38 115.6,46.71 v8(115.27,46.38) ; UCPU1.AT2 UCPU1.AT4 ; UCPU1.B58 UCPU1.D58 104.98,63.94 v8(105.16,63.76) 105.42,63.5 UCPU1.E56 105.64,63.39 106.08,62.95 106.08,62.68 UCPU1.G55 ; UCPU1.AR5 134.81,48.01 v8(134.45,47.65) ; v4(22.54,43.65) v4(23.19,43.65) ; v4(22.54,43.65) v4(21.89,43.65) ; UCPU1.U63 UCPU1.U64 101.47,57.33 101.08,56.94 100.58,56.94 UCPU1.U66 100.19,57.22 v8(99.85,56.88) 99.54,57.2 UCPU1.U67 ; v8(71.19,35.73) 71.07,35.61 PU1501.16 ; v4(8.88,64.36) 8.88,64.56 v4(9.06,64.74) 9.34,64.46 v4(9.34,64.4) ; PU1500.16 60.35,35.56 v8(60.66,35.87) ; UCPU1.AP58 104.53,48.66 v8(104.27,48.92) 104.33,48.92 UCPU1.AN58 ; UCPU1.AN40 114.73,49.31 114.33,48.92 v8(114.33,48.92) ; UCPU1.AK27 122.1,51.34 121.53,51.91 v8(121.25,51.91) ; PU900.6 159.1,6.19 159.44,5.84 160.45,5.84 160.79,6.18 PR904.2 ; v8(101.19,55.03) 100.84,55.39 UCPU1.AA65 ; UCPU1.J8 132.86,60.9 v8(132.54,61.23) ; D63.2 289.17,44.06 v8(289.41,44.29) ; UCPU1.AH6 134.94,51.73 134.94,51.36 135.53,50.78 UCPU1.AJ4 UCPU1.AL4 135.92,50.11 v8(136.12,50.32) 136.32,50.11 UCPU1.AL2 ; v4(19.63,49.87) 19.35,50.15 v4(19.29,50.15) ; v4(19.63,49.87) 19.66,49.87 UT2.E6 19.94,50.16 20.26,50.48 ; v4(19.63,49.87) 19.29,49.52 UT2.D8 ; UT2.M19 v4(23.19,43.65) ; v4(23.19,43.65) v4(23.84,43.65) ; v4(66.49,7.63) 66.22,7.9 PQ117.1 ; UCPU1.B30 119.85,64.91 v8(119.64,64.7) 119.85,64.49 UCPU1.D30 ; v4(23.84,43.65) UT2.R20 ; UCPU1.E18 127.35,63.5 v8(127.13,63.72) 127.13,64.08 UCPU1.D18 127.22,64.29 127.22,64.67 127.28,64.73 UCPU1.B18 ; UCPU1.D39 114.96,64.3 114.96,64.88 114.89,64.94 v4(114.89,65.25) ; UCPU1.AR45 111.99,48.01 v8(111.63,47.65) ; UCPU1.BA45 v8(112.3,45.34) ; v4(26.44,44.95) v4(25.79,45.6) 25.79,45.6 25.14,46.25 v4(25.14,46.25) 25.14,46.25 25.47,46.57 ; UCPU1.L8 133.53,60.82 v4(133.58,60.87) ; v8(121.64,49.57) 122.04,49.96 UCPU1.AM27 122.16,49.96 v8(122.56,49.57) 122.95,49.96 UCPU1.AM25 ; UCPU1.AK16 128.48,51.03 v8(128.48,51.15) ; v8(107.9,47.65) 108.02,47.65 UCPU1.AR52 ; UCPU1.AR35 117.17,47.65 v8(117.07,47.65) 117.36,47.36 UCPU1.AT35 ; v8(122.37,60.82) 122.56,61 UCPU1.J25 ; PR1502.2 v4(55.79,38.06) ; v8(66.22,39.85) 66.12,39.95 PU1150.11 ; UT2.E16 UT2.F16 UT2.H16 ; UCPU1.AL38 v8(116.16,51.17) ; PU1100.11 64.76,57.95 v8(64.86,57.85) ; UCPU1.Y17 128.14,55.86 v8(127.85,56.15) ; PU1501.15 70.57,35.71 v8(70.57,35.71) ; PQ149.4 180.06,13.1 PR272.2 ; UT2.B1 UT2.B2 ; v4(131.67,38.8) 131.21,39.26 CC93.1 ; UCPU1.G58 v8(104.29,62.63) 104.12,62.46 104.07,62.46 UCPU1.G60 ; v8(127.09,48.33) 127.17,48.33 127.31,48.47 127.31,48.47 127.5,48.66 UCPU1.AP18 ; 126.66,45.93 126.66,46.7 UCPU1.AU20 126.54,46.84 126.39,46.84 v8(126.22,47.01) 126.47,47.26 126.58,47.26 UCPU1.AT20 ; PC1007.1 39.08,40.19 v4(39.08,39.84) ; UCPU1.AN20 126.38,49.02 v8(126.24,49.02) ; v4(23.84,48.2) v4(23.19,48.2) v4(23.19,47.55) v4(23.84,47.55) ; v4(23.84,48.2) v4(23.84,48.85) v4(23.84,49.5) ; v4(23.84,48.2) v4(23.84,47.55) ; UCPU1.B14 129.76,64.98 v8(129.57,64.78) 129.76,64.59 UCPU1.D14 ; UCPU1.AB16 129.12,55.26 v8(129.12,55.34) 129.44,55.02 UCPU1.AB15 ; UCPU1.L20 125.92,59.68 125.92,59.49 UCPU1.N21 125.12,59.52 v8(125.12,59.64) ; v8(126.22,47.65) 126.31,47.65 UCPU1.AR20 ; v4(9.01,60.98) v4(8.55,60.98) 8.55,61.17 v4(8.74,61.36) ; 20.26,50.48 v4(19.94,50.8) ; 20.26,50.48 UT2.F6 v4(21.24,49.5) v4(21.89,49.5) ; v4(102.5,65.25) v4(102.5,64.23) ; UCPU1.AN38 115.7,49.22 116,48.92 v8(116.16,48.92) 116.22,48.92 UCPU1.AN37 ; UCPU1.AR53 107.17,47.71 v8(107.01,47.71) ; UCPU1.AM45 112.46,49.54 v8(112.5,49.54) 112.5,49.55 UCPU1.AL45 ; v4(33.64,12.25) 33.84,12.44 PQ134.1 ; UCPU1.AN30 119.88,48.92 v8(119.82,48.92) ; UCPU1.AH64 101.54,51.79 101.54,51.66 101.6,51.6 101.6,51.5 v8(101.76,51.34) ; PR335.2 62.88,3.37 v4(63.25,3) ; v8(117.07,48.28) 117.15,48.28 UCPU1.AP35 ; v8(124.74,45.33) 124.77,45.33 ; 124.77,45.33 124.77,44.7 UCPU1.BA23 ; 124.77,45.33 124.77,45.82 UCPU1.AW23 ; UCPU1.AL52 108.79,50.48 v8(108.79,51.25) ; 25.47,46.57 UT2.V15 ; 25.47,46.57 v4(25.14,46.9) ; PR277.1 186.78,8.97 PQ157.3 ; v4(25.14,43.65) UT2.R20 ; UCPU1.AW32 v8(119.73,45.34) UCPU1.BA32 ; UCPU1.E65 100.8,63.56 100.53,63.82 100.43,63.82 v4(100.02,64.23) v4(100.02,65.25) ; v4(21.89,43.65) v4(21.24,43.65) ; v4(21.89,43.65) v4(21.89,44.3) v4(21.89,44.95) UT2.H16 ; v4(21.89,43.65) 21.81,43.57 UT2.J22 ; UCPU1.T15 129.12,57.12 v8(129.12,57.01) 128.79,56.67 UCPU1.V16 ; UCPU1.AW36 v8(117.26,45.34) UCPU1.BA36 ; v8(118.9,48.92) 119.02,48.92 119.36,49.26 UCPU1.AN32 ; UCPU1.B53 107.28,65.07 107.28,64.4 v4(107.46,64.23) 107.34,64.11 107.34,63.63 UCPU1.E53 108,62.97 108,62.68 108.39,62.29 UCPU1.G52 ; v8(59.75,35.92) 59.85,35.82 PU1500.15 ; 135.41,63.88 135.04,63.88 v4(134.69,64.23) 134.69,64.21 133.99,63.5 UCPU1.E6 ; UCPU1.D25 122.78,64.27 122.73,64.23 UCPU1.D26 122.33,64.65 v8(122.44,64.76) 122.59,64.92 UCPU1.C25 ; UCPU1.AR58 104.36,47.65 v8(104.27,47.65) 104.56,47.36 UCPU1.AT58 ; UCPU1.N10 132.06,59.49 v8(132.06,59.78) 131.59,60.25 UCPU1.L11 ; UCPU1.BA10 UCPU1.AW10 132,46.12 v8(131.76,46.36) ; UCPU1.AN35 117.14,48.92 v8(117.07,48.92) ; v8(138.47,45.96) 137.94,45.96 137.82,46.08 UCPU1.AV1 ; PC607.2 118.62,2.93 118.62,3.74 118.37,3.99 v4(118.37,4.25) PU600.15 ; v4(8.12,44.53) v4(8.55,44.53) v4(9.15,44.53) ; UCPU1.AF10 132.6,53.27 v8(132.6,53.43) ; v8(127.85,56.15) 127.49,56.51 UCPU1.V18 ; v8(127.85,56.15) 128.14,56.44 UCPU1.V17 ; v4(54.61,15.08) 53.73,15.08 53.53,14.89 53.53,14.13 53.19,13.78 PQ127.1 ; v8(128.01,47.73) 128.13,47.73 128.41,48.01 UCPU1.AR16 ; PC1500.2 v4(56.67,38.03) ; v4(21.24,43.65) UT2.F20 ; UCPU1.R13 130.34,58.3 130.34,59.25 UCPU1.N13 130.1,59.31 v8(129.85,59.55) ; UCPU1.AL32 v8(119.82,51.12) ; UC4.3 164.43,12.87 164.57,12.74 v4(164.57,12.55) ; UCPU1.L4 135.92,60.72 v8(136.1,60.54) 136.28,60.72 UCPU1.L2 ; v8(118.9,46.36) 119.01,46.36 UCPU1.AU32 ; v4(23.84,47.55) v4(23.84,46.9) v4(23.84,46.25) ; v4(117.59,66.9) 117.7,66.79 117.7,66.03 117.71,66.02 117.71,65.71 117.37,65.37 UCPU1.B34 UCPU1.D34 ; PU301.3 v4(67.37,3.4) ; DA5.2 v4(292.71,70.47) ; UCPU1.AR28 121.09,48.01 v8(120.73,47.65) 121.02,47.36 UCPU1.AT28 ; v8(115.24,48.28) 115.62,48.66 UCPU1.AP38 ; UCPU1.AR23 123.84,48.01 v8(123.47,47.65) 123.76,47.36 UCPU1.AT23 ; PQ109.4 v4(38.1,6.48) ; v4(70.02,6.23) PC341.2 ; UCPU1.AD62 102.91,54.13 103,54.22 v8(103.13,54.22) ; v8(110.7,47.65) 110.77,47.65 UCPU1.AR46 ; UCPU1.AK11 131.48,50.9 131.05,50.47 130.95,50.47 130.44,49.96 UCPU1.AM13 130.15,49.96 v8(129.81,49.63) ; v4(107.49,45.87) UCPU1.BA53 ; v4(101.93,62.26) 102.9,61.3 v4(102.9,61.27) 102.42,61.27 v4(102.12,60.96) v4(101.47,60.96) v4(100.82,60.96) v4(100.17,60.96) UCPU1.K67 99.1,60.96 v4(98.9,60.75) 98.01,60.75 v4(97.91,60.65) v4(97.26,60.65) ; UCPU1.AR11 131.18,48.01 v8(130.86,47.7) ; UCPU1.AL35 v8(117.99,51.18) ; UCPU1.AF63 102.14,53.02 UCPU1.AE64 101.49,53.95 v8(101.3,54.14) 100.84,53.68 UCPU1.AE65 UCPU1.AE66 UCPU1.AE67 UCPU1.AE68 v4(98.23,53.67) 97.96,53.67 v4(97.8,53.83) ; JEDP1.36 v4(33.58,60.35) ; UCPU1.G5 134.67,62.43 v8(134.41,62.43) 134.22,62.43 UCPU1.G6 ; RC391.1 v4(92.47,67.69) ; 39.79,28.4 PU501.18
  BOTTOM w0.305: v8(109.77,47.65) 109.67,47.65 109.31,48.01 UCPU1.AR50 ; v4(293.03,62.51) 293.03,64.76 JAUDIO1.11 ; WL1.35 284.44,49.57 284.66,49.35 284.66,48.37 284.35,48.07 v4(284.12,48.07) ; v4(124.74,38.3) 125.06,38.71 CR26.1 ; CA31.2 CA32.2 ; v8(9.82,9.89) 10.09,9.62 JESPI1.9 ; v4(185.95,9.57) 186.36,9.16 PQ157.3 ; PQ156.3 191.03,2.99 v4(191.06,3.02) ; v4(21.6,5.98) 21.6,6.41 21.82,6.63 JKB1.17 ; JAUDIO1.14 289.01,64.76 v4(289.01,62.65)
  BOTTOM w0.381: PR320.2 61.82,11.49 62.33,12.01 v8(62.9,12.01) ; v4(116.91,12.46) 117.09,12.46 CC92.2 ; v4(295.61,35.85) 295.19,36.27 CR4.2 ; v8(139.79,18.57) 139.79,16.96 139.69,16.86 ; PQ117.4 67.52,6.11 v4(67.83,5.8) ; UC9.3 116.24,12.61 v4(116.37,12.48) ; v8(160.12,74) 160.1,74.02 PC1420.2
  BOTTOM w0.508: v8(61.98,54.83) 62.37,54.44 PC1119.2 ; v8(165.22,70.31) 165.21,70.33 PR1417.2 PR1418.2 ; v8(58.97,48.47) 59.57,48.47 PC1164.1 ; v8(62.08,45.92) 62.24,46.08 PC1110.1 ; v8(120.76,72.81) v8(120.76,71.31) v8(120.76,70.35) ; CC90.2 142.89,63.42 v8(142.65,63.17) ; v8(61.98,56.46) 61.98,56.1 62.3,55.78 PC1100.1 ; 116.3,73.19 v8(116.3,71.6) 116.3,70.4 v8(116.3,70.4) 116.3,69.82 116.02,69.54 115.88,69.54 v4(115.84,69.5) ; CD38.2 124.3,14.97 123.79,15.47 123.79,15.65 v8(123.23,16.21) ; PC1418.2 162.63,70.3 v8(162.64,70.29) ; CD57.2 126.33,15.3 v4(127.27,16.24) ; v8(14.91,67.26) 16.61,65.56 UT3.9 ; v4(20.59,62.64) 20.59,62.64 UT3.4 ; v8(61.13,64.93) 61.65,64.41 PC1121.2 ; PC333.1 65.13,13.61 v8(65.13,13.12) ; v8(136.86,16.55) 136.86,15.55 136.25,14.94 CD62.2 ; 140.8,61.14 v4(141.51,61.14) 141.92,61.14 v4(142.42,60.65) v4(143.05,60.02) 143.41,59.65 v8(143.61,59.65) 143.69,59.57 v8(144.73,59.57) v4(145.58,59.57) v4(146.43,59.57) 147.23,59.57 147.59,59.93 v8(147.59,60.45) v8(147.59,61.84) v4(147.59,63.3) 147.59,63.71 147.23,64.07 v4(146.56,64.07) v4(144.85,64.07) 142.54,64.07 v8(142.52,64.05) ; CE70.2 v4(5.91,22.57) ; v8(164.9,59.9) 164.8,59.8 164.8,59.19 PC1411.2 ; v8(54.87,36.94) PC508.2 ; CA31.2 283.95,65.44 284.24,65.73 285.78,65.73 286.46,66.42 v4(286.46,67.43) ; CD14.2 CD36.2 141.66,15.01 141.66,17.44 141.47,17.63 v8(141.47,18.67) ; PC805.2 v8(164.56,64.58) ; v8(56.72,35.37) PC1509.2 ; v8(12.06,11.83) 12.06,11.83 11.65,11.42 RE205.2 ; v8(45.68,28.32) 45.48,28.13 PC513.2 ; CD16.2 139.69,16.86 ; CD6.2 134.94,15.42 v8(134.94,16.27) ; CD65.2 v4(119.85,16.34) ; v8(46.42,29.59) 46.42,28.79 PC509.2 ; PC806.2 v8(163.48,65) ; PR1406.2 v8(166.57,59.84) ; v4(117.59,66.9) v4(117.08,67.41) ; PC1414.2 v8(163.97,69.27)
  vias: v1(2.17,66.05) v1(2.17,64.78) v1(2.17,63.51) v1(2.17,62.24) v1(2.15,60.37) v1(2.16,49.78) v1(2.16,48.51) v1(2.15,47.33) v1(2.16,45.97) v1(2.16,44.7) v1(2.66,46.51) v1(3.13,61.23) v1(3.44,66.05) v1(3.44,64.78) v1(3.44,63.51) v1(4.09,49.28) v1(4.09,48.01) v1(4.48,60.97) v1(4.71,66.05) v1(4.71,64.78) v1(5.58,66.05) v1(5.61,49.61) v1(5.76,60.55) v1(5.74,44.09) v1(5.97,66.05) v1(5.96,52.71) v1(5.98,49.6) v1(6.02,60.54) v1(6.05,44.09) v1(6.63,25.74) v1(6.7,52.09) v1(6.96,29.76) v1(7.11,60.29) v1(7.14,53.24) v1(7.1,43.85) v1(7.23,65.79) v1(7.21,49.35) v1(7.31,66.39) v1(7.36,56.66) v1(7.4,60.3) v1(7.41,43.85) v1(7.49,39.16) v1(7.61,65.79) v1(7.66,52.4) v1(7.6,49.34) v1(7.69,60.31) v1(7.71,43.85) v1(7.77,39.16) v1(7.89,37.12) v1(8.08,36.82) v1(7.99,33.8) v1(8.02,30.55) v1(8.23,56.66) v1(8.2,39.19) v1(8.2,38.91) v1(8.36,59.28) v1(8.29,41.87) v1(8.31,38.26) v1(8.38,25.8) v1(8.55,60.6) v1(8.52,48.29) v1(8.5,41.27) v1(8.61,13.02) v1(8.74,43.22) v1(8.84,50.11) v1(8.84,38.87) v1(8.84,38.59) v1(8.89,45.14) v1(9.36,66.48) v1(9.37,64.95) v1(9.35,21.82) v1(9.92,29.41) v1(10.14,47.45) v1(10.36,44.63) v1(11.03,31.38) v1(11.3,47.24) v1(11.51,41.11) v1(11.55,39.12) v1(11.65,16.15) v1(11.88,21.04) v1(12.28,40.18) v1(12.33,55.24) v1(12.33,53.33) v1(12.35,37.73) v1(12.44,36.25) v1(12.42,24.17) v1(12.5,38.27) v1(12.54,23.91) v1(12.55,10.59) v1(12.68,41.15) v1(12.66,37.26) v1(12.77,55.65) v1(12.69,23.61) v1(12.83,54.16) v1(12.86,52.8) v1(12.79,26.73) v1(12.93,51.86) v1(12.96,28.53) v1(12.95,27.79) v1(13.04,60.23) v1(13.27,22.74) v1(13.37,54.75) v1(13.36,53.46) v1(13.39,55.95) v1(13.69,50.89) v1(13.72,32.75) v1(13.72,32.19) v1(13.97,56.59) v1(13.9,55.17) v1(13.96,53.8) v1(13.98,37.9) v1(14.37,51.39) v1(14.41,56.94) v1(14.4,55.51) v1(14.41,54.22) v1(14.39,52.82) v1(14.68,64.4) v1(14.63,50.38) v1(14.72,61.67) v1(14.78,60.35) v1(14.74,59.25) v1(14.83,62.35) v1(14.82,8.68) v1(14.91,63.67) v1(14.97,63) v1(15.1,10.01) v1(15.35,62.26) v1(15.36,5.04) v1(15.4,49.5) v1(15.67,62.84) v1(15.67,37.49) v1(15.69,41.4) v1(15.87,61.79) v1(16.08,63.33) v1(16.12,8.56) v1(16.26,61.03) v1(16.24,60.45) v1(16.23,48.76) v1(16.3,64.57) v1(16.38,39.59) v1(16.41,41.69) v1(16.5,45.25) v1(16.49,43.62) v1(16.56,21.83) v1(16.74,63.07) v1(16.85,9.23) v1(16.98,52.66) v1(17.01,51.39) v1(17.01,50.8) v1(17.19,47.97) v1(17.21,38.68) v1(17.18,24.98) v1(17.26,23.96) v1(17.35,46.11) v1(17.31,44.32) v1(17.33,42.57) v1(17.33,40.66) v1(17.39,31.33) v1(17.38,31.06) v1(17.43,30.77) v1(17.47,30.15) v1(17.4,29.87) v1(17.39,29.59) v1(17.46,24.82) v1(17.48,62.37) v1(17.49,29.2) v1(17.52,5.7) v1(17.67,29.9) v1(17.71,63.11) v1(17.91,38.02) v1(17.98,31.31) v1(17.98,29.81) v1(17.95,6.94) v1(18.14,32.12) v1(18.24,8.42) v1(18.29,40.29) v1(18.38,63.27) v1(18.46,45.71) v1(18.48,31.31) v1(18.48,30.81) v1(18.48,30.31) v1(18.48,29.81) v1(18.45,23.96) v1(18.56,62.54) v1(18.54,29.2) v1(18.48,24.8) v1(18.6,44.55) v1(18.69,42.75) v1(18.8,29.2) v1(18.84,23.96) v1(18.96,48.51) v1(18.94,32.21) v1(18.98,31.31) v1(18.98,30.81) v1(18.98,30.31) v1(18.98,29.81) v1(19.05,45.71) v1(19.07,29.19) v1(19.15,51.34) v1(19.17,50.73) v1(19.14,49.74) v1(19.26,63.11) v1(19.21,32.2) v1(19.35,29.19) v1(19.34,23.96) v1(19.29,8.41) v1(19.45,67.22) v1(19.48,31.31) v1(19.48,30.81) v1(19.48,30.31) v1(19.48,29.81) v1(19.57,42.76) v1(19.64,45.7) v1(19.67,35.68) v1(19.64,29.2) v1(19.72,49.15) v1(19.72,23.96) v1(19.8,37.31) v1(19.98,29.81) v1(19.94,29.21) v1(20.03,32.15) v1(20.1,31.88) v1(20.09,29.51) v1(20.2,32.42) v1(20.26,29.21) v1(20.36,42.72) v1(20.31,35.8) v1(20.34,32.15) v1(20.37,31.86) v1(20.36,25.1) v1(20.41,45.93) v1(20.41,45.3) v1(20.38,31.56) v1(20.39,31.29) v1(20.39,30.99) v1(20.42,30.18) v1(20.41,29.89) v1(20.41,29.62) v1(20.54,7.2) v1(20.64,25.01) v1(20.7,10.01) v1(20.78,7.31) v1(20.86,7.93) v1(20.94,64.04) v1(20.89,49.18) v1(20.94,42.73) v1(21.05,62.79) v1(21.04,61.7) v1(21.38,35.85) v1(21.48,49.18) v1(21.62,50.97) v1(21.63,25.1) v1(21.68,45.93) v1(21.68,44.66) v1(21.78,43.44) v1(21.76,38.08) v1(21.82,21.71) v1(21.88,24.98) v1(22.14,46.57) v1(22.21,47.15) v1(22.29,15.65) v1(22.3,11.61) v1(22.62,50.94) v1(22.8,47.14) v1(23.02,25.07) v1(23.14,52.42) v1(23.22,66.69) v1(23.36,25.07) v1(23.41,47.33) v1(23.41,46.69) v1(23.55,43.44) v1(23.48,42.76) v1(23.61,50.38) v1(23.61,49.74) v1(23.69,49.11) v1(23.8,34.63) v1(23.89,33.46) v1(24.02,29.81) v1(24.17,29.56) v1(24.22,51.44) v1(24.22,50.88) v1(24.3,49.78) v1(24.32,39.77) v1(24.53,54.4) v1(24.68,48.47) v1(24.73,46.49) v1(25.21,45.42) v1(25.22,44.89) v1(25.34,22.44) v1(25.55,49.79) v1(25.52,49.23) v1(25.48,46.06) v1(25.66,43.26) v1(25.68,32.44) v1(25.69,28.66) v1(25.69,28.28) v1(25.96,53.68) v1(25.95,29.67) v1(26.15,50.55) v1(26.16,30.56) v1(26.61,32.1) v1(26.7,47.3) v1(26.87,34.97) v1(26.81,14.9) v1(27.42,47.96) v1(27.54,48.46) v1(27.55,47.11) v1(27.76,11.88) v1(27.95,19.5) v1(28.44,16.78) v1(28.72,37.59) v1(28.9,61.85) v1(29.02,35.54) v1(29.08,63.38) v1(29.24,18.59) v1(29.64,27.07) v1(29.69,39.78) v1(29.83,9.68) v1(29.9,26.99) v1(29.96,17.83) v1(30.14,32) v1(30.23,67.96) v1(30.24,37.81) v1(30.25,32.24) v1(30.23,31.42) v1(30.22,17.73) v1(30.46,64.53) v1(30.52,34.04) v1(30.52,33.54) v1(30.52,32.04) v1(30.52,31.42) v1(30.76,34.38) v1(30.8,31.42) v1(31.08,38.03) v1(31.02,33.54) v1(31.02,33.04) v1(31.02,32.54) v1(31.02,32.04) v1(31.05,13.24) v1(31.1,31.42) v1(31.41,31.49) v1(31.51,34.42) v1(31.52,33.54) v1(31.52,33.04) v1(31.52,32.54) v1(31.63,31.66) v1(31.75,34.35) v1(31.89,31.66) v1(32.02,33.54) v1(32.02,32.04) v1(32.04,8.5) v1(32.09,38.01) v1(32.16,31.65) v1(32.42,31.67) v1(32.52,32.04) v1(32.59,34.32) v1(32.72,64.96) v1(32.72,31.68) v1(32.88,34.32) v1(32.9,37.92) v1(33.05,34.04) v1(33.05,33.77) v1(33.05,33.51) v1(33,32.54) v1(33,32.24) v1(33,31.95) v1(33,31.68) v1(33.1,68.45) v1(33.36,27.44) v1(33.52,32.04) v1(33.58,26.41) v1(33.62,27.43) v1(33.62,27.16) v1(33.85,26.42) v1(34.03,35.54) v1(34.17,66.5) v1(34.12,26.41) v1(34.43,72.71) v1(34.46,45.32) v1(34.38,26.41) v1(34.91,49.79) v1(35.01,64.93) v1(35.08,73.31) v1(35.27,52.65) v1(35.27,51.76) v1(35.27,50.87) v1(35.3,48.73) v1(35.87,66.36) v1(36.51,42.04) v1(37.04,53.74) v1(37.27,42.07) v1(37.28,41.27) v1(37.95,53.72) v1(38.02,66.29) v1(38.11,7.45) v1(38.39,66.91) v1(38.68,73.31) v1(38.77,37.62) v1(38.77,37.29) v1(38.77,37.02) v1(38.76,35.19) v1(38.77,34.88) v1(38.84,65.94) v1(38.98,17.57) v1(39.12,67.46) v1(39.14,37.62) v1(39.14,37.02) v1(39.13,35.19) v1(39.13,34.58) v1(39.28,42.12) v1(39.46,17.57) v1(39.71,55.48) v1(40.39,42.06) v1(40.74,53.75) v1(40.91,67.46) v1(41.29,38.46) v1(41.8,55.66) v1(42.07,2.04) v1(42.18,38.49) v1(42.33,2.05) v1(43.07,67.46) v1(43.73,55.56) v1(43.73,53.78) v1(44.59,55.58) v1(44.62,53.8) v1(46.98,48.42) v1(47.73,64.04) v1(47.95,62.74) v1(48.76,47.68) v1(49.28,17.62) v1(49.55,28.95) v1(49.79,28.71) v1(50.1,15.25) v1(50.1,14.38) v1(50.8,64.81) v1(50.98,70.06) v1(52.77,70) v1(53,3.59) v1(53.74,72.46) v1(57.57,31.63) v1(58.46,31.63) v1(59.02,11.6) v1(59.94,11.6) v1(60.07,38.06) v1(60.1,38.36) v1(60.14,36.82) v1(60.15,36.51) v1(60.36,38.37) v1(60.33,38.06) v1(60.45,36.82) v1(60.44,36.49) v1(61.26,16.73) v1(63.32,31.98) v1(63.51,31.73) v1(64.11,5.32) v1(64.38,5.33) v1(66,35.71) v1(66.24,35.49) v1(68.13,15.48) v1(68.33,15.27) v1(70.27,11.09) v1(70.58,36.69) v1(70.81,36.46) v1(71.11,34.54) v1(71.34,34.26) v1(75.61,9.46) v1(75.61,9.2) v1(75.83,55.71) v1(75.88,9.2) v1(75.88,9.46) v1(80.48,57.77) v1(80.81,57.73) v1(81.67,57.78) v1(82,57.74) v1(82.81,57.82) v1(82.97,57.6) v1(84.17,57.82) v1(84.46,57.84) v1(85.49,13.65) v1(85.7,46.69) v1(85.87,46.92) v1(86.06,47.11) v1(86.6,51.8) v1(86.62,47.11) v1(86.86,51.79) v1(86.91,47.14) v1(87.14,51.77) v1(87.18,47.13) v1(87.54,33.05) v1(87.81,51.8) v1(87.91,47.17) v1(88.07,51.79) v1(88.17,47.16) v1(88.34,51.78) v1(88.44,47.15) v1(88.47,33.96) v1(89.03,51.85) v1(89,47.19) v1(88.99,14.8) v1(89.26,47.18) v1(89.29,51.84) v1(89.57,51.82) v1(89.54,47.16) v1(89.88,14.8) v1(90.27,52.02) v1(90.2,47.17) v1(90.27,34.88) v1(90.33,51.74) v1(90.47,47.18) v1(90.52,52.02) v1(90.74,47.16) v1(90.77,14.8) v1(91.41,47.28) v1(91.68,47.27) v1(91.95,47.26) v1(92.08,32.18) v1(92.75,47.78) v1(93.01,47.84) v1(93.45,16.21) v1(93.56,52.72) v1(93.82,52.71) v1(94.08,52.71) v1(94.53,16.15) v1(94.79,52.73) v1(95.05,52.74) v1(95.08,70.8) v1(95.32,52.72) v1(95.5,9.17) v1(95.76,9.17) v1(96.28,52.72) v1(96.53,56.94) v1(96.54,52.72) v1(96.65,9.15) v1(96.8,56.93) v1(96.91,9.15) v1(97.47,59.97) v1(97.47,52.78) v1(97.49,67.85) v1(97.66,53) v1(97.82,59.99) v1(98.11,36.37) v1(98.46,56.96) v1(98.55,59.95) v1(98.73,56.95) v1(98.89,59.97) v1(99.12,14.96) v1(99.86,34.61) v1(99.9,14.91) v1(100.46,56.96) v1(100.73,56.96) v1(101.21,71.91) v1(101.73,57.93) v1(101.73,57.36) v1(101.73,56.79) v1(101.98,38.17) v1(102.04,38.81) v1(102.29,62.04) v1(102.63,42.95) v1(104.1,44.42) v1(104.27,58.13) v1(104.25,57.54) v1(104.21,38.21) v1(104.8,60.49) v1(104.97,42.09) v1(104.99,44.07) v1(105.01,40.8) v1(105.37,60.5) v1(105.72,42.39) v1(105.93,60.5) v1(106.22,43.93) v1(106.47,66.3) v1(106.4,41.76) v1(106.46,39.25) v1(106.49,60.48) v1(106.75,64.98) v1(106.71,45.35) v1(106.79,66.3) v1(106.88,38.04) v1(107.03,40.55) v1(107.1,42.92) v1(107.09,36.09) v1(107.48,44.91) v1(107.53,41.46) v1(107.66,44.46) v1(107.85,37.87) v1(108.02,38.93) v1(108.56,61.06) v1(108.54,60.48) v1(108.59,61.68) v1(111.19,66.17) v1(111.19,37.26) v1(111.44,66.1) v1(111.69,39.35) v1(112.09,61.94) v1(112.46,41.28) v1(112.62,60.56) v1(112.59,60) v1(112.73,65.23) v1(112.7,64.65) v1(112.7,63.48) v1(112.68,61.75) v1(112.76,40.24) v1(112.69,38.92) v1(113.27,8.26) v1(113.45,52.29) v1(113.52,8.26) v1(113.7,52.11) v1(113.75,38.07) v1(113.77,8.26) v1(114.11,36.97) v1(114.3,52.26) v1(114.29,8.26) v1(114.41,40.03) v1(114.52,52.08) v1(114.51,39.42) v1(114.54,8.26) v1(114.79,8.26) v1(115.04,16.86) v1(118.15,61.39) v1(118.18,13.98) v1(118.67,64.88) v1(118.68,64.25) v1(118.67,63.13) v1(119.55,53.44) v1(119.8,13.98) v1(120.44,53.44) v1(120.56,58.85) v1(120.55,58.3) v1(120.55,57.74) v1(120.55,57.18) v1(120.55,56.6) v1(120.5,56.01) v1(120.5,55.3) v1(120.5,54.74) v1(120.5,54.16) v1(121.2,63.2) v1(121.32,53.44) v1(121.68,57.91) v1(121.67,57.64) v1(121.69,60.44) v1(121.69,60.16) v1(121.71,58.88) v1(121.7,58.61) v1(122.21,53.44) v1(122.95,12.4) v1(123.2,12.4) v1(123.46,12.4) v1(123.53,64.59) v1(123.73,12.4) v1(123.83,64.76) v1(124,12.4) v1(124.04,11.5) v1(124.08,64.59) v1(124.27,12.4) v1(124.37,50.88) v1(124.3,11.5) v1(124.55,62.72) v1(124.56,11.5) v1(125,11.5) v1(125.2,40.42) v1(125.41,11.5) v1(125.84,11.5) v1(126.56,69.68) v1(126.95,40.84) v1(127.4,69.68) v1(128.52,49.72) v1(132.61,39.68) v1(133.37,35.53) v1(136.17,37.99) v1(138.07,39.04) v1(138.64,71.16) v1(138.84,51.21) v1(138.89,37.99) v1(139.24,72.34) v1(139.19,51.4) v1(140.9,9.7) v1(141.1,36.97) v1(141.17,9.7) v1(141.26,53.42) v1(141.34,72.35) v1(141.45,9.7) v1(141.5,42.11) v1(141.69,41.93) v1(142.12,9.7) v1(142.39,9.7) v1(142.53,53.51) v1(142.66,9.7) v1(143.66,57.88) v1(144.1,61.65) v1(144.2,36.5) v1(144.19,36.22) v1(144.93,32.73) v1(144.93,30.28) v1(145.12,61.74) v1(145.52,62.49) v1(146.06,60.67) v1(146.23,61.75) v1(146.57,30.2) v1(146.6,49.23) v1(146.64,15.72) v1(146.77,48.98) v1(146.78,30) v1(146.85,62.88) v1(147.58,62.43) v1(147.57,49.87) v1(148.17,19.04) v1(148.43,18.85) v1(150.25,43.35) v1(150.36,36.27) v1(151.01,31.52) v1(151.07,24.59) v1(151.79,68.86) v1(151.98,66.18) v1(152.25,36.81) v1(152.19,23.66) v1(152.25,19.97) v1(152.34,20.81) v1(153.34,63.81) v1(154.01,74.26) v1(154.68,64.07) v1(155.09,71.43) v1(155.69,55.51) v1(155.71,54.23) v1(156.03,64.03) v1(156.06,62.17) v1(156,59.91) v1(156.11,66.26) v1(156.29,52.82) v1(156.97,74.53) v1(157.62,54.42) v1(157.81,67.39) v1(157.86,65.67) v1(157.8,56.99) v1(157.89,63.22) v1(157.91,60.77) v1(158.37,51.93) v1(158.4,43.19) v1(158.83,53.14) v1(159.06,55.55) v1(159.62,67.86) v1(159.8,71.59) v1(160.05,54.48) v1(160.25,56.93) v1(160.39,51.91) v1(160.57,34.21) v1(160.57,33.21) v1(160.57,32.21) v1(160.57,31.21) v1(160.88,53.13) v1(161.02,50.77) v1(161.17,65.08) v1(161.12,62.68) v1(161.17,60.61) v1(161.23,66.59) v1(161.21,55.78) v1(161.98,74.28) v1(161.89,54.15) v1(162.14,48.99) v1(162.32,56.93) v1(162.44,51.98) v1(162.73,62.9) v1(162.79,67.15) v1(162.81,65.43) v1(162.89,68.7) v1(162.95,60.29) v1(163.26,49.75) v1(163.22,48.2) v1(163.31,53.03) v1(163.38,50.64) v1(163.52,38.26) v1(163.66,70.18) v1(163.62,25.61) v1(163.84,71.29) v1(164.19,41.09) v1(164.75,62.47) v1(164.75,60.64) v1(164.86,74.39) v1(164.83,67.2) v1(164.94,72.94) v1(164.97,65.43) v1(165.1,68.93) v1(165.11,56.07) v1(166.03,57.15) v1(168.64,58.12) v1(168.87,63.49) v1(168.79,60.49) v1(169.19,67.9) v1(170.13,20.54) v1(170.11,18.51) v1(170.32,67.53) v1(170.43,61.71) v1(170.54,64.81) v1(170.61,58.39) v1(172.86,20.33) v1(175.83,18.14) v1(218.77,10.81) v1(218.76,9.8) v1(219.01,10.92) v1(219.01,9.9) v1(221.4,6.12) v1(221.66,6.12) v1(223.9,6.17) v1(224.16,6.17) v1(224.19,12.48) v1(224.45,12.48) v1(224.7,12.48) v1(224.84,6.18) v1(224.96,12.48) v1(225.52,6.17) v1(226.01,9.67) v1(226.2,9.9) v1(226.67,9.63) v1(226.89,9.42) v1(253.9,4.44) v1(254.18,9.8) v1(254.15,4.44) v1(256.47,4.38) v1(256.76,10.1) v1(256.73,9.62) v1(256.73,4.38) v1(261.25,4.99) v1(261.27,4.71) v1(261.85,4.97) v1(261.83,4.69) v1(262.15,4.97) v1(262.13,4.68) v1(263.45,23.24) v1(264.81,18.27) v1(264.97,26.89) v1(264.99,21.09) v1(265.1,27.15) v1(265.09,22.56) v1(265.27,45.95) v1(265.37,58.99) v1(265.33,57.18) v1(265.36,54.9) v1(265.37,50.51) v1(265.36,48.27) v1(265.32,46.84) v1(265.33,23.45) v1(265.4,67.39) v1(265.48,62.92) v1(265.38,60.92) v1(265.48,52.13) v1(265.67,49.25) v1(265.88,49.53) v1(266.08,66.82) v1(266.47,62.95) v1(266.54,61.08) v1(266.54,58.91) v1(266.53,54.91) v1(266.61,65.52) v1(266.58,57.2) v1(267.45,43.72) v1(267.65,43.51) v1(267.96,7.98) v1(267.96,3.66) v1(268.31,43.72) v1(268.31,42.78) v1(268.52,43.51) v1(268.52,42.57) v1(269.56,43.36) v1(269.76,43.16) v1(270.42,49.56) v1(270.5,18.5) v1(270.63,49.35) v1(271.74,55.77) v1(272.25,57.16) v1(272.24,20.96) v1(272.41,1.43) v1(272.63,20.25) v1(272.63,19.37) v1(272.66,1.43) v1(272.84,55.75) v1(272.92,1.43) v1(273.15,66.75) v1(273.1,44.59) v1(273.24,53.5) v1(273.3,44.38) v1(273.88,14.99) v1(274.06,67.02) v1(274.5,56.45) v1(274.87,15.78) v1(275.3,57.24) v1(275.38,56.28) v1(275.46,66.92) v1(275.46,20.03) v1(275.44,19.45) v1(275.49,3.87) v1(275.65,56.28) v1(275.73,18.13) v1(276.37,56.94) v1(276.6,56.79) v1(276.85,56.95) v1(276.89,28.92) v1(276.88,28.65) v1(276.89,28.14) v1(277.12,14.93) v1(277.36,14.79) v1(277.55,23) v1(277.58,6.71) v1(277.6,24.98) v1(278.03,3.73) v1(278.55,25.5) v1(278.55,25.22) v1(278.49,13.32) v1(278.82,26.78) v1(278.83,26.13) v1(279.27,33.47) v1(279.28,33.06) v1(279.28,32.76) v1(279.62,17.8) v1(279.87,11.18) v1(279.88,4.45) v1(279.88,17.78) v1(280.15,11.19) v1(280.73,11.05) v1(280.81,6.86) v1(280.83,4.39) v1(281.01,11.06) v1(281.33,8.97) v1(281.74,11.07) v1(282.01,11.07) v1(282.56,30.44) v1(282.82,30.45) v1(283.08,30.45) v1(283.62,12.85) v1(283.89,12.85) v1(284.01,47.89) v1(284.47,17.44) v1(284.74,17.44) v1(284.76,16.91) v1(284.72,8.13) v1(285.6,48.23) v1(285.92,4.83) v1(286.25,50.88) v1(286.2,19.59) v1(286.76,27.39) v1(286.93,5.43) v1(287.26,50.44) v1(287.26,49.04) v1(287.26,48.04) v1(287.21,46.64) v1(288.32,26.17) v1(288.44,32.82) v1(289.1,34.12) v1(289.27,24.82) v1(289.32,53.07) v1(289.36,27.23) v1(289.58,53.07) v1(289.72,18.05) v1(290.2,34.05) v1(290.27,26.11) v1(290.47,35.21) v1(290.62,24.27) v1(291.37,3.81) v1(291.41,27.28) v1(291.87,34.07) v1(292.48,3.8) v1(292.52,29.13) v1(292.65,32.69) v1(292.64,31.13) v1(292.71,26.61) v1(292.79,35.29) v1(293.46,30.45) v1(293.57,33.41) v1(293.53,32.1) v1(293.57,14.39) v1(293.61,14.13) v1(293.76,13.08) v1(293.77,12.8) v1(293.8,27.51) v1(293.98,9.3) v1(293.99,9.03) v1(294.4,32.82) v1(294.47,31.03) v1(294.55,28.99) v1(294.6,26.66) v1(294.81,35.36) v1(294.88,17.52) v1(294.89,17.24) v1(295.67,17.55) v1(295.65,16.72) v1(295.7,17.14) v3(1.67,5.74) v3(1.82,23.22) v3(1.98,19.79) v3(1.88,17.77) v3(2.06,43.68) v3(1.99,26.69) v3(2.03,16.14) v3(2.06,12.07) v3(2.05,4.27) v3(2.14,63) v3(2.16,46.96) v3(2.3,36.61) v3(2.46,60.58) v3(2.64,18.66) v3(2.65,16.8) v3(2.71,30.25) v3(2.81,65.45) v3(3.18,28.35) v3(3.54,24.9) v3(3.52,5.39) v3(3.66,33.27) v3(3.82,3.96) v3(3.89,63.14) v3(4.32,13.22) v3(4.58,11.27) v3(4.94,68.41) v3(5.09,5.99) v3(5.68,72.33) v3(5.72,70.38) v3(6.29,12.4) v3(6.3,10.53) v3(6.29,8.85) v3(6.41,7.14) v3(7.09,4.62) v3(7.63,44.61) v3(7.66,43.39) v3(7.63,39.55) v3(8.08,59.6) v3(8.1,60.95) v3(8.13,48.32) v3(8.23,49.6) v3(8.52,39.41) v3(8.6,66.14) v3(8.6,54.9) v3(8.7,40.88) v3(8.87,45.74) v3(8.87,44.34) v3(8.96,59.06) v3(9.03,65.13) v3(9.01,56.36) v3(9.08,66.97) v3(9.49,61.18) v3(9.62,63.23) v3(9.64,47.76) v3(10.03,62.38) v3(10.05,45.33) v3(10.06,43.35) v3(10.57,54.12) v3(10.97,64.98) v3(10.94,63.61) v3(11.56,64.83) v3(11.67,46.53) v3(12.3,48.68) v3(12.63,60.42) v3(13.46,66.02) v3(14.91,65.66) v3(15.06,59.67) v3(15.88,59.72) v3(16.7,48.1) v3(16.76,46.33) v3(16.84,59.72) v3(17.33,65.64) v3(17.74,59.7) v3(17.74,29.55) v3(17.8,31.67) v3(17.98,30.81) v3(17.98,30.31) v3(18.25,66.65) v3(18.27,31.65) v3(18.24,29.54) v3(18.63,59.71) v3(18.71,31.65) v3(18.7,29.52) v3(18.88,64.58) v3(19.23,31.62) v3(19.2,29.53) v3(19.58,59.72) v3(19.75,31.66) v3(19.72,29.53) v3(19.98,31.31) v3(19.98,30.81) v3(19.98,30.31) v3(20.42,59.7) v3(21.71,54.64) v3(22.05,59.7) v3(22.75,41.07) v3(22.88,43.84) v3(22.91,39.31) v3(23.01,59.68) v3(23.2,54.85) v3(23.53,43.84) v3(23.96,40.91) v3(24.06,59.69) v3(25.12,59.73) v3(25.16,40.92) v3(25.43,43.92) v3(25.87,48.99) v3(25.87,43.67) v3(25.98,46.03) v3(26.16,59.73) v3(26.53,40.91) v3(26.8,49.1) v3(28.19,41.11) v3(29.83,42.44) v3(29.81,40.85) v3(31.03,51.26) v3(31.04,49.84) v3(31.01,45.41) v3(31.13,47.12) v3(31.36,52.89) v3(31.72,33.94) v3(31.81,42.99) v3(31.81,41.83) v3(32.02,33.04) v3(32.02,32.54) v3(32.15,33.95) v3(32.45,38.79) v3(32.57,33.96) v3(32.54,33.49) v3(32.56,33.04) v3(32.56,32.58) v3(32.88,45.85) v3(32.94,43.41) v3(33.05,49.34) v3(33,47.24) v3(33,44.7) v3(33,32.99) v3(33.28,51.39) v3(33.23,41.18) v3(33.28,40.01) v3(33.45,52.56) v3(33.58,48.24) v3(33.9,50.44) v3(34.24,49.23) v3(34.53,47.03) v3(34.76,53.57) v3(35.96,56.87) v3(37.18,54.38) v3(37.33,56.9) v3(38.41,55.67) v3(38.52,56.98) v3(39.25,17.89) v3(48.03,44.4) v3(48.45,44.41) v3(63.91,5.59) v3(67.09,11.25) v3(75.26,9.24) v3(75.8,9.79) v3(83.13,27.13) v3(83.53,28.54) v3(83.53,25.91) v3(91.36,50.53) v3(91.47,51.84) v3(92.56,49.14) v3(92.59,48.09) v3(93.21,47.17) v3(93.38,24.43) v3(93.51,39.18) v3(93.67,52.04) v3(93.59,50.51) v3(93.74,53.1) v3(94.01,48.95) v3(94.36,48.04) v3(94.67,71.78) v3(95.12,49.91) v3(95.45,53.17) v3(95.39,52.11) v3(95.6,51.2) v3(95.92,52.39) v3(96.29,28.78) v3(96.54,39.47) v3(97.68,67.38) v3(98.65,49.27) v3(98.68,50.1) v3(98.68,45.51) v3(99.45,50.92) v3(99.64,41.68) v3(99.64,39.56) v3(99.68,37.81) v3(99.71,49.55) v3(100.87,41.81) v3(100.84,40.17) v3(100.81,38.96) v3(100.91,24.81) v3(101.32,24.83) v3(102.02,41.82) v3(102.06,39.99) v3(102.68,44.71) v3(102.72,44.24) v3(103.02,43.94) v3(103.68,45.31) v3(104.12,42.21) v3(104.22,40.47) v3(104.2,38.76) v3(105.11,59.89) v3(105.37,41.34) v3(105.46,43.17) v3(105.63,59.87) v3(106.19,59.89) v3(106.81,67.31) v3(106.78,42.1) v3(106.82,40.28) v3(106.82,39.13) v3(107.06,68.46) v3(107.47,36.99) v3(107.49,45.51) v3(107.61,38.11) v3(107.71,39.82) v3(107.84,35.07) v3(107.87,34.64) v3(107.89,47.07) v3(108.26,68.97) v3(108.53,67.04) v3(109.97,70.93) v3(110.08,68.56) v3(111.1,29.4) v3(111.23,41.92) v3(111.26,40.29) v3(111.26,38.56) v3(111.41,29.1) v3(111.59,27.99) v3(111.59,27.55) v3(111.59,27.1) v3(111.62,26.67) v3(112.92,39.89) v3(112.98,42.06) v3(113.57,30.9) v3(113.61,30.49) v3(113.61,7.9) v3(113.88,71.54) v3(113.84,69.79) v3(113.93,68.14) v3(114.08,38.12) v3(113.99,30.83) v3(114.08,7.59) v3(114.09,40.16) v3(114.17,36.64) v3(114.17,36.23) v3(114.17,35.82) v3(114.17,35.41) v3(114.17,29.52) v3(114.25,41.76) v3(114.33,70.61) v3(114.55,43.47) v3(114.5,7.58) v3(114.86,69.42) v3(114.92,7.57) v3(115.16,71) v3(115.25,38.87) v3(115.38,63.05) v3(115.64,68.43) v3(115.97,40.43) v3(116.36,43.43) v3(116.47,41.97) v3(116.96,38.99) v3(116.97,37.83) v3(117.09,62.85) v3(117.58,62.47) v3(118.01,40.13) v3(118.09,42.02) v3(118.73,43.37) v3(119.49,42.04) v3(119.52,40.13) v3(119.54,38.24) v3(119.54,37.16) v3(119.64,43.6) v3(120.36,41.07) v3(120.37,39.39) v3(120.92,43.4) v3(121.67,37.95) v3(121.88,68.48) v3(121.9,71.44) v3(122.11,63.19) v3(122.41,41.95) v3(122.42,40.84) v3(122.74,70.31) v3(123.33,42.22) v3(123.35,40.33) v3(124.15,42.97) v3(124.17,38.27) v3(124.21,62.67) v3(124.21,41.2) v3(124.22,39.42) v3(124.63,12.37) v3(124.62,11.15) v3(125.04,11.15) v3(125.12,12.37) v3(125.45,11.15) v3(125.6,24.79) v3(125.62,12.37) v3(125.71,38.13) v3(125.77,25.24) v3(126.01,37.82) v3(126.09,68.62) v3(126.38,66.39) v3(126.67,68.61) v3(126.6,67.57) v3(126.91,25.3) v3(127.82,68.61) v3(128.9,64.3) v3(129.08,42.63) v3(129.64,62.43) v3(129.9,41.37) v3(129.88,40.9) v3(130.09,40.54) v3(130.96,26.63) v3(133.18,42.63) v3(135.51,24.04) v3(137.88,24.43) v3(137.99,51.71) v3(138.36,49.79) v3(139.55,35.07) v3(139.67,24.08) v3(139.85,53.13) v3(139.87,34.77) v3(140.05,51.96) v3(140.16,34.45) v3(140.57,31.26) v3(140.58,9.61) v3(140.92,59.39) v3(141.1,35.88) v3(141.45,55.03) v3(141.78,9.62) v3(142.98,53.83) v3(142.98,9.61) v3(144.64,27.53) v3(144.74,61.73) v3(145.12,28.19) v3(145.53,62.92) v3(145.53,61.74) v3(146.39,62.89) v3(146.62,61.77) v3(146.81,60.7) v3(147.56,62.82) v3(151.67,72.8) v3(153.33,11.13) v3(153.85,66.79) v3(153.94,70.7) v3(153.91,69.24) v3(153.98,72.55) v3(155.56,65.67) v3(155.67,67.96) v3(155.61,63.48) v3(155.64,61.36) v3(155.59,59.2) v3(155.74,70.03) v3(157.48,62.26) v3(157.53,58.13) v3(157.58,64.87) v3(159.08,72.32) v3(159.23,56.62) v3(160.62,54.67) v3(161.29,72.29) v3(161.52,67.76) v3(161.68,69.37) v3(161.9,25.8) v3(161.91,24.06) v3(162.05,22.8) v3(162.09,21.12) v3(162.52,18.94) v3(163.15,61.99) v3(163.12,59.31) v3(163.1,31.69) v3(163.11,29.89) v3(164.04,23.94) v3(164.42,72.26) v3(164.62,22.31) v3(164.68,20.63) v3(165.46,25.57) v3(165.53,23.93) v3(165.7,61.97) v3(166.69,72.67) v3(166.82,69) v3(166.8,65.94) v3(168.21,72.04) v3(168.47,67.59) v3(168.45,64.87) v3(168.47,58.61) v3(168.53,70.19) v3(168.5,61.94) v3(168.79,73.75) v3(170,70.89) v3(170.14,29.56) v3(170.14,27.7) v3(170.19,36.01) v3(170.24,31.77) v3(170.36,72.56) v3(170.36,68.89) v3(170.34,66.15) v3(170.36,63.25) v3(170.28,33.65) v3(170.42,59.68) v3(170.44,57.33) v3(170.94,25.57) v3(171.09,36.76) v3(171.09,34.95) v3(171.23,32.88) v3(171.29,31.01) v3(171.33,29.06) v3(171.31,27.04) v3(171.79,16.75) v3(172.11,24.92) v3(172.27,23.09) v3(172.3,16.75) v3(173.22,23.87) v3(174.27,22.09) v3(182.45,12.91) v3(182.59,14.09) v3(222.01,6.12) v3(222.43,6.12) v3(224.5,6.15) v3(225.17,6.15) v3(249.36,11.46) v3(250.38,12.54) v3(264.71,13.36) v3(265.1,17.95) v3(265.86,58.08) v3(265.8,51.29) v3(265.87,21.68) v3(265.84,14.35) v3(265.96,64.09) v3(265.95,59.83) v3(265.92,55.9) v3(265.94,53.66) v3(266.03,61.91) v3(266.02,48.59) v3(266.54,45.49) v3(266.6,42.91) v3(267.21,49.6) v3(267.32,46.03) v3(267.32,44.51) v3(267.46,65.8) v3(267.65,56.69) v3(267.71,60.77) v3(267.71,55.47) v3(267.7,53.7) v3(267.78,52.14) v3(267.79,58.74) v3(267.82,50.38) v3(269.18,60.1) v3(269.43,57.61) v3(269.39,56.05) v3(269.42,54.51) v3(269.68,52.4) v3(270.24,48.24) v3(270.41,46.6) v3(270.55,55.43) v3(270.61,58.13) v3(270.77,52.68) v3(270.87,53.95) v3(271.26,66.96) v3(271.77,66.96) v3(272.2,63.56) v3(273.69,65.58) v3(274.6,54.55) v3(274.74,52.52) v3(274.71,50.81) v3(276.86,55.06) v3(276.78,53.61) v3(276.8,51.89) v3(277.9,36.26) v3(277.89,34.31) v3(278.18,54.59) v3(278.37,52.88) v3(280.92,49.08) v3(281.03,47.81) v3(281.14,45.48) v3(281.52,28.5) v3(281.67,44.57) v3(281.85,32.38) v3(281.99,46.38) v3(283.41,47.55) v3(283.47,3.51) v3(283.95,48.43) v3(283.91,46.29) v3(284.24,48.91) v3(284.32,50.46) v3(284.94,48.31) v3(284.93,46.31) v3(285.55,51.02) v3(286.32,17.77) v3(286.32,17.29) v3(286.42,16.69) v3(286.64,19.69) v3(286.66,16.24) v3(286.73,24.32) v3(286.71,23.13) v3(286.81,17.62) v3(286.97,15.94) v3(287.26,31.48) v3(287.28,17.7) v3(287.26,16.59) v3(287.49,19.68) v3(287.54,14.87) v3(287.53,12.07) v3(287.59,48.24) v3(287.6,46.6) v3(287.77,16.59) v3(287.91,17.86) v3(287.98,14.87) v3(288.16,22.29) v3(288.27,16.58) v3(288.4,18.41) v3(288.74,17.61) v3(288.92,31.47) v3(288.98,17.22) v3(288.98,14.9) v3(288.99,16.78) v3(288.98,16.34) v3(289.25,52.6) v3(289.27,20.05) v3(289.31,18.77) v3(290.39,59.01) v3(293.19,53.31) v3(293.23,27.08) v3(293.43,47.89) v3(293.53,50.49) v3(294.16,52.02) v3(294.13,49.14) v3(294.17,46.88) v3(294.09,26.54) v3(294.63,25.76) v3(294.99,48.02) v3(295.09,50.47) v3(295.24,53.45) v3(295.63,51.98) v3(295.76,49.09) v3(295.94,46.34) v4(1.57,27) v4(1.49,17.17) v4(1.55,14.55) v4(1.61,25.7) v4(1.62,15.75) v4(1.59,13.69) v4(1.6,12.89) v4(1.68,24.34) v4(1.69,18.89) v4(1.9,60.04) v4(2.02,65.36) v4(2.03,61.75) v4(2.15,63.92) v4(2.1,48.81) v4(2.24,24.65) v4(2.36,47.71) v4(2.37,45.51) v4(2.36,19.23) v4(2.37,18.01) v4(2.4,44.07) v4(2.72,48.51) v4(2.69,21.49) v4(2.98,24.59) v4(3.04,47.73) v4(3.07,46.38) v4(3.01,43.31) v4(3.11,64.38) v4(3.14,44.67) v4(3.14,24.33) v4(3.1,18.24) v4(3.2,60.11) v4(3.31,62.37) v4(3.67,47.01) v4(3.72,49.22) v4(3.73,48.05) v4(3.7,45.88) v4(3.85,61.62) v4(3.93,59.92) v4(4.08,63.82) v4(4.21,65.22) v4(4.44,47.15) v4(4.45,3.64) v4(4.48,48.62) v4(4.52,45.9) v4(5.64,5.33) v4(6.07,3.76) v4(6.28,5.67) v4(6.33,11.87) v4(6.71,52.73) v4(7,57.53) v4(7.01,56.23) v4(7.01,54.03) v4(7.17,26.57) v4(7.23,63.56) v4(7.2,62.77) v4(7.24,11.11) v4(7.36,5.37) v4(7.46,63.38) v4(7.41,62.57) v4(7.43,47.02) v4(7.38,46.14) v4(7.46,9.85) v4(7.64,46.14) v4(7.62,10.47) v4(7.71,56.89) v4(7.71,55.02) v4(7.74,52.17) v4(7.7,47.01) v4(7.77,37.66) v4(7.69,8.23) v4(7.82,53.23) v4(8.07,63.58) v4(8.07,62.74) v4(8.02,57.76) v4(8.17,43.11) v4(8.22,40.62) v4(8.23,40.22) v4(8.22,39.8) v4(8.29,63.41) v4(8.35,62.54) v4(8.32,46.95) v4(8.28,46.13) v4(8.47,42.77) v4(8.38,38.56) v4(8.44,10.23) v4(8.56,55.92) v4(8.57,46.2) v4(8.55,43.14) v4(8.57,40.2) v4(8.59,51.16) v4(8.6,46.94) v4(8.61,22.45) v4(8.72,56.73) v4(8.73,52.18) v4(8.94,46.26) v4(8.94,39.98) v4(8.91,37.12) v4(9.15,33.4) v4(9.17,30.18) v4(9.26,3.69) v4(9.76,52.37) v4(9.82,57.14) v4(9.83,56.63) v4(9.83,56.08) v4(9.82,55.33) v4(9.81,54.75) v4(9.78,52.75) v4(9.8,51.89) v4(9.83,47.27) v4(9.84,46.7) v4(9.83,46.15) v4(9.84,45.69) v4(9.81,41.4) v4(9.83,40.77) v4(9.83,40.2) v4(9.86,39.58) v4(9.87,38.64) v4(9.87,38.06) v4(9.82,36.2) v4(9.89,54.24) v4(9.96,42.17) v4(10.07,60.38) v4(10.06,47.76) v4(10.06,42.86) v4(10.48,44.29) v4(10.45,17.94) v4(10.49,33.35) v4(10.58,31.58) v4(10.59,30.2) v4(10.91,65.4) v4(10.94,63.21) v4(11.12,40.01) v4(11.22,46.91) v4(11.37,42.15) v4(11.5,64.41) v4(11.51,3.77) v4(11.67,38.62) v4(11.62,37.18) v4(11.65,35.95) v4(11.65,17.93) v4(11.74,41.15) v4(11.94,33.53) v4(11.99,31.53) v4(12.26,47.8) v4(12.22,39.85) v4(12.22,37.45) v4(12.32,60.73) v4(12.68,42.15) v4(12.68,5.72) v4(12.7,4.62) v4(12.93,38.56) v4(12.98,65.83) v4(13.08,3.7) v4(13.34,40.47) v4(13.29,37.63) v4(13.3,6.19) v4(13.96,40.24) v4(13.94,39.61) v4(13.96,36.83) v4(14.04,3.65) v4(14.15,35.93) v4(14.18,9.28) v4(14.26,57) v4(14.3,28.47) v4(14.33,14.63) v4(14.45,40.25) v4(14.43,39.61) v4(14.56,35.92) v4(14.63,28.47) v4(14.68,9.28) v4(14.73,59.85) v4(14.94,40.93) v4(15.18,9.28) v4(15.25,51.13) v4(15.47,59.85) v4(15.48,37.47) v4(15.41,35.92) v4(15.49,38.1) v4(15.96,40.95) v4(15.97,37.46) v4(15.98,38.1) v4(16.12,35.92) v4(16.34,59.85) v4(16.45,51.63) v4(16.85,35.91) v4(17.3,59.85) v4(17.31,29.12) v4(17.38,40.97) v4(17.59,35.9) v4(17.77,41.52) v4(17.93,37.22) v4(18.22,59.85) v4(18.19,35.89) v4(18.96,40.46) v4(18.88,38.01) v4(18.94,37.15) v4(18.99,39.71) v4(19.05,35.9) v4(19.15,59.85) v4(19.34,29.12) v4(19.75,35.9) v4(19.93,42.02) v4(20.08,59.84) v4(20.13,25.49) v4(20.26,34.6) v4(20.39,25.48) v4(20.48,35.88) v4(20.74,29.12) v4(20.8,59.84) v4(21.22,35.87) v4(21.5,56.32) v4(21.5,55.75) v4(21.6,59.82) v4(21.71,37.2) v4(21.79,39.66) v4(21.98,35.87) v4(22.48,59.82) v4(22.58,57.63) v4(22.86,54.25) v4(22.89,39.66) v4(23.07,15.02) v4(23.15,39.66) v4(23.54,59.81) v4(23.53,35.87) v4(23.67,39.66) v4(23.75,54.67) v4(23.7,11.63) v4(23.77,7.05) v4(24.17,15.22) v4(24.24,39.68) v4(24.23,35.86) v4(24.33,57.61) v4(24.33,56.98) v4(24.3,17.93) v4(24.44,9.67) v4(24.44,8.76) v4(24.58,59.75) v4(24.65,6.99) v4(24.85,53.49) v4(24.87,39.66) v4(24.83,37.08) v4(25.05,16.67) v4(25.33,58.04) v4(25.31,57.77) v4(25.29,57) v4(25.29,56.73) v4(25.49,39.67) v4(25.67,59.81) v4(25.62,55.21) v4(26.14,39.67) v4(26.2,55.24) v4(26.45,35.84) v4(26.86,59.82) v4(26.92,39.67) v4(27.3,35.85) v4(27.45,6.76) v4(27.53,39.67) v4(27.63,37.1) v4(27.96,4.08) v4(28.03,59.67) v4(28.01,35.85) v4(28.18,39.68) v4(28.09,19.7) v4(28.54,59.67) v4(28.61,29.46) v4(28.74,35.83) v4(28.88,29.67) v4(29.25,59.7) v4(29.26,2.18) v4(29.35,67.81) v4(29.38,55.28) v4(29.44,42.54) v4(29.48,35.82) v4(29.5,15.59) v4(29.68,59.7) v4(29.79,29.74) v4(30,51.88) v4(30.11,59.7) v4(30.27,65.29) v4(30.34,20.78) v4(30.61,43.77) v4(30.7,66.77) v4(30.85,68.54) v4(30.82,59.67) v4(30.98,13.61) v4(31.18,22.12) v4(31.18,21.37) v4(31.18,53.61) v4(31.35,26.48) v4(31.4,42.26) v4(31.39,35.86) v4(31.97,43.33) v4(31.91,39.89) v4(31.95,38.71) v4(32.08,61.3) v4(32.12,59.7) v4(32.15,40.88) v4(32.24,39.88) v4(32.43,52.74) v4(32.45,43.3) v4(32.53,14.71) v4(32.72,67.63) v4(32.91,59.7) v4(32.89,35.86) v4(33.16,69.02) v4(33.25,11.19) v4(33.34,72.32) v4(33.43,51.75) v4(33.47,50.43) v4(33.57,70.43) v4(33.5,48.96) v4(33.51,48.59) v4(33.57,43.05) v4(33.57,41.78) v4(33.63,59.64) v4(33.63,58.63) v4(33.62,57.72) v4(33.61,56.99) v4(33.64,56.28) v4(33.58,50.81) v4(33.6,42.44) v4(33.76,45.98) v4(33.84,48.99) v4(33.85,48.47) v4(33.82,46.64) v4(33.83,45.33) v4(33.85,44.79) v4(33.87,44.12) v4(33.85,43.26) v4(34.21,73.7) v4(34.44,71.82) v4(34.45,56.07) v4(34.51,68.97) v4(35.06,3.89) v4(35.08,61.3) v4(35.34,74.13) v4(35.32,3.89) v4(35.42,71.15) v4(35.53,69.87) v4(35.54,65.82) v4(35.56,54.78) v4(35.6,3.89) v4(35.95,55.8) v4(36.08,23.05) v4(36.58,61.3) v4(36.69,55.68) v4(36.84,3.7) v4(36.89,66.57) v4(37.26,55.68) v4(37.4,42.04) v4(37.63,31.06) v4(37.79,30.82) v4(37.96,55.66) v4(38.04,65.31) v4(38.08,61.3) v4(38.22,21.19) v4(38.29,42.04) v4(38.34,20.96) v4(38.49,66.34) v4(38.57,54.56) v4(38.75,56.06) v4(39.02,31.17) v4(39.02,30.84) v4(39.16,21.18) v4(39.35,20.97) v4(39.3,17.38) v4(39.55,67.81) v4(39.58,61.3) v4(39.5,17.57) v4(40,8.2) v4(40.34,21.23) v4(40.56,21.02) v4(40.67,67.16) v4(40.63,65.36) v4(40.62,1.72) v4(40.87,17.6) v4(40.87,17.34) v4(41.09,65.35) v4(41.08,61.3) v4(41.24,20.99) v4(41.52,21.01) v4(41.67,65.34) v4(41.65,6.03) v4(41.72,58.39) v4(41.79,68.27) v4(42.01,70.7) v4(42.25,69.45) v4(42.25,57.36) v4(42.27,56.22) v4(42.97,3.05) v4(43.46,65.97) v4(43.62,72.75) v4(43.66,67.16) v4(44.06,51.65) v4(44.14,69.6) v4(44.58,61.3) v4(44.63,68.04) v4(44.74,70.62) v4(45.44,67.1) v4(45.56,43.9) v4(46.16,66.14) v4(46.08,61.3) v4(46.43,43.9) v4(46.54,67.94) v4(46.62,69.52) v4(47,70.42) v4(47.11,6.14) v4(47.47,53.55) v4(47.46,43.94) v4(47.84,45.93) v4(48.37,72.61) v4(48.58,61.3) v4(49.23,70.47) v4(49.27,43.94) v4(49.28,19.35) v4(49.37,15.99) v4(49.54,54.52) v4(49.62,69.71) v4(49.72,47.17) v4(50.36,58.99) v4(50.38,58.33) v4(50.5,64.75) v4(50.5,57.77) v4(50.58,17.45) v4(50.6,1.61) v4(51.63,16.99) v4(52.66,18.69) v4(52.73,72.84) v4(53.48,62.4) v4(54.56,19.99) v4(54.61,17.51) v4(55.25,68.16) v4(56.07,72.75) v4(56.02,10.28) v4(56.11,68.16) v4(56.51,48.92) v4(56.77,48.92) v4(57.83,72.79) v4(59.33,29.83) v4(60.18,36.8) v4(60.44,36.8) v4(61.77,16.8) v4(61.78,15.62) v4(62.27,2.38) v4(62.4,17.84) v4(63.95,18.66) v4(64.02,2.51) v4(65.59,57.37) v4(65.6,57.08) v4(65.85,57.36) v4(65.87,57.1) v4(65.97,30.46) v4(66.02,35.68) v4(66.15,57.1) v4(66.1,37.71) v4(66.19,57.35) v4(66.25,35.47) v4(66.46,57.36) v4(66.45,57.09) v4(66.53,45.39) v4(66.53,45.11) v4(66.53,44.85) v4(66.52,44.56) v4(66.8,45.37) v4(66.81,45.11) v4(66.81,44.85) v4(66.8,44.56) v4(66.83,39.24) v4(66.83,38.9) v4(66.97,55.45) v4(66.96,55.08) v4(66.97,37.69) v4(67.02,56.86) v4(67.02,56.52) v4(67.01,56.12) v4(67,55.77) v4(67.1,39.24) v4(67.11,38.9) v4(67.27,45.71) v4(67.35,56.83) v4(67.36,56.5) v4(67.37,56.12) v4(67.37,55.78) v4(67.3,55.43) v4(67.29,55.06) v4(67.33,47.49) v4(67.33,47.16) v4(67.33,46.76) v4(67.31,46.41) v4(67.29,46.08) v4(67.67,55.42) v4(67.65,55.05) v4(67.67,47.47) v4(67.68,47.13) v4(67.62,46.07) v4(67.6,45.7) v4(67.59,39.24) v4(67.6,38.9) v4(67.72,56.83) v4(67.74,56.51) v4(67.72,56.08) v4(67.69,55.76) v4(67.69,46.75) v4(67.68,46.42) v4(67.85,40.36) v4(67.87,39.24) v4(67.88,38.9) v4(67.79,29.36) v4(67.97,45.69) v4(68.04,47.46) v4(68.05,47.15) v4(68.04,46.72) v4(68,46.4) v4(67.98,46.06) v4(68.12,40.37) v4(68.15,39.23) v4(68.16,38.91) v4(68.4,40.36) v4(68.43,39.24) v4(68.43,38.9) v4(68.67,29.35) v4(68.71,39.23) v4(68.72,38.89) v4(68.99,39.23) v4(69,38.92) v4(69.27,39.25) v4(69.27,38.91) v4(69.55,39.25) v4(69.56,38.91) v4(69.55,29.36) v4(69.83,39.25) v4(69.84,38.93) v4(70.55,36.74) v4(70.74,44.93) v4(70.74,36.56) v4(70.91,36.31) v4(73.27,37.74) v4(73.44,37.49) v4(73.61,37.71) v4(75.58,9.38) v4(75.58,10.66) v4(75.88,10.66) v4(75.92,8.74) v4(76.28,9.1) v4(76.43,9.31) v4(76.6,9.5) v4(76.78,9.68) v4(76.97,9.86) v4(80.26,58.82) v4(80.54,58.81) v4(80.59,40.84) v4(80.84,40.85) v4(81.09,40.84) v4(81.57,58.82) v4(81.83,58.81) v4(82.1,8.9) v4(82.39,10.17) v4(82.41,8.91) v4(82.66,10.17) v4(82.92,10.17) v4(83.06,8.9) v4(83.19,10.17) v4(83.34,8.9) v4(83.75,10.17) v4(85.13,40.07) v4(85.12,39.79) v4(85.12,39.51) v4(85.38,39.92) v4(85.37,39.64) v4(85.37,39.36) v4(85.38,47.26) v4(85.68,47.26) v4(85.96,47.26) v4(86.57,50.25) v4(86.7,47.27) v4(86.83,50.27) v4(86.95,47.28) v4(87.08,50.25) v4(87.21,47.27) v4(87.77,47.25) v4(87.8,50.27) v4(88.05,50.26) v4(88.03,47.27) v4(88.33,50.25) v4(88.28,47.25) v4(89.01,50.27) v4(89.04,47.32) v4(89.26,50.26) v4(89.3,47.34) v4(89.52,50.27) v4(89.55,47.32) v4(90.23,50.28) v4(90.22,47.3) v4(90.19,8.88) v4(90.48,63.1) v4(90.48,47.31) v4(90.49,50.28) v4(90.57,8.88) v4(90.75,63.1) v4(90.74,50.28) v4(90.73,47.3) v4(90.95,8.88) v4(91.81,63.32) v4(92.09,63.32) v4(92.32,50.14) v4(92.57,52.15) v4(92.79,52.44) v4(93.11,63.37) v4(93.2,50.14) v4(93.39,63.37) v4(93.73,48.64) v4(93.9,52.76) v4(93.91,51.78) v4(94.06,62.03) v4(94.13,47.57) v4(94.35,50.07) v4(94.28,49.28) v4(94.45,50.83) v4(95.17,51.79) v4(95.17,49.05) v4(95.21,50.24) v4(95.78,52.75) v4(96.52,70.84) v4(96.92,73.12) v4(96.93,63.81) v4(97.26,52.41) v4(97.26,47.4) v4(97.31,70.91) v4(97.4,66.23) v4(98.69,63.88) v4(98.69,63.23) v4(100.01,41.51) v4(100.07,40.22) v4(101.23,40.28) v4(101.35,43.92) v4(101.34,39.02) v4(101.39,41.56) v4(102.38,41.54) v4(102.43,40.32) v4(103.71,43.92) v4(103.77,41.3) v4(103.82,42.41) v4(103.87,40.32) v4(103.85,39.08) v4(105.6,42.85) v4(105.77,41.53) v4(106.31,43.92) v4(106.9,42.41) v4(107.05,67.06) v4(107.14,40.07) v4(107.25,41.13) v4(107.43,67.89) v4(107.83,37) v4(108.04,39.88) v4(108.04,38.07) v4(108.3,66.64) v4(108.62,67.95) v4(108.94,69.03) v4(108.9,68.56) v4(109.21,72.07) v4(110.55,72.06) v4(110.75,38.98) v4(110.83,40.52) v4(110.9,41.93) v4(110.89,9.95) v4(111.27,9.95) v4(111.65,9.95) v4(112.5,42.4) v4(112.53,41.41) v4(112.51,40.04) v4(113.23,70.97) v4(113.26,69.84) v4(113.24,69.4) v4(113.35,7.64) v4(113.48,43.92) v4(113.52,68.26) v4(113.62,7.51) v4(113.72,38) v4(114.22,10.05) v4(114.34,69.74) v4(114.29,8.01) v4(114.41,69.17) v4(114.47,67.71) v4(114.46,40.24) v4(114.38,39.88) v4(114.47,10.05) v4(114.42,8.24) v4(114.56,8) v4(114.64,41.92) v4(114.77,8.25) v4(114.84,8) v4(115.13,11.59) v4(115.11,10.07) v4(115.28,7.49) v4(115.19,2.74) v4(115.37,10.07) v4(115.28,7.78) v4(115.6,42.51) v4(115.67,40.65) v4(115.68,39.75) v4(116.08,43.92) v4(116.13,68.27) v4(116.09,11.58) v4(116.35,10.07) v4(116.42,67.84) v4(116.56,41.64) v4(116.63,69.09) v4(116.67,37.99) v4(116.98,71.35) v4(117.01,40.36) v4(117.36,73.18) v4(117.34,10.7) v4(117.34,10.42) v4(117.34,9.49) v4(117.34,9.21) v4(117.39,70.52) v4(117.48,71.36) v4(117.59,10.7) v4(117.59,10.42) v4(117.59,9.49) v4(117.59,9.21) v4(117.7,41.99) v4(117.91,8.3) v4(118.06,2.48) v4(118.43,43.92) v4(118.42,41.03) v4(118.52,71.95) v4(118.81,39.2) v4(118.86,37.95) v4(118.89,40.25) v4(119.11,71.38) v4(119.13,42.05) v4(119.17,2.44) v4(119.27,66.72) v4(119.5,67.16) v4(119.67,73.16) v4(119.59,72.22) v4(119.74,71.37) v4(120.04,2.44) v4(120.13,67.69) v4(120.18,69.12) v4(120.85,69.27) v4(120.84,68.5) v4(121.06,43.92) v4(121.05,41.89) v4(121.02,41.05) v4(121.07,39.65) v4(121.17,12.28) v4(121.11,11.37) v4(121.19,62.85) v4(121.32,38.07) v4(121.45,71.21) v4(121.46,11.37) v4(121.55,12.28) v4(121.8,42.04) v4(121.85,11.37) v4(121.88,40.85) v4(121.93,12.28) v4(122.1,62.85) v4(122.15,11.37) v4(122.28,12.28) v4(122.47,11.37) v4(122.62,62.98) v4(122.63,12.28) v4(122.69,69.31) v4(122.77,11.37) v4(122.95,42.09) v4(122.89,41.12) v4(122.93,12.28) v4(123.06,11.37) v4(123.24,12.28) v4(123.34,11.37) v4(123.41,43.92) v4(123.59,12.28) v4(123.93,62.85) v4(123.92,12.28) v4(124.66,40.77) v4(124.59,39.4) v4(124.71,41.45) v4(124.84,62.85) v4(125.43,67.52) v4(126.43,38.97) v4(126.75,67.08) v4(126.84,40.47) v4(127.62,67.51) v4(127.78,2.61) v4(128.02,2.74) v4(128.94,40.72) v4(129.26,38.8) v4(133.77,9.5) v4(134.66,9.49) v4(135.3,64.92) v4(135.84,73.88) v4(135.82,9.6) v4(136.36,38.82) v4(136.76,9.57) v4(137.15,73.86) v4(137.32,72.32) v4(138.04,63.9) v4(138.2,72.81) v4(138.33,65.63) v4(138.34,64.23) v4(138.5,51.09) v4(139.1,38.87) v4(139.27,52.1) v4(139.41,65.59) v4(139.66,51.14) v4(139.77,64.27) v4(139.87,73.82) v4(139.99,38.87) v4(140.01,13.18) v4(140.16,64.04) v4(140.16,63.46) v4(140.22,62.94) v4(140.21,62.29) v4(140.25,61.64) v4(140.29,13.18) v4(140.54,13.18) v4(140.69,65.5) v4(140.92,71.65) v4(141.02,59.76) v4(141.18,13.19) v4(141.3,72.83) v4(141.46,13.19) v4(141.67,65.08) v4(141.74,13.19) v4(141.91,54.76) v4(142.08,71.65) v4(142.12,64.55) v4(142.15,54.85) v4(142.53,74.13) v4(143.45,60.71) v4(144.36,61.65) v4(144.29,3.69) v4(144.4,74.15) v4(144.69,62.89) v4(145,2.97) v4(145.53,63.33) v4(145.56,61.05) v4(145.55,60.39) v4(145.82,13.79) v4(145.91,61.74) v4(145.9,16.05) v4(145.89,2.08) v4(146.1,13.8) v4(146.18,16.05) v4(146.39,60.69) v4(146.84,16.05) v4(146.94,58.89) v4(146.97,1.69) v4(147.02,61.79) v4(146.99,57.41) v4(147.1,16.04) v4(148.24,1.69) v4(149.51,1.69) v4(150.27,11.87) v4(150.7,58.21) v4(150.7,57.95) v4(150.84,52.7) v4(150.78,1.69) v4(150.95,58.12) v4(151.12,52.69) v4(151.27,40.93) v4(151.23,40.15) v4(151.23,39.86) v4(151.28,40.62) v4(151.63,13.3) v4(151.91,13.3) v4(152.05,1.69) v4(152.19,61.75) v4(152.9,54.7) v4(153.07,54.46) v4(153.02,5.71) v4(153.09,73.25) v4(153.13,41.39) v4(153.13,41.04) v4(153.11,40.75) v4(153.1,40.44) v4(153.1,39.97) v4(153.08,4.55) v4(153.22,4.8) v4(153.37,6.1) v4(153.34,5.72) v4(153.34,4.55) v4(153.49,4.79) v4(153.64,6.09) v4(153.6,4.54) v4(153.69,5.72) v4(153.77,4.78) v4(153.87,4.53) v4(153.9,6.08) v4(153.96,5.7) v4(153.89,1.67) v4(155.11,1.64) v4(156.06,56.16) v4(156.21,1.63) v4(156.38,56.15) v4(156.76,63.25) v4(156.96,45.73) v4(157.26,73.99) v4(157.35,68.23) v4(157.37,66.92) v4(157.31,65.76) v4(157.52,67.89) v4(157.54,66.57) v4(157.63,65.73) v4(157.66,50.76) v4(157.82,50.53) v4(158.15,13.27) v4(158.32,43.67) v4(158.65,68.2) v4(158.62,50.73) v4(158.68,42.53) v4(158.82,67.86) v4(158.91,50.55) v4(159.38,58.48) v4(159.38,58.76) v4(159.5,37.3) v4(159.5,16.6) v4(159.67,37.09) v4(159.84,50.69) v4(160.15,50.58) v4(160.28,36.2) v4(160.28,35.7) v4(160.28,35.2) v4(160.28,31.7) v4(160.28,30.2) v4(160.28,28.7) v4(160.28,27.2) v4(160.28,25.7) v4(160.28,24.2) v4(160.28,22.7) v4(160.28,21.2) v4(160.28,19.7) v4(160.28,18.2) v4(160.28,17.7) v4(160.78,66.03) v4(160.75,4.07) v4(160.78,6.3) v4(161.22,59.12) v4(161.36,25.6) v4(161.37,24.21) v4(161.34,20.01) v4(161.46,21.43) v4(161.54,22.53) v4(161.5,18.83) v4(161.67,66.03) v4(162.08,31.4) v4(162.08,30.41) v4(162.5,56.87) v4(163.17,23) v4(163.17,20.33) v4(163.6,36.78) v4(163.6,36.28) v4(163.6,35.78) v4(163.7,1.73) v4(164.26,14.83) v4(164.2,9.86) v4(164.31,14.08) v4(164.38,24.35) v4(164.39,7.77) v4(164.67,25.46) v4(164.65,7.77) v4(164.83,51.77) v4(164.85,51.01) v4(164.85,6.8) v4(165.27,2.7) v4(165.34,9.18) v4(165.67,55.72) v4(165.69,57.35) v4(165.71,52.46) v4(165.88,55.53) v4(165.92,52.26) v4(166.1,37.78) v4(166.1,26.28) v4(166.14,6.6) v4(166.21,7.32) v4(166.7,52.34) v4(166.91,52.15) v4(166.95,41.04) v4(166.92,12.43) v4(167.07,56.11) v4(167.06,55.84) v4(167.05,14.84) v4(167.81,14.9) v4(167.83,11.38) v4(168.44,40.1) v4(168.8,21.95) v4(168.8,21.42) v4(169.01,20.78) v4(169.01,20.25) v4(169.72,2.1) v4(170.05,16.7) v4(170.05,11.34) v4(171.26,8.08) v4(172.56,20.19) v4(172.98,5.2) v4(173.06,20.11) v4(174.35,12.64) v4(174.7,9.74) v4(175.5,15.98) v4(175.56,12.07) v4(176.13,12.06) v4(177.45,11.8) v4(178.3,10.74) v4(178.53,10.88) v4(179.19,13.09) v4(180.65,5.61) v4(191.57,9.3) v4(192.25,9.3) v4(194.48,9.48) v4(194.74,9.48) v4(194.76,2.89) v4(195.03,2.89) v4(195.38,9.47) v4(195.64,9.47) v4(196.27,9.5) v4(196.53,9.5) v4(197.16,9.5) v4(197.42,9.5) v4(197.44,3.83) v4(197.72,3.83) v4(198.02,9.5) v4(198.28,9.5) v4(199.8,3.75) v4(200.1,3.74) v4(200.67,3.74) v4(200.98,3.74) v4(203.66,7.72) v4(204.83,1.82) v4(209.13,5.7) v4(210.11,3.54) v4(210.22,11.03) v4(210.52,4.45) v4(213.8,2.71) v4(215.51,1.72) v4(215.7,4.01) v4(219.34,13.58) v4(246.93,9.52) v4(247.53,2.63) v4(247.9,9.5) v4(247.91,2.63) v4(248.29,2.63) v4(248.78,9.51) v4(252.37,7.44) v4(252.63,7.43) v4(252.71,12.39) v4(252.89,7.44) v4(255.5,9.23) v4(257.15,5.73) v4(257.16,5.48) v4(257.16,5.2) v4(260.81,11.17) v4(261.45,9.23) v4(262.83,9.56) v4(262.79,8.24) v4(263.58,7.91) v4(263.69,10.98) v4(263.8,9.1) v4(264.78,8.51) v4(264.82,10.06) v4(264.94,10.97) v4(265.36,64.16) v4(265.41,67.26) v4(265.41,66.26) v4(266.1,10.34) v4(266.1,9.76) v4(266.36,65.19) v4(266.29,13.16) v4(266.79,6.38) v4(266.93,12.86) v4(267.2,66.53) v4(267.26,4.86) v4(267.29,3.68) v4(267.3,2.78) v4(267.66,12.71) v4(268.33,58.42) v4(268.42,67.06) v4(268.42,66.17) v4(268.42,65.28) v4(268.43,64.38) v4(268.41,57.36) v4(268.44,9.56) v4(268.85,59.23) v4(268.92,52.57) v4(268.92,52.07) v4(268.92,51.57) v4(268.92,51.07) v4(268.92,50.57) v4(268.92,50.07) v4(268.92,49.57) v4(268.92,49.07) v4(268.92,48.57) v4(268.92,48.07) v4(268.92,47.57) v4(268.92,47.07) v4(268.92,46.57) v4(268.92,46.07) v4(268.92,45.57) v4(268.92,45.07) v4(268.92,44.57) v4(268.92,44.07) v4(268.92,43.57) v4(268.92,43.07) v4(269.02,53.32) v4(269.02,42.32) v4(269.53,12.39) v4(269.68,58.34) v4(269.77,42.22) v4(269.85,56.91) v4(270.12,59.29) v4(270.14,12.38) v4(270.27,63.49) v4(270.27,42.22) v4(270.77,42.22) v4(270.78,2.16) v4(270.77,1.87) v4(270.95,56.67) v4(271.21,59.32) v4(271.38,1.88) v4(271.38,2.18) v4(271.84,56.66) v4(272.28,53.44) v4(272.27,42.22) v4(272.2,13.37) v4(272.57,2.29) v4(272.72,2.05) v4(273.47,57.21) v4(273.77,42.22) v4(274.55,20.36) v4(274.55,19.98) v4(274.55,19.6) v4(274.66,67.11) v4(274.6,27.19) v4(274.6,26.81) v4(275.17,57.3) v4(275.09,4.38) v4(275.27,56.34) v4(275.42,57.39) v4(276.09,55.91) v4(276.11,55.53) v4(276.6,16.86) v4(276.77,42.22) v4(276.97,16.86) v4(277.06,10.48) v4(277.18,11.39) v4(277.21,35.83) v4(277.21,9.72) v4(277.2,8.65) v4(277.38,39.43) v4(277.38,34.36) v4(277.61,31.04) v4(277.61,30.77) v4(277.62,30.49) v4(277.76,53.44) v4(277.96,21.35) v4(277.96,21.08) v4(277.93,20.01) v4(277.93,19.72) v4(277.94,19.45) v4(277.95,18.97) v4(279.02,10.6) v4(279.01,9.99) v4(279.26,53.42) v4(280.1,10.36) v4(280.41,39.22) v4(280.41,38.93) v4(280.41,38.64) v4(280.52,38.16) v4(280.51,12.9) v4(280.66,9.59) v4(280.65,8.97) v4(280.58,4.46) v4(280.76,53.42) v4(280.71,20.15) v4(281.25,28.25) v4(281.43,16.07) v4(281.43,14.71) v4(281.61,23.59) v4(281.88,38.45) v4(282.12,29.43) v4(282.15,15.71) v4(282.26,53.42) v4(282.21,14.79) v4(282.3,16.65) v4(282.41,17.74) v4(282.58,18.5) v4(282.76,8.09) v4(282.87,29.32) v4(283.03,30.75) v4(283.11,32.24) v4(283.24,33.67) v4(283.22,31.48) v4(283.35,32.85) v4(283.33,30.74) v4(283.76,29.32) v4(283.92,35.17) v4(284.04,53.32) v4(284.02,42.32) v4(283.99,21.08) v4(284.12,51.07) v4(284.12,46.57) v4(284.15,32.18) v4(284.15,31.6) v4(284.47,22.97) v4(284.41,11.39) v4(284.71,3.59) v4(285.02,18.83) v4(285.02,13.82) v4(285.2,11.46) v4(285.4,24.48) v4(285.41,22.96) v4(285.5,22.29) v4(285.98,50.5) v4(285.98,47.85) v4(285.94,21.39) v4(286.11,29.47) v4(286.27,15.48) v4(286.95,49.05) v4(287.06,46.95) v4(287,19.37) v4(287.04,17.94) v4(287.2,49.18) v4(287.31,37.84) v4(287.52,17.92) v4(287.52,16.83) v4(287.52,16.33) v4(287.61,24.39) v4(287.64,23.03) v4(287.6,20.18) v4(287.77,19.41) v4(287.75,16.09) v4(287.8,50.15) v4(287.8,49.28) v4(288.08,49.94) v4(288.08,49.08) v4(288.02,16.83) v4(288.02,16.33) v4(288.09,30.8) v4(288.09,19.96) v4(288.23,17.94) v4(288.27,16.11) v4(288.33,59.41) v4(288.3,17.69) v4(288.48,17.94) v4(288.52,17.33) v4(288.52,16.83) v4(288.52,16.33) v4(288.52,15.32) v4(288.56,14.97) v4(288.56,14.69) v4(288.52,14.32) v4(288.58,46.95) v4(288.71,50.13) v4(288.7,49.11) v4(288.88,24.14) v4(288.98,49.94) v4(288.98,49.3) v4(288.89,15.91) v4(288.89,15.34) v4(289.04,15.65) v4(289.22,22.07) v4(289.38,59.41) v4(289.6,22.01) v4(289.6,21.75) v4(289.74,69.12) v4(289.76,24.19) v4(289.89,70.28) v4(289.92,37.79) v4(290.1,58.22) v4(290.1,57.75) v4(290.1,57.27) v4(290.53,59.4) v4(290.67,57.86) v4(290.9,57.11) v4(291.13,70.35) v4(291.66,28.75) v4(292.34,52.72) v4(292.34,51.27) v4(292.32,49.76) v4(292.32,48.56) v4(292.34,47.61) v4(292.52,30.94) v4(293.04,34.41) v4(293.04,33.84) v4(293.17,16.78) v4(293.17,16.52) v4(293.13,13.21) v4(293.13,12.96) v4(293.26,15.65) v4(293.26,15.39) v4(293.26,15.14) v4(293.18,14.44) v4(293.18,14.18) v4(293.18,13.93) v4(293.33,52.21) v4(293.38,49.41) v4(293.33,36.21) v4(293.33,35.93) v4(293.36,35.28) v4(293.36,35.01) v4(293.45,46.96) v4(294.19,53.23) v4(294.27,51.08) v4(294.23,48.04) v4(295.15,52.32) v4(295.12,51.23) v4(295.16,14.41) v4(295.2,49.4) v4(295.48,63.72) v4(295.54,17.84) v4(295.56,16.95) v4(295.56,13.67) v4(295.61,47.79) v5(31.07,46.3) v5(31.06,45.97) v5(31.07,44.67) v5(31.04,41.86) v5(31.1,44.24) v5(31.08,43.29) v5(31.11,42.75) v5(31.3,52.14) v5(31.33,51.72) v5(31.34,50.79) v5(31.34,50.23) v5(31.34,44.47) v5(31.28,43.73) v5(32.83,52.28) v5(32.82,51.61) v5(32.86,50.83) v5(32.84,50.27) v5(32.85,47.1) v5(32.87,46.5) v5(32.88,45.64) v5(32.86,45) v5(32.87,44.37) v5(32.87,43.74) v5(32.94,49.8) v5(32.94,49.38) v5(32.9,48.95) v5(32.92,48.43) v5(32.9,47.71) v5(137.76,63.54) v6(29.13,39.87) v6(30.22,46.2) v6(30.27,44.55) v6(30.22,43.32) v6(30.23,42.79) v6(30.31,42.29) v6(31.97,48.89) v6(31.93,48.39) v6(32.06,46.78) v6(32.03,45.36) v6(32.1,49.96) v6(32.1,49.6) v6(32.1,47.73) v6(32.09,44.7) v6(80.81,4.91) v6(80.85,3.91) v6(82.08,4.91) v6(82.12,4.02) v6(83.35,4.91) v6(83.39,4.02) v6(84.62,4.91) v6(84.66,4.02) v6(85.89,4.91) v6(85.93,4.02) v6(87.02,2.14) v6(87.16,4.91) v6(87.2,4.02) v6(88.43,4.91) v6(88.47,4.02) v6(89.09,2.13) v6(89.66,3.09) v6(89.8,4.24) v6(90.81,1.95) v6(90.81,0.93) v6(90.88,3.16) v6(92.08,1.95) v6(92.08,0.93) v6(93.35,1.95) v6(93.35,0.93) v6(94.62,1.95) v6(94.62,0.93) v6(95.89,1.95) v6(95.89,0.93) v6(97.16,1.95) v6(97.16,0.93) v6(98.43,1.95) v6(98.43,0.93) v6(99.7,1.95) v6(99.7,0.93) v6(100.97,1.95) v6(100.97,0.93) v6(102.24,1.95) v6(103.51,1.95) v6(104.78,1.95) v6(106.05,1.95) v6(107.32,1.95) v6(108.59,1.95) v6(109.86,1.95) v6(111.13,1.95) v6(112.4,1.95) v6(113.67,1.95) v6(114.94,1.95) v6(116.21,1.95) v6(117.48,1.95) v6(118.75,1.95) v6(120.02,1.95) v6(121.29,1.95) v6(122.56,1.95) v6(123.83,1.95) v6(125.1,1.95) v6(126.37,1.95) v6(127.64,1.95) v6(128.7,2.46) v6(129.12,7.06) v6(129.12,5.79) v6(129.12,4.52) v6(129.12,3.52) v6(129.97,7.88) v6(132.37,43.21) v6(138.91,8.85) v6(140.18,8.85) v6(141.45,8.85) v6(142.72,8.85) v6(143.51,8.19) v6(144.17,7.39) v6(144.17,6.12) v6(144.17,4.85) v6(155.69,41.95) v6(155.72,40.01) v6(155.97,46.1) v6(155.92,38.36) v6(156.35,42.84) v6(156.37,40.89) v6(156.39,44.14) v6(156.57,39.24) v6(156.62,46.99) v6(156.93,37.72) v6(157.05,45.03) v6(157.11,35.73) v6(157.37,41.22) v6(157.48,39.9) v6(157.66,45.94) v6(157.58,38.6) v6(157.78,44.04) v6(157.77,36.61) v6(157.75,33.02) v6(157.78,31.28) v6(157.92,29.59) v6(158.02,42.1) v6(158.14,40.78) v6(158.31,46.82) v6(158.29,35.22) v6(158.43,44.93) v6(158.43,37.92) v6(158.41,33.9) v6(158.43,32.17) v6(158.58,30.47) v6(158.82,27.81) v6(158.94,42.42) v6(158.95,36.1) v6(159.07,45.89) v6(159.09,38.8) v6(159.31,41.56) v6(159.47,28.7) v6(159.61,29.99) v6(159.72,46.78) v6(159.73,25.3) v6(159.74,22.71) v6(159.71,20.92) v6(159.76,18.11) v6(159.97,42.44) v6(160.11,33.5) v6(160.27,30.87) v6(160.37,21.81) v6(160.38,26.18) v6(160.4,23.6) v6(160.41,18.99) v6(160.77,34.38) v6(160.93,32.39) v6(161.02,16.67) v6(161.1,29.89) v6(161.59,33.28) v6(161.64,26.96) v6(161.68,17.56) v6(161.76,30.77) v6(162.3,27.85) v6(162.37,16.12) v6(162.63,25.8) v6(162.74,18.01) v6(162.91,23.64) v6(162.94,20.79) v6(163.02,17) v6(163.28,26.68) v6(163.39,18.89) v6(163.57,24.52) v6(170.08,33.28) v6(170.13,35.31) v6(170.17,30.29) v6(170.2,32.18) v6(170.27,27.08) v6(170.3,28.97) v6(170.78,36.19) v6(170.8,34.37) v6(170.85,33.06) v6(170.87,31.24) v6(170.95,29.86) v6(170.97,28.04) v6(171.76,27.12) v6(171.73,25.23) v6(171.92,28.96) v7(11.19,59.96) v7(11.49,59.77) v7(12.2,59.77) v7(12.49,59.61) v7(68.25,8.55) v7(68.49,8.44) v7(70.03,8.52) v7(267.41,18.92) v8(0.57,72.31) v8(0.52,70.68) v8(0.51,68.85) v8(0.54,37.61) v8(0.55,36.63) v8(0.51,29.96) v8(0.51,28.69) v8(0.51,27.42) v8(0.51,26.15) v8(0.51,24.88) v8(0.51,23.61) v8(0.51,22.34) v8(0.51,21.07) v8(0.51,19.8) v8(0.51,18.53) v8(0.51,17.26) v8(0.52,16.55) v8(0.52,15.28) v8(0.52,14.01) v8(0.52,12.74) v8(0.52,11.47) v8(0.52,10.2) v8(0.52,8.93) v8(0.52,7.66) v8(0.52,6.39) v8(0.52,5.12) v8(0.52,3.85) v8(0.52,2.58) v8(0.59,41.02) v8(0.7,57.72) v8(1.02,71.4) v8(1.22,43.54) v8(1.39,66.11) v8(1.39,49.66) v8(1.5,73.62) v8(1.5,64.83) v8(1.5,63.56) v8(1.5,62.29) v8(1.5,61.02) v8(1.5,48.5) v8(1.5,47.23) v8(1.5,45.96) v8(1.5,44.69) v8(1.49,29.99) v8(1.82,72.8) v8(1.82,70) v8(1.82,38.85) v8(1.8,2.51) v8(2.07,8.8) v8(2.32,54.94) v8(2.62,40.25) v8(2.62,37.45) v8(2.87,10.2) v8(2.87,7.4) v8(3.05,33.73) v8(3.01,32.82) v8(3.07,2.51) v8(3.12,56.34) v8(3.12,53.54) v8(3.37,73.62) v8(3.44,72.8) v8(3.44,70) v8(4.24,71.4) v8(4.24,40.25) v8(4.24,37.45) v8(4.34,2.51) v8(4.49,10.2) v8(4.49,7.4) v8(4.74,56.34) v8(4.74,53.54) v8(5.04,38.85) v8(5.11,73.63) v8(5.29,8.8) v8(5.54,54.94) v8(5.61,2.51) v8(6.26,73.64) v8(6.37,57.06) v8(6.5,60.19) v8(6.58,53.3) v8(6.61,43.72) v8(6.76,66.34) v8(6.75,49.81) v8(6.88,2.51) v8(7.12,73.21) v8(7.12,71.94) v8(7.12,70.67) v8(7.12,69.4) v8(7.51,68.51) v8(7.79,4.78) v8(7.89,53.78) v8(8.15,2.51) v8(8.7,68.28) v8(8.96,57.61) v8(8.98,41.54) v8(9.42,2.51) v8(9.97,68.28) v8(10.69,2.51) v8(11.16,44.41) v8(11.24,68.28) v8(11.96,2.51) v8(12.15,58.41) v8(12.17,46.11) v8(12.22,67.49) v8(12.34,56.28) v8(12.47,63.88) v8(12.51,68.28) v8(13.27,45.24) v8(13.23,2.51) v8(13.3,39.16) v8(13.78,68.28) v8(13.88,40.92) v8(14.27,46.27) v8(14.21,38.8) v8(14.37,43.11) v8(14.29,41.68) v8(14.5,2.51) v8(14.95,39.94) v8(14.94,39.16) v8(14.94,38.56) v8(15.05,68.28) v8(15.1,36.88) v8(15.57,60.65) v8(15.61,38.79) v8(15.77,2.51) v8(16.32,68.28) v8(17.04,2.51) v8(17.24,37.03) v8(17.59,68.28) v8(18.31,2.51) v8(18.86,68.28) v8(18.86,38.88) v8(19.47,61.81) v8(19.56,2.49) v8(20.13,68.28) v8(20.83,2.49) v8(21.4,68.28) v8(21.87,67.27) v8(22.1,2.49) v8(22.36,63.92) v8(22.67,68.28) v8(23.23,1.92) v8(23.32,0.82) v8(23.49,65.88) v8(23.49,61.96) v8(23.94,68.28) v8(24.22,0.5) v8(24.52,29.09) v8(25.21,68.28) v8(25.49,0.5) v8(25.75,65.88) v8(25.75,61.96) v8(26.43,68.34) v8(26.76,0.5) v8(26.88,63.92) v8(27.15,75.48) v8(27.15,74.21) v8(27.15,72.94) v8(27.15,71.67) v8(27.15,70.4) v8(27.11,69.12) v8(27.54,67.33) v8(28.03,0.5) v8(28.18,75.48) v8(28.68,71.75) v8(28.7,73.99) v8(28.9,69.52) v8(29.25,65.77) v8(29.3,0.5) v8(29.45,75.48) v8(29.91,72.98) v8(29.93,71.1) v8(30.57,0.5) v8(30.72,75.48) v8(30.72,69.61) v8(30.9,73.89) v8(31.14,71.91) v8(31.84,0.5) v8(31.99,75.48) v8(32.13,66.8) v8(32.61,69.47) v8(33.11,0.5) v8(33.26,75.48) v8(34.38,0.5) v8(34.53,75.48) v8(35.8,75.48) v8(36.89,37.62) v8(36.92,35.53) v8(36.91,34.34) v8(36.92,0.5) v8(37.07,75.48) v8(38.19,0.5) v8(38.34,75.48) v8(39.2,49.84) v8(39.2,47.88) v8(39.2,45.91) v8(39.46,0.5) v8(39.61,75.48) v8(39.79,25.48) v8(40.13,28.91) v8(40.27,22.97) v8(40.22,22.38) v8(40.25,21.8) v8(40.29,27.87) v8(40.49,28.43) v8(40.73,0.5) v8(40.88,75.48) v8(40.86,22.97) v8(40.85,22.39) v8(40.87,21.81) v8(41.17,49.84) v8(41.17,47.88) v8(41.17,45.91) v8(41.47,22.97) v8(41.47,22.39) v8(41.46,21.81) v8(42.06,22.97) v8(42.06,22.39) v8(42.06,21.8) v8(42,0.5) v8(42.15,75.48) v8(43.14,49.84) v8(43.14,47.88) v8(43.14,45.91) v8(43.27,0.5) v8(43.42,75.48) v8(44.54,0.5) v8(44.69,75.48) v8(45.81,0.5) v8(45.96,75.48) v8(47.08,0.5) v8(47.23,75.48) v8(47.29,20.09) v8(47.57,34.39) v8(47.6,33.79) v8(47.63,19.39) v8(47.85,20.57) v8(47.89,19.97) v8(48.25,19.32) v8(48.35,0.5) v8(48.5,75.48) v8(48.53,19.91) v8(48.62,24.78) v8(48.71,24.19) v8(49.24,24.81) v8(49.34,25.39) v8(49.34,23.57) v8(49.66,24.08) v8(49.62,0.5) v8(49.77,75.48) v8(50.17,29.57) v8(50.37,23.75) v8(50.46,23.12) v8(50.66,29.22) v8(50.74,26.78) v8(50.85,22.65) v8(50.89,0.5) v8(51.04,75.48) v8(51.02,23.78) v8(52.16,0.5) v8(52.22,23.12) v8(52.23,22.5) v8(52.31,75.48) v8(53.01,50.89) v8(53.01,50.19) v8(53.01,49.48) v8(53.43,0.5) v8(53.58,75.48) v8(53.98,50.89) v8(53.98,50.19) v8(53.98,49.48) v8(53.94,33.69) v8(54.6,33.69) v8(54.7,0.5) v8(54.85,75.48) v8(54.88,22.7) v8(54.88,22.12) v8(54.94,50.89) v8(54.94,50.19) v8(54.94,49.48) v8(54.92,24.76) v8(54.9,24.02) v8(54.9,23.3) v8(55.28,35.9) v8(55.37,62.42) v8(55.89,35.9) v8(55.97,0.5) v8(56.12,75.48) v8(56.34,26.56) v8(56.5,64.38) v8(56.5,60.46) v8(56.92,26.56) v8(57.24,51.11) v8(57.24,0.5) v8(57.39,75.48) v8(57.7,51.72) v8(57.82,51.11) v8(58.27,27.27) v8(58.28,51.72) v8(58.32,27.9) v8(58.41,51.11) v8(58.51,44.51) v8(58.51,0.5) v8(58.66,75.48) v8(58.76,64.38) v8(58.76,60.46) v8(58.87,51.72) v8(58.98,33.6) v8(58.98,28.68) v8(59.01,27.98) v8(59.03,27.29) v8(59.09,44.51) v8(59.45,51.72) v8(59.68,44.51) v8(59.6,34.23) v8(59.6,32.98) v8(59.78,0.5) v8(59.81,28.71) v8(59.83,27.98) v8(59.86,27.29) v8(59.93,75.48) v8(59.89,62.42) v8(60.26,44.51) v8(60.23,33.6) v8(60.48,53.59) v8(60.68,58.18) v8(60.62,27.93) v8(60.61,27.24) v8(60.76,57.44) v8(60.85,44.48) v8(60.99,53.96) v8(60.98,53.26) v8(61.05,0.5) v8(61.2,75.48) v8(61.27,58.13) v8(61.43,44.48) v8(61.42,27.21) v8(62.32,0.5) v8(62.47,75.48) v8(62.9,13.12) v8(62.9,10.89) v8(63.59,0.5) v8(63.74,75.48) v8(64.02,13.12) v8(64.02,12.01) v8(64.02,10.89) v8(64.86,0.5) v8(65.01,75.48) v8(65.13,12.01) v8(65.13,10.89) v8(65.32,62.12) v8(65.32,61.16) v8(65.32,60.2) v8(65.32,59.52) v8(65.57,62.69) v8(65.72,56.61) v8(65.72,56.03) v8(65.72,55.44) v8(65.95,59.49) v8(65.88,52.52) v8(65.88,51.56) v8(65.88,50.6) v8(65.93,49.92) v8(66.03,62.12) v8(66.03,61.16) v8(66.03,60.2) v8(66.13,0.5) v8(66.28,75.48) v8(66.21,62.69) v8(66.31,56.61) v8(66.31,56.03) v8(66.31,55.44) v8(66.56,49.92) v8(66.59,52.52) v8(66.59,51.56) v8(66.59,50.6) v8(66.67,44.05) v8(66.67,43.09) v8(66.67,42.13) v8(66.73,62.12) v8(66.73,61.16) v8(66.73,60.2) v8(66.69,47.71) v8(66.71,47.1) v8(66.71,46.44) v8(66.69,45.85) v8(66.82,62.72) v8(66.97,63.38) v8(66.96,35.23) v8(66.99,54.34) v8(67.04,48.28) v8(67.38,62.38) v8(67.3,52.52) v8(67.3,51.56) v8(67.3,50.6) v8(67.43,44.81) v8(67.38,44.05) v8(67.38,43.09) v8(67.38,42.13) v8(67.4,0.5) v8(67.55,75.48) v8(67.57,63.43) v8(67.5,39.86) v8(67.54,35.24) v8(67.64,70.73) v8(67.61,54.34) v8(67.63,48.29) v8(67.85,62.8) v8(67.81,59.09) v8(67.82,58.46) v8(67.9,19.63) v8(67.9,18.4) v8(67.88,17.06) v8(68.04,44.81) v8(68.09,44.05) v8(68.09,43.09) v8(68.09,42.13) v8(68.09,39.83) v8(68.23,70.73) v8(68.26,63.27) v8(68.25,48.3) v8(68.57,19.6) v8(68.54,18.4) v8(68.51,17.06) v8(68.67,39.83) v8(68.67,0.5) v8(68.76,47.45) v8(68.76,46.81) v8(68.76,46.18) v8(68.73,45.57) v8(68.73,44.88) v8(68.69,44.21) v8(68.82,75.48) v8(68.81,70.73) v8(68.85,48.32) v8(69.26,47.85) v8(69.33,47.23) v8(69.39,70.73) v8(69.69,33.38) v8(69.74,15.78) v8(69.98,70.71) v8(69.95,0.51) v8(70.09,75.48) v8(70.12,45.45) v8(70.12,44.85) v8(70.12,44.25) v8(70.08,16.35) v8(70.21,12) v8(70.32,34.01) v8(70.32,32.76) v8(70.56,70.71) v8(70.71,44.23) v8(70.8,46.66) v8(70.79,12) v8(70.94,33.38) v8(71.21,0.5) v8(71.36,75.48) v8(71.29,44.23) v8(71.41,46.66) v8(71.52,45.5) v8(71.56,44.86) v8(71.72,46.14) v8(71.91,44.23) v8(72,46.65) v8(72.15,44.79) v8(72.25,45.47) v8(72.33,46.14) v8(72.48,0.5) v8(72.5,44.24) v8(72.63,75.48) v8(72.62,46.65) v8(72.81,44.79) v8(72.91,46.13) v8(72.94,45.42) v8(73.02,68.41) v8(73.09,44.21) v8(73.55,44.79) v8(73.61,68.41) v8(73.6,46.08) v8(73.6,45.37) v8(73.72,44.2) v8(73.75,0.5) v8(73.9,75.48) v8(74.15,44.83) v8(74.19,68.41) v8(74.2,46.13) v8(74.2,45.42) v8(74.31,44.2) v8(74.5,26.95) v8(74.78,68.41) v8(74.78,45.26) v8(74.78,44.65) v8(74.79,45.88) v8(75.02,0.5) v8(75.17,75.48) v8(75.36,68.41) v8(75.63,28.91) v8(75.63,24.99) v8(75.95,68.41) v8(76.29,0.5) v8(76.44,75.48) v8(76.54,68.41) v8(77.56,0.5) v8(77.67,56.41) v8(77.71,75.48) v8(77.74,54.47) v8(77.89,28.91) v8(77.89,24.99) v8(78.12,54.94) v8(78.33,56.42) v8(78.83,0.5) v8(79,56.41) v8(79.02,26.95) v8(79.67,56.4) v8(79.89,66.81) v8(79.92,0.5) v8(80.39,56.13) v8(80.38,1.44) v8(80.5,66.81) v8(80.52,2.61) v8(81.02,56.13) v8(81.12,66.79) v8(81.24,3.35) v8(81.74,66.79) v8(81.72,56.12) v8(82.27,3.52) v8(82.37,56.11) v8(83.01,56.11) v8(83.21,67.57) v8(83.54,3.52) v8(83.82,67.57) v8(84.71,3.26) v8(85.32,75.48) v8(85.36,2.28) v8(85.69,1.11) v8(85.83,62.58) v8(86.4,75.47) v8(86.47,67.85) v8(86.42,62.58) v8(86.47,42.75) v8(86.5,0.57) v8(87,62.58) v8(87.67,75.47) v8(87.6,69.81) v8(87.6,65.89) v8(87.59,62.59) v8(87.6,44.71) v8(87.6,40.79) v8(87.72,0.5) v8(88.17,62.58) v8(88.75,62.58) v8(88.94,75.47) v8(88.99,0.5) v8(89.34,62.58) v8(89.37,61.05) v8(89.86,65.89) v8(89.86,44.71) v8(89.86,40.79) v8(90.21,75.47) v8(90.26,0.5) v8(90.55,61.05) v8(90.99,67.85) v8(90.99,42.75) v8(91.48,75.47) v8(91.53,0.5) v8(91.81,61.03) v8(92.75,75.47) v8(92.8,0.5) v8(93.06,61.03) v8(93.92,43.19) v8(94.02,75.47) v8(94.07,0.5) v8(94.2,46.37) v8(94.33,45.03) v8(95.09,43.19) v8(95.29,75.47) v8(95.34,0.5) v8(95.67,47.54) v8(95.61,27.85) v8(96.56,75.47) v8(96.61,0.5) v8(97.83,75.47) v8(97.88,0.5) v8(98.39,40.62) v8(98.42,38.73) v8(99.1,75.47) v8(99.15,0.5) v8(100.37,75.47) v8(100.42,0.5) v8(101.64,75.47) v8(101.69,0.5) v8(101.86,58.66) v8(102.48,13.28) v8(102.91,75.47) v8(102.96,0.5) v8(103.06,13.28) v8(103.65,13.28) v8(104.18,75.47) v8(104.23,13.28) v8(104.23,0.5) v8(104.83,13.29) v8(105.45,75.47) v8(105.44,13.28) v8(105.5,0.5) v8(106.02,56.71) v8(106.01,55.81) v8(105.99,54.87) v8(106.07,13.28) v8(106.72,75.47) v8(106.71,13.28) v8(106.77,0.5) v8(106.98,56.74) v8(106.95,54.8) v8(107.01,55.8) v8(107.31,13.28) v8(107.88,54.78) v8(107.92,56.71) v8(107.96,55.81) v8(107.9,13.28) v8(107.99,75.47) v8(108.04,0.5) v8(109.26,75.47) v8(109.31,0.5) v8(109.75,49.63) v8(110.19,28.47) v8(110.53,75.47) v8(110.58,0.5) v8(111.8,75.47) v8(111.85,0.5) v8(111.9,57.31) v8(111.9,55.99) v8(111.9,54.69) v8(113.07,75.47) v8(113.12,0.5) v8(113.81,58.12) v8(114.15,21.33) v8(114.2,54.06) v8(114.34,75.47) v8(114.39,0.5) v8(114.75,25.39) v8(114.76,24.12) v8(115.03,58.48) v8(115.09,56.22) v8(115.47,54.06) v8(115.61,75.47) v8(115.66,0.5) v8(116.24,58.48) v8(116.2,6.63) v8(116.74,54.06) v8(116.88,75.47) v8(116.93,0.5) v8(117,6.61) v8(117.46,58.48) v8(117.41,56.98) v8(117.63,55.72) v8(117.78,6.62) v8(117.96,54.06) v8(118.15,75.47) v8(118.2,0.5) v8(118.5,72.93) v8(118.68,58.48) v8(118.91,62.61) v8(119.08,26.5) v8(119.42,75.47) v8(119.47,0.5) v8(120.69,75.47) v8(120.74,0.5) v8(121.06,54.12) v8(121.11,59.53) v8(121.1,56.88) v8(121.11,54.78) v8(121.96,75.47) v8(122.01,0.5) v8(122.88,67.74) v8(123.08,68.6) v8(123.23,75.47) v8(123.28,0.5) v8(124.5,75.47) v8(124.55,0.5) v8(125.05,16.46) v8(125.62,23.54) v8(125.77,75.47) v8(125.82,0.5) v8(126.72,71.74) v8(127.04,75.47) v8(127.09,0.5) v8(127.3,71.74) v8(128.31,75.47) v8(128.36,0.5) v8(128.56,71.76) v8(129.15,71.76) v8(129.58,75.47) v8(129.63,0.5) v8(130.19,6.25) v8(130.19,5.61) v8(130.47,6.82) v8(130.85,75.47) v8(130.81,6.26) v8(130.79,5.62) v8(130.9,0.5) v8(131.33,19.61) v8(131.48,5.82) v8(131.8,19.21) v8(132.12,75.47) v8(132.09,5.81) v8(132.17,0.5) v8(133.39,75.47) v8(133.44,0.5) v8(133.95,53.42) v8(134.66,75.47) v8(134.6,53.41) v8(134.71,0.5) v8(134.8,5.82) v8(135.93,75.47) v8(135.98,0.5) v8(136.09,63.21) v8(137.2,75.47) v8(137.22,6.5) v8(137.21,5.91) v8(137.25,0.5) v8(138.47,75.47) v8(138.52,0.5) v8(138.92,64.18) v8(139.43,63.85) v8(139.74,75.47) v8(139.79,0.5) v8(141.01,75.47) v8(141.06,0.5) v8(142.28,75.47) v8(142.33,0.5) v8(143.47,67.85) v8(143.47,42.75) v8(143.55,75.47) v8(143.6,0.5) v8(144.6,69.81) v8(144.6,65.89) v8(144.6,44.71) v8(144.6,40.79) v8(144.72,75.48) v8(144.87,0.5) v8(146.06,6.77) v8(146.14,0.5) v8(146.86,69.81) v8(146.86,65.89) v8(146.86,44.71) v8(146.86,40.79) v8(146.81,8.08) v8(146.81,5.46) v8(147.41,0.5) v8(147.99,67.85) v8(147.99,42.75) v8(148.33,8.08) v8(148.33,5.46) v8(148.68,0.5) v8(149.08,6.77) v8(149.95,0.5) v8(150.88,33.73) v8(151.22,0.5) v8(152.47,75.48) v8(152.49,0.5) v8(153.74,75.48) v8(153.76,0.5) v8(155.01,75.48) v8(155.03,0.5) v8(156.28,75.48) v8(156.31,5.94) v8(156.3,0.5) v8(156.93,6.56) v8(156.93,5.31) v8(157.03,68.86) v8(157.44,71.13) v8(157.55,75.48) v8(157.56,5.94) v8(157.57,0.5) v8(157.64,68.83) v8(157.82,73.49) v8(158.07,71.75) v8(158.07,70.51) v8(158.69,71.13) v8(158.82,75.48) v8(158.81,47.89) v8(158.84,0.5) v8(158.88,59.76) v8(159.1,62.1) v8(159.34,64.43) v8(159.47,59.74) v8(159.72,62.72) v8(159.72,61.48) v8(160.09,75.48) v8(160.11,0.5) v8(160.35,62.1) v8(161.1,64.27) v8(161.36,75.48) v8(161.38,0.5) v8(161.76,52.78) v8(162.13,55.32) v8(162.4,52.77) v8(162.63,75.48) v8(162.65,0.5) v8(162.75,55.94) v8(162.75,54.69) v8(162.86,64.24) v8(162.96,49.18) v8(163.38,55.32) v8(163.59,64.22) v8(163.9,75.48) v8(163.92,0.5) v8(165.17,75.48) v8(165.19,0.5) v8(165.83,64.56) v8(165.99,74.28) v8(165.99,71.69) v8(166.44,75.48) v8(166.46,0.5) v8(167.67,47.8) v8(167.71,75.48) v8(167.73,0.5) v8(168.63,49.45) v8(168.63,46.15) v8(168.98,75.48) v8(169,0.5) v8(170.25,75.48) v8(170.27,15.41) v8(170.27,13.89) v8(170.27,12.36) v8(170.27,0.5) v8(170.53,49.45) v8(170.53,46.15) v8(170.82,74.05) v8(171.06,70.3) v8(171.52,75.48) v8(171.48,47.8) v8(171.54,0.5) v8(172.11,74.81) v8(172.11,73.54) v8(172.11,72.27) v8(172.11,71) v8(172.11,69.73) v8(172.11,68.46) v8(172.11,67.19) v8(172.11,65.92) v8(172.11,64.65) v8(172.11,63.38) v8(172.11,62.11) v8(172.11,60.84) v8(172.11,59.57) v8(172.11,58.3) v8(172.11,57.03) v8(172.11,55.76) v8(172.11,54.49) v8(172.11,53.22) v8(172.11,51.95) v8(172.11,44.73) v8(172.12,43.61) v8(172.12,42.34) v8(172.12,41.07) v8(172.12,39.8) v8(172.12,38.53) v8(172.12,37.26) v8(172.12,35.99) v8(172.12,34.72) v8(172.2,33.13) v8(172.37,31.65) v8(172.62,30.18) v8(172.88,29.04) v8(172.94,1.51) v8(173.25,27.78) v8(173.86,26.19) v8(174.21,1.51) v8(174.34,25.05) v8(175,23.82) v8(175.48,1.51) v8(175.56,22.79) v8(176.15,21.87) v8(176.75,1.51) v8(177,20.74) v8(177.85,19.69) v8(178.02,1.51) v8(178.74,18.71) v8(179.29,1.51) v8(179.54,17.93) v8(180.36,17.17) v8(180.56,1.51) v8(181.37,16.36) v8(181.7,0.5) v8(182.36,15.66) v8(182.97,0.5) v8(183.53,14.9) v8(184.24,0.5) v8(184.78,14.19) v8(185.51,0.5) v8(186,13.61) v8(186.78,0.5) v8(187.37,13.06) v8(188.05,0.5) v8(188.74,12.6) v8(189.32,0.5) v8(190.12,12.2) v8(190.59,0.5) v8(191.47,11.91) v8(191.86,0.5) v8(192.95,11.69) v8(193.13,0.5) v8(194.23,11.59) v8(194.4,0.5) v8(195.5,11.53) v8(195.67,0.5) v8(196.62,11.56) v8(196.94,0.5) v8(197.9,11.66) v8(198.21,0.5) v8(199.29,11.82) v8(199.48,0.5) v8(200.55,12.06) v8(200.75,0.5) v8(201.71,12.36) v8(202.02,0.5) v8(202.93,12.7) v8(203.29,0.5) v8(204.1,13.14) v8(204.56,0.5) v8(205.18,13.58) v8(205.83,0.5) v8(206.28,14.1) v8(207.1,0.5) v8(207.32,14.67) v8(208.37,0.5) v8(208.42,15.31) v8(209.43,16.01) v8(209.64,0.5) v8(210.56,16.89) v8(210.91,0.5) v8(211.34,17.58) v8(212.18,0.5) v8(212.24,18.43) v8(212.73,8.38) v8(213.25,19.51) v8(213.45,0.5) v8(213.48,9.69) v8(213.48,7.07) v8(214.1,20.51) v8(214.72,0.5) v8(215,9.69) v8(215,7.07) v8(215.75,8.38) v8(215.99,0.5) v8(216.28,19.81) v8(217.24,21.46) v8(217.24,18.16) v8(217.26,0.5) v8(218.53,0.5) v8(219.14,21.46) v8(219.14,18.16) v8(219.8,0.5) v8(220.09,19.81) v8(221.07,0.5) v8(221.98,20.91) v8(222.34,0.5) v8(222.61,9.52) v8(222.74,19.96) v8(223.55,19.04) v8(223.61,0.5) v8(224.51,18.06) v8(224.88,0.5) v8(225.28,17.36) v8(226.15,0.5) v8(226.21,16.59) v8(227.2,15.84) v8(227.42,0.5) v8(228.31,15.12) v8(228.69,0.5) v8(229.51,14.42) v8(229.96,0.5) v8(230.77,13.78) v8(231.23,0.5) v8(232.1,13.21) v8(232.5,0.5) v8(233.32,12.76) v8(233.77,0.5) v8(234.53,12.37) v8(235.04,0.5) v8(235.93,12.04) v8(236.31,0.5) v8(237.19,11.8) v8(237.58,0.5) v8(238.54,11.63) v8(238.85,0.5) v8(239.78,11.56) v8(240.12,0.5) v8(241.08,11.55) v8(241.39,0.5) v8(242.36,11.59) v8(242.66,0.5) v8(243.74,11.73) v8(243.93,0.5) v8(245.06,11.92) v8(245.2,0.5) v8(246.37,12.22) v8(246.47,0.5) v8(247.74,0.5) v8(247.85,12.64) v8(249.01,0.5) v8(249.17,13.11) v8(250.28,0.5) v8(250.45,13.64) v8(251.39,14.09) v8(251.55,0.5) v8(252.31,14.59) v8(252.82,0.5) v8(253.34,15.19) v8(253.4,7.46) v8(254.09,0.5) v8(254.32,15.86) v8(255.24,16.55) v8(255.36,0.5) v8(256.19,17.34) v8(256.63,0.5) v8(256.95,18.01) v8(257.84,18.91) v8(257.9,0.5) v8(258.58,19.74) v8(259.17,0.5) v8(259.35,20.68) v8(259.98,21.53) v8(260.44,0.5) v8(260.57,22.42) v8(261.32,23.66) v8(261.71,0.5) v8(261.93,24.86) v8(262.46,26.04) v8(262.9,27.17) v8(262.98,0.5) v8(263.23,28.21) v8(263.6,29.44) v8(263.81,30.54) v8(264.02,31.69) v8(264.17,32.9) v8(264.26,67.22) v8(264.26,65.95) v8(264.26,64.68) v8(264.26,63.41) v8(264.26,62.14) v8(264.26,60.87) v8(264.26,59.6) v8(264.26,58.33) v8(264.26,57.06) v8(264.26,55.79) v8(264.26,54.52) v8(264.26,53.25) v8(264.26,51.98) v8(264.26,50.71) v8(264.26,49.44) v8(264.26,48.17) v8(264.26,46.9) v8(264.26,45.63) v8(264.26,44.36) v8(264.26,43.09) v8(264.26,41.82) v8(264.26,40.55) v8(264.26,39.28) v8(264.26,38.01) v8(264.26,36.74) v8(264.26,35.47) v8(264.26,34.2) v8(264.25,0.5) v8(264.58,68.28) v8(265.26,65) v8(265.52,0.5) v8(265.85,68.28) v8(266.1,65.86) v8(266.74,66.91) v8(267.12,68.28) v8(268.04,35.75) v8(268.17,47.11) v8(268.28,27.87) v8(268.39,68.28) v8(268.39,24.28) v8(268.52,16.44) v8(269,37.4) v8(269,34.1) v8(269.33,0.5) v8(269.66,68.28) v8(269.66,17.86) v8(269.8,25.4) v8(269.8,24.28) v8(269.8,23.16) v8(270.07,10.92) v8(270.07,9.54) v8(270.07,8.16) v8(270.07,6.78) v8(270.65,29.74) v8(270.6,0.5) v8(270.93,68.28) v8(270.9,37.4) v8(270.9,34.1) v8(271.22,25.4) v8(271.22,24.28) v8(271.22,23.16) v8(271.34,49.48) v8(271.34,46.18) v8(271.45,10.92) v8(271.45,9.54) v8(271.45,6.78) v8(271.85,35.75) v8(271.87,0.5) v8(272.2,68.28) v8(272.63,24.28) v8(272.83,10.92) v8(272.83,9.54) v8(272.9,17.46) v8(273.14,0.5) v8(273.47,68.28) v8(274.21,10.92) v8(274.21,9.54) v8(274.21,8.16) v8(274.21,6.78) v8(274.74,68.28) v8(274.69,63.85) v8(274.69,61.88) v8(274.69,59.91) v8(274.87,49.47) v8(274.87,46.17) v8(276.01,68.28) v8(276.66,61.88) v8(276.66,59.91) v8(276.92,2.49) v8(277.28,68.28) v8(277.85,49.46) v8(277.93,46.17) v8(278.19,2.49) v8(278.55,68.28) v8(278.63,61.88) v8(279.46,2.49) v8(279.82,68.28) v8(280.26,46.93) v8(280.49,49.47) v8(280.73,2.49) v8(281.09,68.28) v8(282,2.49) v8(282.36,68.28) v8(283.27,2.49) v8(283.63,68.28) v8(284.54,2.49) v8(284.9,68.28) v8(285.81,2.49) v8(286.05,52.54) v8(286.17,68.28) v8(287.08,2.49) v8(287.26,28.7) v8(287.36,34.96) v8(287.36,32.72) v8(287.81,68.28) v8(287.85,45.69) v8(288.09,67.71) v8(288.35,2.49) v8(288.47,33.84) v8(288.57,68.92) v8(288.63,70.35) v8(288.85,28.73) v8(288.95,46.23) v8(289.18,71.47) v8(289.52,68.12) v8(289.59,34.96) v8(289.59,32.72) v8(289.62,2.49) v8(290.48,71.5) v8(290.89,2.49) v8(291.77,42.15) v8(291.86,71.5) v8(292.16,2.49) v8(292.57,43.55) v8(292.57,40.75) v8(292.5,22.2) v8(293.02,58.25) v8(293.33,71.48) v8(293.3,23.6) v8(293.3,20.8) v8(293.43,2.49) v8(293.82,59.65) v8(293.82,56.85) v8(294.19,43.55) v8(294.19,40.75) v8(294.51,71.5) v8(294.7,2.49) v8(294.92,23.6) v8(294.92,20.8) v8(294.99,42.15) v8(295.18,27.12) v8(295.26,32.93) v8(295.25,32.28) v8(295.19,29.85) v8(295.44,59.65) v8(295.44,56.85) v8(295.76,50.98) v8(295.76,49.71) v8(295.72,22.2) v8(295.96,47.17) v8(295.97,2.49) v8(295.99,53.45) v8(296.24,58.25) v8(296.75,68.32) v8(296.75,67.05) v8(296.75,65.78) v8(296.75,64.51) v8(296.75,63.24) v8(296.75,54.35) v8(296.75,46.73) v8(296.76,38.73) v8(296.75,37.84) v8(296.77,18.43) v8(296.77,17.16) v8(296.77,15.89) v8(296.77,14.62) v8(296.77,13.35) v8(296.77,12.08) v8(296.77,10.81) v8(296.76,9.77) v8(296.77,8.27) v8(296.77,5.93) v8(296.77,4.87) v8(296.77,3.39) v9(9.49,34.26) v9(9.67,35.47) v9(9.98,37.46) v9(9.93,36.86) v9(9.99,38.48) v9(10.15,32.68) v9(11.29,31.6) v9(12.11,30.47) v9(13.95,30.62) v9(14.44,29.97) v9(14.87,30.28) v9(15.51,31.83) v9(15.5,30.14) v9(63.22,9.71) v9(63.64,9.71) v9(64.01,9.71) v11(19.69,40.7) v11(26.74,45.12) v11(35.19,25.99) v11(37.56,33.51) v11(40.04,24.21) v11(40.16,26.79) v11(40.76,73.63) v11(50.69,25.28) v11(55.46,71.29) v11(58.51,35.19) v11(67.4,55.96) v11(68.19,61.6) v11(69.38,42.27) v11(74.25,72.47) v11(80.74,39.22) v11(82.21,56.93) v11(83.17,69.15) v11(85.94,39.12) v11(102.59,41.95) v11(116.83,7.98) v11(122.72,10.73) v11(123.48,10.27) v11(124.45,13.52) v11(127.26,74.24) v11(133.09,6.1) v11(153.58,41.15) v11(157.23,51.52) v11(165.19,65.18) v11(165.88,70.92) v11(166.16,50.91) v11(169.11,72.4) v11(266.28,19.64) v11(267.1,65.31) v11(270.32,61.97) v11(270.7,58.12) v11(271.54,12.12) v11(271.63,51.76) v11(271.64,26.85) v11(272.02,54.62) v11(274.87,44.36)
