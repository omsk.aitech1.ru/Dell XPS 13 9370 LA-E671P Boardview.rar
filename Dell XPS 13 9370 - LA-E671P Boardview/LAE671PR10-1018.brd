# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_CARDTX_N1_C: length 1.5
  BOTTOM w0.102: CR11.2 287.15,30.64 287.15,31.35 287.07,31.42 UR1.8
PCIE_PRX_CARDTX_P1: length 212.3
  IN3 w0.089: v8(287.54,29.25) 287.54,29.89 287.22,30.21 284.74,30.21 284.56,30.03 273.39,30.03 272.02,28.66 267.99,28.66 267.36,28.03 267.36,26.72 266.14,25.5 266.14,24.8 265.27,23.92 264.21,21.85 264.21,19.26 260.44,15.49 259.39,15.49 256.43,12.53 256.43,11.74 255.13,10.44 252.26,10.44 251.48,9.66 250.82,9.66 250.39,9.23 231.12,9.23 228.53,11.82 226.54,11.82 225.74,12.61 222.76,12.61 221.68,13.7 210.68,13.7 206.21,9.23 187.7,9.23 186.18,10.75 179.44,10.75 175.41,14.78 169.27,14.78 166.33,17.72 161.4,17.72 159.18,19.94 159.18,25.02 158.97,25.23 158,26.2 158,36.05 154.89,39.17 154.89,44.91 150.24,49.56 150.24,50.01 148.43,51.82 148.43,52.57 144.79,56.21 142.54,56.21 142.06,56.69 140.36,56.69 137.26,59.79 137.26,60.76 136.13,61.89 135.52,61.89 135.26,62.15 135.26,63.36 134.56,64.07 132.52,64.07 130.7,62.25 v3(130.7,62.19)
  GND3 w0.102: v4(130.33,62.2) 130.69,62.2 v3(130.7,62.19)
  BOTTOM w0.102: CR10.1 287.36,29.64 287.36,29.43 v8(287.54,29.25)
PCIE_PRX_CARDTX_P1_C: length 1.5
  BOTTOM w0.102: CR10.2 287.37,30.62 287.37,31.28 287.47,31.38 UR1.7
PCIE_PRX_SSDTX_N9: length 80.1
  IN3 w0.089: v3(124.42,63.28) 124.45,63.28 124.89,63.72 124.89,64.11 124.39,64.61 124.39,65.06 124.97,65.64 126.73,65.64 127.2,66.11 127.2,67.05 127.56,67.41 130.44,67.41 131.08,66.78 134.92,66.78 135.35,67.22 136.85,67.22 137.68,66.38 137.68,66.19 140.16,63.72 140.16,58.83 141.1,57.89 144.1,57.89 144.57,57.41 145.39,57.41 149.62,53.17 149.62,52.29 151.47,50.45 151.47,49.97 156.03,45.41 156.03,39.66 159.61,36.08 159.61,26.5 160.36,25.75 160.36,20.38 161.63,19.1 161.87,19.1 v3(161.97,19)
  GND3 w0.102: v3(161.97,19) 161.85,19 v4(161.61,19.23) ; v4(124.84,63.5) 124.77,63.5 124.58,63.3 124.45,63.3 v3(124.42,63.28)
  BOTTOM w0.102: JNGFF1.5 160.9,18.7 161.44,19.23 v4(161.61,19.23)
PCIE_PRX_SSDTX_N10: length 81.8
  IN3 w0.089: v3(123.46,63.2) 123.86,63.59 123.86,64.01 123.64,64.23 123.64,65.37 125.6,67.33 125.6,68.76 125.93,69.09 128.14,69.09 128.31,68.93 128.31,68.55 128.68,68.18 131.33,68.18 131.85,68.7 134.12,68.7 134.88,69.46 136.41,69.46 138.5,67.37 138.5,66.49 141.12,63.87 141.12,62.88 141.59,62.41 141.59,60.41 143.24,58.76 145.48,58.76 147.47,56.77 147.85,56.77 150.34,54.28 150.34,53.49 150.87,52.96 150.87,52.26 151.81,51.33 152.49,51.33 155.4,48.42 155.4,47.14 156.78,45.76 156.78,39.99 160.37,36.39 160.37,26.97 161.15,26.2 161.15,22.21 161.62,21.73 162.03,21.73 v3(162.1,21.67)
  GND3 w0.102: v4(161.76,21.7) 161.8,21.67 v3(162.1,21.67) ; v3(123.46,63.2) 123.11,62.85 v4(123.02,62.85)
  BOTTOM w0.102: v4(161.76,21.7) 161.66,21.81 161.08,21.81 160.97,21.7 JNGFF1.17
PCIE_PRX_SSDTX_N11: length 83
  IN3 w0.089: v8(120.84,63.84) 120.9,63.89 120.9,64.33 123.77,67.21 123.77,68.37 124.37,68.97 124.37,69.16 125.47,70.27 133.3,70.27 133.72,70.68 137.54,70.68 144.09,64.13 147.94,64.13 148.56,63.5 148.56,58.65 150.59,56.63 150.59,55.6 151.48,54.71 151.48,54.01 156.53,48.96 156.53,47.66 157.93,46.26 157.93,40.42 162.28,36.06 162.28,34.54 161.48,33.74 161.48,29.87 161.89,29.46 161.89,27.19 162.97,26.11 162.97,25.09 162.68,24.8 162.07,24.8 v3(161.89,24.61)
  GND3 w0.102: v4(161.35,24.7) 161.81,24.7 v3(161.89,24.61)
  BOTTOM w0.097: UCPU1.E28 121.18,63.5 v8(120.84,63.84)
  BOTTOM w0.102: JNGFF1.29 v4(161.35,24.7)
PCIE_PRX_SSDTX_P9: length 80.1
  IN3 w0.089: v3(124.45,63.81) 124.45,64.05 124.04,64.46 124.04,65.21 124.82,65.99 126.59,65.99 126.84,66.25 126.84,67.2 127.41,67.77 130.59,67.77 131.22,67.13 134.77,67.13 135.21,67.57 137,67.57 138.04,66.53 138.04,66.34 140.51,63.87 140.51,58.98 141.25,58.24 144.24,58.24 144.72,57.76 145.54,57.76 149.98,53.32 149.98,52.44 151.82,50.6 151.82,50.12 156.38,45.56 156.38,39.81 159.97,36.22 159.97,26.65 160.51,26.11 160.72,25.9 160.72,20.52 161.78,19.46 161.91,19.46 v3(161.98,19.53)
  GND3 w0.102: v4(161.61,19.73) 161.81,19.53 v3(161.98,19.53) ; v3(124.45,63.81) 124.35,63.81 124.04,63.5 v4(123.93,63.5)
  BOTTOM w0.102: JNGFF1.7 161.08,19.2 v4(161.61,19.73)
PCIE_PRX_SSDTX_P10: length 81.8
  IN3 w0.089: v3(162.1,22.25) 161.94,22.09 161.77,22.09 161.51,22.36 161.51,26.35 160.73,27.12 160.73,36.54 157.13,40.14 157.13,45.91 155.75,47.29 155.75,48.57 152.64,51.69 151.95,51.69 151.23,52.41 151.23,53.1 150.69,53.64 150.69,54.42 147.99,57.13 147.61,57.13 145.62,59.12 143.39,59.12 141.95,60.56 141.95,62.55 141.47,63.03 141.47,64.02 138.85,66.64 138.85,67.51 136.55,69.81 134.73,69.81 133.98,69.06 131.71,69.06 131.18,68.53 128.83,68.53 128.66,68.7 128.66,69.08 128.29,69.45 125.79,69.45 125.24,68.9 125.24,67.48 123.28,65.52 123.28,64.08 123.5,63.86 123.5,63.78 v3(123.46,63.74)
  GND3 w0.102: v3(123.46,63.74) 123.25,63.74 v4(123.02,63.5) ; v4(161.76,22.2) 161.81,22.25 v3(162.1,22.25)
  BOTTOM w0.102: JNGFF1.19 160.97,22.2 161.13,22.04 161.6,22.04 v4(161.76,22.2)
PCIE_PRX_SSDTX_P11: length 83
  IN3 w0.089: v8(121.73,63.8) 121.73,63.19 121.62,63.09 121.36,63.09 121.25,63.19 121.25,64.19 124.12,67.06 124.12,68.22 124.72,68.82 124.72,69.01 125.62,69.91 133.45,69.91 133.86,70.32 137.39,70.32 143.94,63.78 147.79,63.78 148.21,63.36 148.21,58.51 150.23,56.48 150.23,55.46 151.13,54.56 151.13,53.86 156.17,48.82 156.17,47.51 157.57,46.12 157.57,40.27 161.93,35.91 161.93,34.69 161.13,33.89 161.13,29.72 161.54,29.31 161.54,27.04 162.62,25.96 162.62,25.24 162.53,25.15 161.97,25.15 v3(161.88,25.24)
  GND3 w0.102: v3(161.88,25.24) 161.83,25.2 v4(161.35,25.2)
  BOTTOM w0.097: v8(121.73,63.8) 122.03,63.5 UCPU1.E27
  BOTTOM w0.102: JNGFF1.31 v4(161.35,25.2)
PCIE_PRX_TBTX_N5: length 132.1
  IN2 w0.076: v3(128.06,63.27) 128.18,63.39 128.18,63.68 127.75,64.12 127.75,65.58 127.47,65.85 125.52,65.85 125.32,66.06 124.11,66.06 124.01,65.96 123.99,65.96
  IN2 w0.089: 123.99,65.96 122.16,65.96 120.59,67.53 116.94,67.53 115.94,66.52 113.36,66.52 111.64,68.24 111.64,68.71 110.16,70.18 109.09,70.18 108.28,71 106.74,71 106.43,70.7 102.1,70.7 101.58,70.18 94.49,70.18 94.09,69.78 91.34,69.78 89.96,71.15 86.93,71.15 85.21,69.43 79.58,69.43 77.79,71.22 53.84,71.22 52.43,69.8 47.59,69.8 44.37,66.58 43.7,66.58 42,64.88 36.39,64.88 30.11,58.6 30.11,55.34 29.12,54.35 29.12,53.96 28.79,53.63 28.79,52.2 29.12,51.88 29.12,43.34 27.27,41.49 27.27,40.61 27.42,40.47 v3(27.53,40.47)
  GND3 w0.102: v4(128.5,62.85) 128.5,62.87 128.1,63.27 v3(128.06,63.27) ; v3(27.53,40.47) 27.53,40.47 v4(27.53,40.12)
PCIE_PRX_TBTX_N5_C: length 3.2
  BOTTOM w0.076: UT2.V22 25.95,42.88 26.17,42.66 26.17,41.88 26.65,41.4 27.12,41.4 27.29,41.22 27.29,40.94 CT4.2
PCIE_PRX_TBTX_N6: length 134
  IN2 w0.076: v8(128.09,61.86) 127.88,62.07 127.79,62.07 126.27,63.6 125.44,63.6 124.82,64.22 124.25,64.22 124.15,64.12 124.13,64.12
  IN2 w0.089: 124.13,64.12 123.28,64.12 123.16,64 122.1,64 121.67,64.43 120.76,64.43 120.2,63.86 119.26,63.86 118.11,65.02 112.58,65.02 111.42,66.17 110.44,66.17 110.26,65.99 109.63,65.99 109.04,66.58 109.04,67.42 108.76,67.7 106.22,67.7 105.75,68.17 97.7,68.17 96.63,67.09 92.07,67.09 90.92,65.95 90.92,65.88 90.05,65.01 87.38,65.01 84.42,67.98 78.98,67.98 77.18,69.77 72.01,69.77 71.44,69.21 54.1,69.21 51.58,66.68 46.59,66.68 44.8,64.89 44.36,64.89 42.78,63.31 38.17,63.31 32.75,57.88 32.75,54.89 30.95,53.1 30.95,51.72 30.62,51.39 30.62,40.59 29.76,39.73 28.16,39.73 27.96,39.53 25.83,39.53 25.63,39.74 24.66,39.74 24.34,40.06 24.34,40.42 v3(24.29,40.47)
  GND3 w0.102: v3(24.29,40.47) 24.23,40.41 v4(24.23,40.12)
  BOTTOM w0.076: v8(128.09,61.86) 127.75,62.2 UCPU1.G18
PCIE_PRX_TBTX_N6_C: length 2.7
  BOTTOM w0.076: CT21.2 24.47,40.95 24.47,41.56 24.05,41.98 24.05,42.17 23.9,42.32 23.9,42.67 24.11,42.89 UT2.P22
PCIE_PRX_TBTX_N7: length 138.3
  IN2 w0.076: 122.95,61.61 122.97,61.61 123.06,61.71 124.39,61.71 124.94,61.16 126.24,61.16 126.8,61.72 127.04,61.72 127.12,61.64 127.12,61.47 v3(126.99,61.34)
  IN2 w0.089: v3(22.42,39.59) 22.53,39.69 23.64,39.69 24.34,38.99 25.06,38.99 25.45,38.59 30.05,38.59 31.65,40.19 31.65,40.35 32.59,41.29 32.59,43.25 32.31,43.54 32.31,44.95 32.02,45.23 32.02,49.75 32.16,49.89 32.16,51.48 32.16,51.48 32.16,53.2 33.52,54.55 33.52,55.09 33.52,56.1 33.52,57.53 38.45,62.45 43.63,62.45 47.07,65.89 51.98,65.89 54.57,68.48 71.74,68.48 72.31,69.05 76.88,69.05 78.67,67.25 82.41,67.25 85.41,64.26 91.11,64.26 92.07,65.22 96.64,65.22 98.74,67.33 105.46,67.33 107.29,65.5 107.73,65.5 107.93,65.29 109.21,65.29 110.39,64.11 110.76,64.11 111.21,63.66 112.67,63.66 113.27,64.26 116.86,64.26 118.04,63.08 118.04,62.14 118.57,61.61 122.95,61.61
  GND3 w0.102: v3(126.99,61.34) 126.78,61.55 126.78,61.72 v4(126.93,61.87) ; v4(21.89,40.11) 21.9,40.11 v3(22.42,39.59)
  BOTTOM w0.076: UCPU1.F20 126.62,62.9 126.62,63.07 126.71,63.16 126.94,63.16 127.06,63.05 127.06,62 v4(126.93,61.87)
PCIE_PRX_TBTX_N7_C: length 2.5
  BOTTOM w0.076: 22.08,41.28 22.08,41.54 22.21,41.66 22.21,42.17 22.06,42.32 22.06,42.67 22.27,42.89 UT2.K22
  BOTTOM w0.102: 22.08,41.28 22.08,40.89 CT8.2
PCIE_PRX_TBTX_N8: length 132
  IN3 w0.076: 124.53,60.1 124.54,60.12 124.54,60.25 124.81,60.52 124.81,61.87 125.13,62.19 125.59,62.19 125.83,62.42 v3(126.05,62.42)
  IN3 w0.089: v3(32.81,39.19) 32.88,39.27 34.04,39.27 34.57,39.79 35.11,39.79 40.09,44.77 40.09,47.41 45.51,52.83 45.51,57.31 46.05,57.85 46.05,59.67 46.64,60.26 48.62,60.26 50.42,62.06 53.04,62.06 56.49,65.51 59.3,65.51 59.44,65.38 76.01,65.38 77.26,64.13 77.98,64.13 78.42,63.68 79.36,63.68 83.91,59.13 93.34,59.13 94.65,60.44 95.37,60.44 96.04,61.11 102.36,61.11 102.7,61.45 103.46,61.45 104.62,60.29 106.38,60.29 107.63,59.05 119.29,59.05 120.29,60.05 122.62,60.05 122.93,59.75 124.17,59.75 124.53,60.1
  GND3 w0.102: v4(125.76,62.2) 125.83,62.2 v3(126.05,62.42) ; v4(32.09,39.14) 32.2,39.14 32.34,39.27 32.72,39.27 v3(32.81,39.19)
  BOTTOM w0.102: v4(32.09,39.14) 31.33,39.14 31.19,39.28 30.02,39.28 28.89,38.15 v10(21.45,38.15) 20.81,38.15 19.55,39.41 CT12.1
PCIE_PRX_TBTX_N8_C: length 2.7
  BOTTOM w0.076: CT12.2 19.76,40.92 19.76,41.21 20.31,41.75 20.31,42.23 20.22,42.32 20.22,42.73 UT2.F22
PCIE_PRX_TBTX_P5: length 132.1
  IN2 w0.076: 124.14,66.32 124.16,66.32 124.26,66.22 125.39,66.22 125.59,66.02 127.54,66.02 127.91,65.65 127.91,64.19 128.23,63.87 v3(128.5,63.87)
  IN2 w0.089: 124.14,66.32 122.3,66.32 120.74,67.89 116.8,67.89 115.79,66.88 113.5,66.88 111.99,68.39 111.99,68.86 110.31,70.54 109.24,70.54 108.42,71.36 106.59,71.36 106.29,71.05 101.96,71.05 101.43,70.53 94.34,70.53 93.95,70.13 91.48,70.13 90.11,71.51 86.79,71.51 85.06,69.78 79.73,69.78 77.93,71.57 53.7,71.57 52.28,70.16 47.44,70.16 44.22,66.93 43.55,66.93 41.85,65.23 36.24,65.23 29.75,58.74 29.75,55.49 28.76,54.49 28.76,54.1 28.44,53.78 28.44,52.06 28.76,51.73 28.76,43.48 26.92,41.64 v3(26.92,40.47)
  GND3 w0.102: v4(128.5,63.5) v3(128.5,63.87) ; v3(26.92,40.47) 26.9,40.45 v4(26.9,40.12)
PCIE_PRX_TBTX_P5_C: length 3.2
  BOTTOM w0.076: CT2.2 26.9,40.71 27.13,40.94 27.13,41.15 27.05,41.23 26.58,41.23 26.01,41.81 26.01,42.11 25.94,42.18 25.83,42.18 25.72,42.29 25.72,42.51 25.79,42.59 25.9,42.59 25.95,42.54 UT2.V23
PCIE_PRX_TBTX_P6: length 134
  IN2 w0.076: v8(128.04,62.63) 128.24,62.43 128.24,62.32 128.15,62.23 127.86,62.23 126.34,63.76 125.51,63.76 124.88,64.38 124.25,64.38 124.15,64.48 124.13,64.48
  IN2 w0.089: 124.13,64.48 123.14,64.48 123.01,64.35 122.25,64.35 121.82,64.78 120.61,64.78 120.05,64.22 119.41,64.22 118.26,65.37 112.72,65.37 111.57,66.53 110.3,66.53 110.12,66.35 109.77,66.35 109.39,66.73 109.39,67.57 108.91,68.06 106.36,68.06 105.9,68.52 97.55,68.52 96.48,67.45 91.92,67.45 90.57,66.09 90.57,66.03 89.91,65.37 87.53,65.37 84.57,68.33 79.12,68.33 77.33,70.13 71.86,70.13 71.29,69.56 53.96,69.56 51.43,67.04 46.45,67.04 44.65,65.25 44.21,65.25 42.63,63.66 38.03,63.66 32.39,58.03 32.39,55.04 30.6,53.25 30.6,51.87 30.27,51.54 30.27,40.74 29.61,40.08 28.02,40.08 27.82,39.88 25.98,39.88 25.77,40.09 24.81,40.09 24.69,40.21 24.69,40.39 24.78,40.48 v3(24.84,40.48)
  GND3 w0.102: v3(24.84,40.48) 24.86,40.46 v4(24.86,40.12)
  BOTTOM w0.076: v8(128.04,62.63) 127.98,62.57 127.76,62.57 127.59,62.75 UCPU1.F18
PCIE_PRX_TBTX_P6_C: length 2.7
  BOTTOM w0.076: UT2.P23 24.11,42.63 24.18,42.69 24.3,42.69 24.36,42.64 24.36,42.31 24.21,42.17 24.21,42.05 24.64,41.62 24.64,40.93 CT19.2
PCIE_PRX_TBTX_P7: length 138.3
  IN2 w0.076: v3(126.92,62.37) 126.92,62.07 126.18,61.32 125.01,61.32 124.46,61.87 123.06,61.87 122.97,61.97 122.95,61.97
  IN2 w0.089: 122.95,61.97 118.72,61.97 118.4,62.29 118.4,63.22 117,64.62 113.12,64.62 112.52,64.01 111.36,64.01 110.91,64.46 110.54,64.46 109.36,65.65 108.08,65.65 107.87,65.85 107.44,65.85 105.6,67.68 105.31,67.68 98.59,67.68 96.49,65.58 91.92,65.58 90.96,64.62 85.55,64.62 82.56,67.61 78.82,67.61 77.03,69.4 72.16,69.4 71.59,68.84 54.43,68.84 51.84,66.25 46.92,66.25 43.48,62.81 38.3,62.81 33.17,57.67 33.17,56.1 33.17,55.09 33.17,54.7 31.81,53.34 31.81,51.63 31.81,51.63 31.81,50.03 31.67,49.89 31.67,45.08 31.95,44.8 31.95,43.39 32.23,43.11 32.23,41.44 31.29,40.5 31.29,40.34 29.9,38.95 25.6,38.95 25.21,39.34 24.49,39.34 23.78,40.05 22.9,40.05 22.48,40.48 v3(22.48,40.6)
  GND3 w0.102: v4(127.32,61.87) 127.32,61.97 v3(126.92,62.37) ; v3(22.48,40.6) 22.25,40.38 22.25,40.21 22.35,40.11 v4(22.48,40.11)
  BOTTOM w0.076: UCPU1.E20 126.85,63.33 127.01,63.33 127.22,63.12 127.22,61.97 v4(127.32,61.87)
PCIE_PRX_TBTX_P7_C: length 2.5
  BOTTOM w0.076: 22.3,41.28 22.3,41.5 22.39,41.59 22.39,42.16 22.51,42.29 22.51,42.63 22.45,42.69 22.33,42.69 22.27,42.64 UT2.K23
  BOTTOM w0.102: CT6.2 22.48,40.7 22.3,40.87 22.3,41.28
PCIE_PRX_TBTX_P8: length 131.9
  IN3 w0.076: v3(125.38,62.79) 125.41,62.82 125.53,62.82 125.68,62.67 125.68,62.51 125.52,62.35 125.06,62.35 124.65,61.94 124.65,60.59 124.43,60.37 124.42,60.37
  IN3 w0.089: v3(32.8,39.74) 32.92,39.62 33.9,39.62 34.43,40.15 34.97,40.15 39.73,44.92 39.73,47.55 45.16,52.97 45.16,57.46 45.69,58 45.69,59.81 46.49,60.61 48.47,60.61 50.28,62.41 52.89,62.41 56.34,65.87 59.45,65.87 59.58,65.73 76.16,65.73 77.41,64.48 78.13,64.48 78.57,64.04 79.5,64.04 84.06,59.49 93.19,59.49 94.5,60.79 95.22,60.79 95.9,61.46 102.21,61.46 102.55,61.81 103.61,61.81 104.77,60.65 106.53,60.65 107.78,59.4 119.14,59.4 120.15,60.41 122.77,60.41 123.07,60.1 124.02,60.1 124.29,60.37 124.42,60.37
  GND3 w0.102: v3(32.8,39.74) 32.58,39.52 v4(32.09,39.52) ; v3(125.38,62.79) 125.7,62.79 v4(125.76,62.85)
  BOTTOM w0.102: v4(32.09,39.52) 32.05,39.52 31.89,39.36 31.43,39.36 31.29,39.5 29.92,39.5 28.8,38.38 v10(23.34,38.38) 20.91,38.38 19.78,39.5 19.78,39.69 19.85,39.76 20.06,39.76 20.14,39.84 CT10.1
PCIE_PRX_TBTX_P8_C: length 2.7
  BOTTOM w0.076: CT10.2 19.93,40.92 19.93,41.12 20.49,41.68 20.49,42.12 20.67,42.3 20.67,42.59 20.6,42.66 20.5,42.66 20.43,42.59 UT2.F23
PCIE_PRX_WLANTX_N3: length 225.1
  GND1 w0.102: v1(281.78,47.64) 281.78,47.53 281.68,47.43 v3(281.49,47.43)
  IN2 w0.076: 129.88,65.09 129.88,65.07 129.98,64.98 129.98,64.42 128.46,62.9 128.46,62.25 128.67,62.04 128.89,62.04 v8(129.06,61.87)
  IN2 w0.089: v3(281.49,47.43) 281.49,47.37 279,44.89 277.7,44.89 272.84,40.02 270.01,40.02 266.92,36.93 266.92,30.75 266.48,30.31 266.48,25.45 263.92,22.89 263.92,20.08 259.98,16.14 259.14,16.14 252.52,9.52 250.77,9.52 249.62,8.37 231.26,8.37 229.76,9.87 227.4,9.87 226.35,10.92 217.59,10.92 216.06,12.44 211.04,12.44 206.93,8.33 187.13,8.33 185.45,10.01 174.91,10.01 172.76,12.16 172.76,14.23 172.19,14.8 169.55,14.8 165.46,18.89 163.67,18.89 161.46,21.1 161.46,27.67 160.74,28.39 160.74,32.81 160.17,33.38 160.17,35.95 155.17,40.94 155.17,45.39 149.5,51.07 149.5,53.49 143.81,59.19 143.48,59.19 143.11,59.55 143.11,61.21 141.13,63.19 141.13,63.78 137.18,67.73 135.35,67.73 134,66.38 130.94,66.38 129.88,65.32 129.88,65.09
  BOTTOM w0.076: v8(129.06,61.87) 128.75,61.55 UCPU1.H16
PCIE_PRX_WLANTX_N3_C: length 2.1
  TOP w0.102: CH1.2 282.76,48.29 283.03,48.56 283.28,48.56 v8(283.44,48.72)
  BOTTOM w0.102: v8(283.44,48.72) 283.44,48.91 283.62,49.08 284.1,49.08 WL1.36
PCIE_PRX_WLANTX_P3: length 225.1
  GND1 w0.102: v1(282.42,47) 282.1,47 v3(282.02,46.92)
  IN2 w0.076: v8(129.05,62.52) 129.05,62.3 128.96,62.21 128.73,62.21 128.62,62.32 128.62,62.83 130.14,64.35 130.14,64.98 130.24,65.07 130.24,65.11
  IN2 w0.089: v3(282.02,46.92) 282.02,47.05 281.93,47.14 281.76,47.14 279.15,44.53 277.85,44.53 272.98,39.66 270.16,39.66 267.28,36.78 267.28,30.6 266.84,30.16 266.84,25.3 264.28,22.74 264.28,19.93 260.12,15.78 259.28,15.78 252.66,9.16 250.92,9.16 249.77,8.02 231.11,8.02 229.61,9.52 227.25,9.52 226.21,10.56 217.44,10.56 215.91,12.09 211.18,12.09 207.07,7.97 186.99,7.97 185.3,9.66 174.76,9.66 172.41,12.02 172.41,14.08 172.04,14.44 169.4,14.44 165.31,18.53 163.52,18.53 161.11,20.95 161.11,27.52 160.38,28.25 160.38,32.67 159.81,33.24 159.81,35.8 154.81,40.8 154.81,45.25 149.14,50.92 149.14,53.35 143.66,58.83 143.33,58.83 142.75,59.41 142.75,61.06 140.77,63.04 140.77,63.63 137.03,67.37 135.5,67.37 134.15,66.02 131.09,66.02 130.24,65.17 130.24,65.11
  BOTTOM w0.076: UCPU1.G16 128.76,62.2 129.05,62.49 v8(129.05,62.52)
PCIE_PRX_WLANTX_P3_C: length 2
  TOP w0.102: CH2.2 283.01,47.7 283.01,48.22 283.12,48.33 283.3,48.33 283.45,48.18 v8(283.45,48.12)
  BOTTOM w0.102: WL1.37 283.89,48.57 v8(283.45,48.12)
PCIE_PTX_CARDRX_N1: length 219.7
  IN3 w0.089: v3(128.32,65.88) 128.25,65.88 128.16,65.97 128.16,66.16 128.28,66.28 128.72,66.28 129.04,65.96 135.79,65.96 136.67,65.09 136.67,62.74 138.16,61.25 138.16,60.23 139.35,59.05 139.35,58.39 140.64,57.1 143.81,57.1 144.27,56.63 144.96,56.63 148.83,52.76 148.83,52 150.68,50.15 150.68,49.69 153.19,47.18 153.19,47.17 155.28,45.07 155.28,39.34 158.41,36.21 158.41,26.5 159.58,25.33 159.58,20.1 161.53,18.14 167.91,18.14 170.13,15.93 176.68,15.93 177.28,15.33 177.28,13.63 179.77,11.14 186.37,11.14 187.88,9.63 206.02,9.63 210.48,14.09 224.82,14.09 226.7,12.21 228.75,12.21 231.34,9.62 250.21,9.62 250.64,10.06 251.3,10.06 252.46,11.22 254.52,11.22 259.24,15.93 260.32,15.93 263.82,19.43 263.82,22.04 264.91,24.23 265.68,25.01 265.68,25.62 266.84,26.77 266.84,28.81 268.48,30.45 275.35,30.45 276.46,31.57 278.72,31.57 279.84,30.45 284.31,30.45 284.49,30.62 287.98,30.62 288.78,29.83 288.78,29.51 288.55,29.29 v8(288.46,29.29)
  GND3 w0.102: v4(127.96,65.57) 128.01,65.57 v3(128.32,65.88)
  BOTTOM w0.102: v8(288.46,29.29) 288.52,29.34 CR22.1
PCIE_PTX_CARDRX_N1_C: length 1.5
  BOTTOM w0.102: UR1.4 288.67,31.28 288.75,31.21 288.75,30.65 CR22.2
PCIE_PTX_CARDRX_P1: length 219.6
  IN3 w0.089: v3(128.14,66.64) 128.86,66.64 129.18,66.32 135.94,66.32 137.02,65.23 137.02,62.89 138.52,61.4 138.52,60.38 139.7,59.19 139.7,58.54 140.79,57.45 143.95,57.45 144.42,56.98 145.11,56.98 149.18,52.91 149.18,52.15 151.04,50.29 151.04,49.83 153.54,47.33 153.54,47.32 155.64,45.22 155.64,39.48 158.76,36.35 158.76,26.65 159.72,25.69 159.93,25.48 159.93,20.25 161.68,18.5 168.06,18.5 170.27,16.28 176.83,16.28 177.64,15.48 177.64,13.78 179.92,11.5 186.52,11.5 188.03,9.99 205.87,9.99 210.33,14.44 224.97,14.44 226.85,12.57 228.9,12.57 231.49,9.98 250.06,9.98 250.49,10.41 251.15,10.41 252.31,11.57 254.38,11.57 259.09,16.29 260.17,16.29 263.46,19.58 263.46,22.13 264.61,24.44 265.33,25.16 265.33,25.76 266.48,26.92 266.48,28.96 268.33,30.8 275.2,30.8 276.32,31.92 278.87,31.92 279.99,30.8 284.17,30.8 284.34,30.98 288.13,30.98 289.13,29.98 v8(289.13,29.29)
  GND3 w0.102: v3(128.14,66.64) 127.96,66.46 v4(127.96,66.22)
  BOTTOM w0.102: v8(289.13,29.29) 289.16,29.31 CR23.1
PCIE_PTX_CARDRX_P1_C: length 1.5
  BOTTOM w0.102: CR23.2 288.98,30.6 288.98,31.18 289.07,31.28 UR1.3
PCIE_PTX_SSDRX_N9: length 82.9
  IN2 w0.089: v8(123.37,67.41) 123.66,67.53 123.84,67.53 124.29,67.98 124.89,67.98 126.72,69.81 128.04,69.81 128.9,70.68 139.12,70.68 142.41,67.39 142.41,66.47 144.35,64.53 147.56,64.53 149.02,63.07 149.02,58.07 151.4,55.69 151.4,53.63 155.53,49.5 155.53,46.96 156.44,46.05 156.44,41.35 161.99,35.8 161.99,29.69 163.1,28.58 163.1,23.59 163.47,23.21 163.47,20.75 163.77,20.45 164.11,20.45 v3(164.22,20.34)
  GND3 w0.102: v3(164.22,20.34) 164.07,20.34 v4(163.63,19.9)
  BOTTOM w0.097: UCPU1.B23 124.13,65.76 123.71,66.17 123.71,67.16 123.46,67.41 v8(123.37,67.41)
PCIE_PTX_SSDRX_N9_C: length 2.7
  BOTTOM w0.102: JNGFF1.11 160.95,20.2 161.1,20.35 161.6,20.35 161.75,20.2 162.41,20.2 CD92.2
PCIE_PTX_SSDRX_N10: length 88.9
  IN2 w0.089: v3(164.22,22.73) 164.23,22.74 164.7,22.74 165.08,23.12 165.08,24.01 164.23,24.86 164.23,26.86 164.76,27.39 164.76,32.08 163.17,33.67 163.17,37.58 157.65,43.1 157.65,46.49 156.64,47.5 156.64,50 152.53,54.11 152.53,57.74 150.61,59.66 150.61,63.44 149.79,64.26 149.79,68.56 147.02,71.33 144.33,71.33 140.31,71.33 138.75,72.89 128.45,72.89 127.8,72.25 127.8,71.38 127.4,70.97 126.17,70.97 124.29,69.08 124.04,69.08 123.96,69.16 v8(123.95,69.16)
  GND3 w0.102: v4(163.63,22.56) 163.86,22.79 164.16,22.79 v3(164.22,22.73)
  BOTTOM w0.076: v8(123.95,69.16) 123.95,68.86 124.18,68.63 124.18,67.45 124.25,67.38 124.25,66.76 124.56,66.45 124.56,66.06 124.55,65.96 124.55,65.87 124.56,65.65 124.56,65.39 124.53,65.32 124.44,64.89 UCPU1.D23
PCIE_PTX_SSDRX_N10_C: length 2.8
  BOTTOM w0.102: JNGFF1.23 160.89,23.2 161.02,23.33 161.48,23.33 161.91,22.89 162.38,22.89 CD94.2
PCIE_PTX_SSDRX_N11: length 93
  IN2 w0.089: v3(165.43,24.47) 165.31,24.59 165.09,24.59 164.63,25.05 164.63,26.64 165.95,27.96 165.95,30.55 165.73,30.77 165.73,32.53 164.88,33.38 164.88,34.9 164.43,35.35 164.43,37.91 159.93,42.41 158.9,42.41 158.04,43.27 158.04,46.66 157.22,47.48 157.22,49.98 152.97,54.23 152.97,57.86 151.03,59.81 151.03,63.74 150.23,64.54 150.23,68.78 147.17,71.83 144.75,71.83 143.29,73.29 126.4,73.29 124.57,71.45 124.57,71.06 122.72,69.22 122.08,69.22 v3(121.91,69.05)
  GND3 w0.102: v3(121.91,69.05) 122.02,69.16 122.25,69.16 v4(122.31,69.1) ; v3(165.43,24.47) 165.26,24.64 164.95,24.64 v4(164.78,24.47)
  BOTTOM w0.076: v4(122.31,69.1) 122.22,69.19 122.1,69.19 121.99,69.08 v10(121.99,68.33) 121.99,67.94 123.5,66.42 123.5,65.96 123.68,65.78 123.68,65.6 123.85,65.43 123.85,65.13 123.56,64.85 UCPU1.D24
  BOTTOM w0.102: CD96.1 163.98,24.69 164.55,24.69 v4(164.78,24.47)
PCIE_PTX_SSDRX_N11_C: length 3.9
  BOTTOM w0.102: JNGFF1.35 161.2,26.2 161.33,26.33 161.48,26.33 161.87,25.94 161.87,24.93 162.14,24.66 162.4,24.66 CD96.2
PCIE_PTX_SSDRX_P9: length 82.9
  IN2 w0.089: v3(164.22,20.9) 164.12,20.81 163.92,20.81 163.83,20.9 163.83,23.36 163.45,23.74 163.45,28.73 162.35,29.83 162.35,35.94 156.8,41.49 156.8,46.2 155.88,47.11 155.88,49.65 151.76,53.78 151.76,55.84 149.38,58.22 149.38,63.22 147.71,64.88 144.5,64.88 142.76,66.62 142.76,67.54 139.27,71.03 128.76,71.03 127.89,70.17 126.58,70.17 124.74,68.34 124.14,68.34 123.69,67.89 123.46,67.89 123.37,67.98 v8(123.37,68.09)
  GND3 w0.102: v3(164.22,20.9) 164.1,20.78 v4(163.63,20.78)
  BOTTOM w0.097: UCPU1.A23 124.05,66.22 123.91,66.36 123.91,67.23 123.74,67.41 123.74,67.57 123.37,67.94 v8(123.37,68.09)
PCIE_PTX_SSDRX_P9_C: length 2.7
  BOTTOM w0.102: JNGFF1.13 161,20.7 161.12,20.58 161.69,20.58 161.84,20.43 162.36,20.43 CD93.2
PCIE_PTX_SSDRX_P10: length 88.9
  IN2 w0.089: v8(123.27,69.16) 123.7,68.73 124.43,68.73 126.32,70.62 127.55,70.62 128.16,71.23 128.16,72.1 128.59,72.54 138.6,72.54 140.16,70.98 144.33,70.98 146.87,70.98 149.44,68.41 149.44,64.11 150.26,63.29 150.26,59.51 152.17,57.6 152.17,53.97 156.28,49.86 156.28,47.36 157.29,46.35 157.29,42.96 162.81,37.43 162.81,33.52 164.4,31.93 164.4,27.54 163.87,27.01 163.87,24.71 164.72,23.86 164.72,23.26 164.55,23.09 164.32,23.09 164.24,23.18 v3(164.24,23.4)
  GND3 w0.102: v3(164.24,23.4) 164.24,23.35 164.07,23.19 163.89,23.19 v4(163.63,23.45)
  BOTTOM w0.076: UCPU1.C23 124.1,64.92 124.02,65 124.02,65.18 124.11,65.27 124.25,65.27 124.38,65.4 124.38,65.65 124.38,65.65 124.38,65.67 124.37,65.87 124.37,65.97 124.38,66.07 124.38,66.37 124.09,66.67 124.09,67.31 124.02,67.38 124.02,68.56 123.64,68.94 123.35,68.94 123.27,69.02 v8(123.27,69.16)
PCIE_PTX_SSDRX_P10_C: length 2.8
  BOTTOM w0.102: JNGFF1.25 160.91,23.7 161.05,23.56 161.57,23.56 162.01,23.12 162.39,23.12 CD95.2
PCIE_PTX_SSDRX_P11: length 93.1
  IN2 w0.089: v3(121.91,69.65) 121.98,69.58 122.58,69.58 124.21,71.21 124.21,71.6 126.25,73.64 143.44,73.64 144.9,72.19 147.32,72.19 150.58,68.92 150.58,64.69 151.38,63.89 151.38,59.95 153.33,58.01 153.33,54.38 157.57,50.13 157.57,47.71 158.4,46.89 158.4,43.41 159.04,42.77 160.08,42.77 164.79,38.06 164.79,35.5 165.24,35.05 165.24,33.53 166.09,32.67 166.09,30.92 166.31,30.7 166.31,27.81 164.99,26.5 164.99,25.2 165.24,24.95 165.37,24.95 v3(165.44,25.02)
  GND3 w0.102: v3(121.91,69.65) 122.07,69.65 122.22,69.49 v4(122.32,69.49) ; v4(164.78,25.05) 164.96,24.87 165.29,24.87 v3(165.44,25.02)
  BOTTOM w0.076: UCPU1.C24 123.56,65.17 123.49,65.1 123.31,65.1 123.19,65.21 123.19,65.32 123.51,65.64 123.51,65.72 123.34,65.89 123.34,66.35 121.82,67.87 121.82,68.08 121.82,68.08 121.82,68.58 121.82,68.59 121.82,69.15 122.05,69.38 122.2,69.38 v4(122.32,69.49)
  BOTTOM w0.102: v4(164.78,25.05) 164.65,24.92 163.94,24.92 CD97.1
PCIE_PTX_SSDRX_P11_C: length 3.9
  BOTTOM w0.102: JNGFF1.37 161.2,26.7 161.33,26.56 161.57,26.56 162.1,26.04 162.1,25.02 162.23,24.89 162.37,24.89 CD97.2
PCIE_PTX_TBRX_N5: length 128.1
  IN2 w0.076: v3(126.37,64.69) 126.26,64.58 126.26,64.41 126.36,64.31 126.57,64.31 126.94,64.68 126.94,64.9 126.56,65.28 124.1,65.28 124,65.19 123.99,65.19
  IN2 w0.089: 123.99,65.19 121.55,65.19 120.97,65.77 113,65.77 110.86,67.91 110.86,68.4 109.95,69.3 108.88,69.3 107.95,70.23 107.68,70.23 106.83,69.39 95.04,69.39 94.67,69.02 91.04,69.02 89.7,70.36 87.54,70.36 85.88,68.7 79.28,68.7 77.48,70.49 71.7,70.49 71.14,69.93 53.71,69.93 51.91,68.13 46.98,68.13 44.6,65.74 44.04,65.74 42.39,64.09 37.85,64.09 32.27,58.51 31.22,58.51 30.89,58.18 30.89,57.33 31.85,56.38 31.85,55.11 30.2,53.47 30.2,52.04 29.87,51.7 29.87,43.02 28.93,42.08 28.93,40.6 v3(29.07,40.46)
  GND3 w0.102: v4(28.8,40.12) 28.8,40.23 29.03,40.46 v3(29.07,40.46) ; v3(126.37,64.69) 126.39,64.66 126.6,64.66 126.69,64.75 126.69,64.84 v4(126.61,64.92)
PCIE_PTX_TBRX_N5_C: length 3.3
  BOTTOM w0.076: UT2.Y22 26.87,42.87 27.09,42.65 27.09,42.25 27.55,41.79 27.93,41.79 28.57,41.15 28.57,40.94 CT3.1
PCIE_PTX_TBRX_N6: length 135.1
  IN2 w0.089: v3(109.21,71.48) 109.21,71.25 109.33,71.13 109.48,71.13 109.59,71.24 109.59,71.64 109.33,71.9 106.46,71.9 106.01,71.46 101.56,71.46 101.1,71 91.18,71 90.27,71.91 86.6,71.91 84.84,70.15 79.88,70.15 78.09,71.94 53.45,71.94 52.1,70.6 47.23,70.6 46.35,69.72 45.14,69.72 44.61,69.19 44.61,68.66 41.62,65.67 36.07,65.67 29.2,58.81 29.2,55.55 28.37,54.72 28.37,54.31 28.04,53.98 28.04,51.85 28.37,51.52 28.37,43.65 25.9,41.18 25.9,40.91 26.01,40.8 26.11,40.8 26.22,40.69 26.22,40.56 v3(26.13,40.48)
  GND3 w0.102: v3(109.21,71.48) 109.61,71.88 v4(109.61,72.06) ; v4(26.13,40.12) 26.1,40.15 26.1,40.45 v3(26.13,40.48)
  BOTTOM w0.076: 125.89,68.21 125.9,68.19 125.9,68.15 126.18,67.88 126.18,66.76 126.33,66.61 126.33,65.01 126.04,64.73 UCPU1.D20
  BOTTOM w0.102: 125.89,68.21 121.68,72.42 121.68,73.29 121.11,73.86 110.71,73.86 109.61,72.75 v4(109.61,72.06)
PCIE_PTX_TBRX_N6_C: length 2.7
  BOTTOM w0.076: CT20.1 25.9,40.94 25.9,41.46 25.26,42.1 25.26,42.66 25.03,42.88 UT2.T22
PCIE_PTX_TBRX_N7: length 136.3
  IN2 w0.076: v3(126,67.52) 126,67.47 125.85,67.32 125.29,67.32 124.86,66.89 124.11,66.89 124.01,66.99 123.99,66.99
  IN2 w0.089: v3(23.07,40.45) 23.17,40.54 23.17,41.23 23.74,41.8 24.86,41.8 27.26,44.2 27.26,50.45 26.87,50.85 26.87,56.42 26.66,56.63 26.66,57.98 35.54,66.86 40.44,66.86 44.41,70.82 45.8,70.82 47.35,72.37 48.21,72.37 48.86,73.02 78.54,73.02 80.33,71.23 82.77,71.23 84.57,73.03 90.71,73.03 91.2,72.54 91.61,72.54 92.09,73.02 100.99,73.02 101.45,72.57 105.35,72.57 105.79,73.01 111.1,73.01 111.63,72.48 111.63,70.29 112.79,69.13 112.79,68.67 113.69,67.76 115.52,67.76 116.55,68.79 121.03,68.79 122.82,66.99 123.99,66.99
  GND3 w0.102: v3(126,67.52) 125.65,67.17 v4(125.62,67.17) ; v4(23.06,40.11) 23.06,40.44 v3(23.07,40.45)
  BOTTOM w0.076: v4(125.62,67.17) 125.47,67.02 125.25,67.02 125.03,66.79 125.03,66.14 125.1,65.94 125.47,65.57 UCPU1.B21
PCIE_PTX_TBRX_N7_C: length 2.5
  BOTTOM w0.076: 23.22,41.49 23.22,41.95 23.15,42.02 23.15,42.15 22.97,42.32 22.97,42.7 23.19,42.92 UT2.M22
  BOTTOM w0.102: CT7.1 23.22,40.85 23.22,41.49
PCIE_PTX_TBRX_N8: length 129.6
  IN3 w0.076: v3(125.84,64.14) 125.67,64.3 125.49,64.3 125.32,64.13 125.32,63.37 124.82,62.88 124.82,62.52 124.04,61.73 123.67,61.73 123.58,61.64 123.56,61.64
  IN3 w0.089: v3(32.8,40.29) 32.95,40.44 33.87,40.44 38.79,45.36 38.79,48.07 40.64,49.92 40.64,50.42 44.71,54.5 44.71,59.68 46.22,61.18 48.47,61.18 50.16,62.87 52.75,62.87 56.14,66.26 59.83,66.26 59.99,66.1 76.34,66.1 77.52,64.92 78.34,64.92 78.84,64.42 79.71,64.42 84.25,59.88 93,59.88 94.33,61.21 95,61.21 96.13,62.34 100.93,62.34 101.55,62.95 102.88,62.95 104.35,61.48 107.04,61.48 107.45,61.07 108.74,61.07 109.05,61.37 119.34,61.37 119.6,61.64 123.56,61.64
  GND3 w0.102: v4(125.48,64.27) 125.61,64.14 v3(125.84,64.14) ; v3(32.8,40.29) 32.51,40.29 v4(32.44,40.22)
  BOTTOM w0.102: CT11.2 20.72,39.33 21.24,38.82 v10(25.08,38.82) 28.66,38.82 30.07,40.22 v4(32.44,40.22)
PCIE_PTX_TBRX_N8_C: length 2.6
  BOTTOM w0.076: CT11.1 20.93,40.92 20.93,41.35 21.29,41.71 21.29,42.16 21.13,42.31 21.13,42.67 21.35,42.89 UT2.H22
PCIE_PTX_TBRX_P5: length 128
  IN2 w0.076: 124.03,65.54 124.13,65.45 126.63,65.45 127.11,64.97 v3(127.11,64.32)
  IN2 w0.089: 124.03,65.54 121.7,65.54 121.11,66.13 113.14,66.13 111.21,68.06 111.21,68.55 110.1,69.66 109.02,69.66 108.1,70.59 107.53,70.59 106.68,69.74 94.89,69.74 94.52,69.37 91.19,69.37 89.84,70.72 87.39,70.72 85.73,69.06 79.43,69.06 77.63,70.85 71.56,70.85 70.99,70.28 53.56,70.28 51.76,68.49 46.84,68.49 44.45,66.1 43.89,66.1 42.24,64.45 37.7,64.45 32.12,58.87 31.07,58.87 30.54,58.33 30.54,57.18 31.49,56.23 31.49,55.26 29.85,53.61 29.85,52.19 29.51,51.85 29.51,43.17 28.57,42.23 28.57,40.56 v3(28.48,40.47)
  GND3 w0.102: v3(127.11,64.32) 127.06,64.27 v4(126.61,64.27) ; v3(28.48,40.47) 28.17,40.15 v4(28.17,40.12)
PCIE_PTX_TBRX_P5_C: length 3.3
  BOTTOM w0.076: CT1.1 28.4,40.94 28.4,41.09 27.86,41.62 27.48,41.62 26.93,42.18 26.73,42.18 26.64,42.26 26.64,42.5 26.73,42.58 26.79,42.58 26.87,42.5 UT2.Y23
PCIE_PTX_TBRX_P6: length 135.1
  IN2 w0.089: v3(109.96,71.48) 109.96,71.77 109.47,72.26 106.31,72.26 105.86,71.81 101.41,71.81 100.95,71.35 91.33,71.35 90.42,72.26 86.45,72.26 84.7,70.5 80.03,70.5 78.24,72.3 53.3,72.3 51.95,70.95 47.09,70.95 46.21,70.08 45,70.08 44.25,69.33 44.25,68.81 41.48,66.03 35.92,66.03 28.85,58.95 28.85,55.7 28.01,54.87 28.01,54.45 27.69,54.13 27.69,51.7 28.01,51.38 28.01,43.8 25.54,41.33 25.54,40.91 25.54,40.82 v3(25.54,40.48)
  GND3 w0.102: v4(110.17,72.06) 110.06,72.06 109.94,71.94 109.94,71.5 v3(109.96,71.48) ; v3(25.54,40.48) 25.5,40.43 v4(25.5,40.12)
  BOTTOM w0.076: 125.73,68.05 125.74,68.03 125.79,68.03 126.01,67.81 126.01,66.69 126.16,66.54 126.16,65.62 126.08,65.54 125.86,65.54 125.66,65.34 125.66,65.17 125.9,64.92 126,64.92 126.13,65.05 126.13,65.16 UCPU1.C20
  BOTTOM w0.102: v4(110.17,72.06) 110.06,72.06 109.83,72.29 109.83,72.65 110.81,73.63 v10(113.84,73.63) 121.02,73.63 121.45,73.2 121.45,72.32 125.73,68.05
PCIE_PTX_TBRX_P6_C: length 2.7
  BOTTOM w0.076: CT5.1 25.73,40.94 25.73,41.39 24.93,42.19 24.93,42.19 24.8,42.32 24.8,42.56 24.87,42.64 24.97,42.64 25.03,42.57 UT2.T23
PCIE_PTX_TBRX_P7: length 136.3
  IN2 w0.076: 123.99,66.63 124.01,66.63 124.11,66.73 124.93,66.73 125.36,67.15 126.1,67.15 126.22,67.03 126.22,66.89 126.1,66.77 v3(126,66.77)
  IN2 w0.089: v3(23.64,40.44) 23.52,40.56 23.52,41.08 23.89,41.44 25.01,41.44 27.62,44.06 27.62,50.6 27.22,51 27.22,56.57 27.01,56.78 27.01,57.83 35.69,66.5 40.59,66.5 44.56,70.47 45.95,70.47 47.5,72.02 48.36,72.02 49.01,72.67 78.39,72.67 80.18,70.87 82.91,70.87 84.72,72.67 90.56,72.67 91.05,72.18 91.76,72.18 92.24,72.67 100.85,72.67 101.3,72.21 105.49,72.21 105.94,72.66 110.95,72.66 111.27,72.34 111.27,70.14 112.43,68.99 112.43,68.52 113.54,67.41 115.67,67.41 116.7,68.43 120.88,68.43 122.68,66.63 123.99,66.63
  GND3 w0.102: v4(125.62,66.67) 125.62,66.74 125.72,66.84 125.92,66.84 v3(126,66.77) ; v4(23.64,40.11) 23.64,40.44 v3(23.64,40.44)
  BOTTOM w0.076: UCPU1.A21 125.56,66.22 125.66,66.13 125.66,65.98 125.56,65.88 125.39,65.88 125.24,66.03 125.19,66.17 125.19,66.72 125.32,66.85 125.43,66.85 v4(125.62,66.67)
PCIE_PTX_TBRX_P7_C: length 2.5
  BOTTOM w0.076: 23.43,41.49 23.43,41.49 23.4,41.53 23.4,42 23.31,42.09 23.31,42.19 23.42,42.3 23.42,42.61 23.37,42.67 23.26,42.67 23.19,42.6 UT2.M23
  BOTTOM w0.102: CT22.1 23.43,40.91 23.43,41.49
PCIE_PTX_TBRX_P8: length 129.6
  IN3 w0.076: 123.56,61.99 123.58,61.99 123.67,61.9 123.97,61.9 124.66,62.59 124.66,62.95 125.15,63.44 125.15,64.2 125.42,64.47 125.54,64.47 v3(125.84,64.76)
  IN3 w0.089: 123.56,61.99 119.45,61.99 119.19,61.73 108.9,61.73 108.59,61.42 107.6,61.42 107.18,61.84 104.5,61.84 103.03,63.31 101.4,63.31 100.79,62.7 95.98,62.7 94.85,61.56 94.18,61.56 92.85,60.24 84.4,60.24 79.86,64.78 78.98,64.78 78.49,65.27 77.67,65.27 76.48,66.46 60.14,66.46 59.98,66.62 55.99,66.62 52.6,63.23 50.01,63.23 48.32,61.54 46.07,61.54 44.36,59.82 44.36,54.64 40.28,50.57 40.28,50.06 38.44,48.22 38.44,45.51 33.73,40.8 32.86,40.8 v3(32.81,40.85)
  GND3 w0.102: v4(125.48,64.92) 125.49,64.91 125.69,64.91 v3(125.84,64.76) ; v4(32.48,40.68) 32.54,40.68 32.7,40.85 v3(32.81,40.85)
  BOTTOM w0.076: 29.95,40.43 29.92,40.41
  BOTTOM w0.102: 29.92,40.41 28.57,39.05 v10(27.33,39.05) 21.33,39.05 20.95,39.43 20.95,39.62 21.05,39.72 21.2,39.72 21.31,39.83 CT9.2 ; v4(32.48,40.68) 32.45,40.68 32.22,40.45 29.97,40.45 29.95,40.43
PCIE_PTX_TBRX_P8_C: length 2.6
  BOTTOM w0.076: CT9.1 21.11,40.9 21.11,41.28 21.47,41.63 21.47,42.17 21.59,42.29 21.59,42.62 21.52,42.69 21.41,42.69 21.35,42.62 UT2.H23
PCIE_PTX_WLANRX_N3: length 231.4
  GND1 w0.102: v1(281.27,45.93) 281.44,45.93 v3(281.61,45.76)
  IN2 w0.089: v3(128.37,64.47) 128.29,64.47 128.13,64.63 128.13,64.83 128.25,64.95 128.91,64.95 130.91,66.95 132.55,66.95 134.64,69.04 138.11,69.04 143.38,63.77 147.16,63.77 148.27,62.65 148.27,57.31 148.52,57.07 148.52,56.04 150.1,54.46 150.1,51.14 155.61,45.62 155.61,41.1 160.58,36.14 160.58,33.94 161.23,33.29 161.23,29.36 162.35,28.24 162.35,23.17 162.71,22.8 162.71,20.42 163.85,19.28 166.26,19.28 169.56,15.98 173.4,15.98 174.08,15.3 174.08,12.82 174.61,12.3 177.3,12.3 179.18,10.42 185.68,10.42 187.37,8.74 206.57,8.74 210.76,12.93 220.55,12.93 222.16,11.32 226.5,11.32 227.56,10.27 230.02,10.27 231.49,8.8 249.08,8.8 250.19,9.92 250.99,9.92 252.64,11.57 253.68,11.57 258.77,16.66 259.93,16.66 263.53,20.26 263.53,23.06 266.07,25.6 266.07,30.46 266.5,30.89 266.5,37.13 270.05,40.68 271.52,40.68 279.1,48.26 281.5,48.26 282.52,47.24 282.52,45.97 282.01,45.46 281.77,45.46 281.61,45.63 v3(281.61,45.76)
  GND3 w0.102: v3(128.37,64.47) 128.25,64.59 128.09,64.59 127.96,64.46 v4(127.96,64.27)
PCIE_PTX_WLANRX_N3_C: length 3.4
  TOP w0.102: v8(283.33,46.96) 283.14,46.76 282.92,46.76 282.63,46.47 282.63,45.73 282.51,45.6 282.36,45.6 282.18,45.78 CH4.2
  BOTTOM w0.102: v8(283.33,46.96) 283.94,47.57 WL1.39
PCIE_PTX_WLANRX_P3: length 231.4
  GND1 w0.102: v3(281.65,45.1) 281.58,45.04 v1(281.27,45.04)
  IN2 w0.089: v3(281.65,45.1) 282.16,45.1 282.88,45.83 282.88,47.39 281.64,48.62 278.96,48.62 271.37,41.03 269.91,41.03 266.15,37.28 266.15,31.04 265.71,30.6 265.71,25.75 263.17,23.21 263.17,20.4 259.78,17.01 258.62,17.01 253.53,11.92 252.49,11.92 250.84,10.27 250.05,10.27 248.93,9.16 231.64,9.16 230.17,10.62 227.71,10.62 226.65,11.68 222.3,11.68 220.7,13.28 210.61,13.28 206.42,9.09 187.52,9.09 185.83,10.78 179.33,10.78 177.45,12.65 174.75,12.65 174.44,12.97 174.44,15.45 173.55,16.34 169.71,16.34 166.41,19.64 164,19.64 163.07,20.57 163.07,22.95 162.7,23.32 162.7,28.39 161.58,29.51 161.58,33.44 160.94,34.09 160.94,36.28 155.97,41.25 155.97,45.77 150.46,51.28 150.46,54.61 148.87,56.19 148.87,57.21 148.62,57.46 148.62,62.8 147.3,64.12 143.53,64.12 138.25,69.4 134.49,69.4 132.4,67.31 130.77,67.31 128.8,65.34 v3(128.49,65.34)
  GND3 w0.102: v3(128.49,65.34) 128.27,65.11 128.15,65.11 v4(127.96,64.92)
PCIE_PTX_WLANRX_P3_C: length 3.4
  TOP w0.102: CH5.2 282.18,45.08 282.48,45.37 282.6,45.37 282.86,45.63 282.86,46.37 283.02,46.53 283.14,46.53 v8(283.34,46.34)
  BOTTOM w0.102: v8(283.34,46.34) 283.34,46.39 284.02,47.07 WL1.40
PCIE_RBIAS: length 5.4
  TOP w0.305: v8(23.52,45.26) 23.62,45.26 24.04,44.84 24.04,44.29 24.25,44.09 24.25,43.3 24.46,43.09 v2(24.46,42.67) 24.46,42.23 23.61,41.38 RT7.2
  BOTTOM w0.203: UT2.N16 23.83,45.6 23.52,45.29 v8(23.52,45.26)
PCIE_RCOMPN: length 1.6
  TOP w0.305: v8(134.42,63.14) 134.59,62.96 134.63,62.96 135.15,62.44 RC50.1
  BOTTOM w0.254: v8(134.42,63.14) 134.71,62.85 UCPU1.F5
PCIE_RCOMPP: length 2.3
  TOP w0.305: RC50.2 134.88,63.65 134.16,63.65 v2(134.14,63.62)
  GND1 w0.254: v3(135.38,63.77) 135.25,63.64 135.25,63.36 v1(135.18,63.29)
  GND3 w0.254: v4(134.9,63.5) 135.11,63.5 v3(135.38,63.77)
PCIE_WAKE#: length 366.1
  TOP w0.095: v2(12.75,25.41) 12.4,25.05 RE185.1 10.96,25.05 RE186.1 10.71,25.28 v7(10.02,24.59)
  IN1 w0.076: v8(284.81,52.98) 284.19,52.36 280.09,52.36 277.42,49.69 277.42,39.81 279.23,38 279.23,35.44 278.78,34.99 278.78,32.55 279.43,31.9 279.43,27.9 279.33,27.79 279.33,26.47 279.87,25.93 279.87,22.66 279.47,22.26 279.47,19.81 278.66,19 278.66,15.37 277.24,13.95 275.1,13.95 273.74,12.59 264.72,12.59 260.89,8.75 259.1,8.75 257.97,7.63 257.97,7.24 256.51,5.77 255.93,5.77 255.14,4.98 253.42,4.98 252.76,4.32 227.46,4.32 225.94,5.84 225.94,6.15 224.28,7.82 217.38,7.82 215.64,6.07 185.29,6.07 183.38,7.98 169.29,7.98 167.82,9.46 164.95,9.46 164.27,10.14 160.91,10.14 158.69,7.91 152.91,7.91 150,10.82 145.13,10.82 144.74,11.22 138.59,11.22 137.96,10.58 118.18,10.58 115.84,8.24 115.53,8.24 115.07,7.78 112.93,7.78 112.16,7.01 80.92,7.01 77.1,3.19 74.21,3.19 73.92,2.9 68.41,2.9 68.32,2.99 63.07,2.99 62.38,3.68 58.46,3.68 58.25,3.88 50.45,3.88 47.61,6.73 36.28,6.73 35.65,6.09 33.25,6.09 32.62,6.71 31.21,6.71 30.09,7.83 28.09,7.83 27.46,7.2 26.76,7.2 26.05,7.91 25.59,7.91 24.13,9.37 22.2,9.37 21.78,8.95 21.78,7.58 20.42,6.21 15.48,6.21 13.72,4.45 11,4.45 10.08,5.37 9.56,5.37 6.69,8.23 6.69,10.87 3.94,13.63 3.94,17.89 3.34,18.49 3.34,20 5.8,22.46 7.24,22.46 7.88,23.1 7.88,24.04 8.43,24.59 v7(10.02,24.59)
  BOTTOM w0.095: WL1.29 284.35,52.57 284.76,52.98 v8(284.81,52.98)
PCIE_WAKE#_AR: length 18.4
  TOP w0.095: RT432.2 29.29,48.44 28.95,48.79 v2(28.95,48.99) 28.95,49.17 29.41,49.64 29.41,51.7 RT433.2 29.87,52.95 28.22,54.6 v1(28.13,54.6)
  GND1 w0.095: v3(27.61,54.6) v1(28.13,54.6)
  GND3 w0.095: v4(26.93,54.6) v3(27.61,54.6)
  IN4 w0.076: v4(26.93,54.6) 27.22,54.31 27.64,54.31 27.91,54.58 29.98,54.58 30.91,55.51 31.59,55.51 31.74,55.66 v5(31.74,55.95)
  BOTTOM w0.076: UT2.W1 26.41,53.99
  BOTTOM w0.095: RT431.2 32.26,56.47 v5(31.74,55.95) ; 26.41,53.99 26.41,54.09 v4(26.93,54.6)
PCIE_WAKE#_R: length 270.7
  TOP w0.095: UE3.N13 15.1,20.71 v2(14.75,21.06) 14.26,21.55 12.52,21.55 12.02,22.04 12.02,22.34 RE127.1 11.6,22.89 11.6,24.1 v1(11.56,24.14) ; v7(149.83,28.11) 149.8,28.14 149.8,28.37 R264.2
  IN1 w0.076: v9(131.6,41.19) 134.19,38.6 134.19,36.46 135.44,35.22 139.85,35.22 140.28,35.65 142.42,35.65 149.83,28.24 v7(149.83,28.11)
  GND1 w0.095: v9(131.6,41.19) 131.44,41.19 v3(131.22,40.96) ; v1(11.56,24.14) 10.98,24.72 v3(10.98,24.8)
  IN2 w0.064: v3(37.64,39.56) 37.22,39.56 36.5,38.84 36.5,36.88 36.74,36.64 36.99,36.64 37.8,35.83 37.8,28.93 38.63,28.1 38.63,26.67 38.13,26.17 38.13,25.65 37.02,24.54 37.02,22.87 37.49,22.4 37.68,22.4 38.12,21.96 38.12,20.82 39.11,19.83 39.11,19.12 40.74,17.48 42.76,17.48 44.86,15.38 52.61,15.38 55.28,12.71 60.47,12.71 60.75,12.44 61.45,12.44 62.28,11.6 62.28,10.75 62.6,10.44 70.18,10.44 70.9,11.15 74.57,11.15 75.02,11.61 76.34,11.61 78.49,13.76 78.49,15.46 77.93,16.01 77.93,20.03 76.28,21.68 76.28,22.42 v8(76.66,22.79)
  IN3 w0.064: v3(31,56.18) 31.5,55.68 31.5,54.58 30.24,53.32 ; v3(10.98,24.8) 10.98,24.92 8.7,27.2 8.7,28.87 7.79,29.78 7.79,31.07 9.37,32.66 9.37,36.49 9.81,36.93 9.81,38.15 10.15,38.49 10.15,39.74 11.06,40.64 11.06,43.76 10.77,44.05 10.77,44.6 11.3,45.14 11.3,49.28 13.16,51.14 13.16,53.32 14.96,55.11 14.96,58.46 15.81,59.31 20.04,59.31 20.64,58.71 23.29,58.71 25.53,56.48 25.53,54.62 26.04,54.11 28.2,54.11 28.41,53.9
  IN3 w0.076: 28.41,53.9 29.02,53.28 30.2,53.28 30.24,53.32
  GND3 w0.095: v4(37.55,39.92) 37.55,39.66 v3(37.64,39.56) ; v3(31,56.18) 31.07,56.18 31.21,56.32 v4(31.35,56.32) ; v6(130.35,40.96) v3(131.22,40.96)
  IN4 w0.076: v5(34.69,53.42) 32.81,55.3 32.55,55.3 32.06,55.8 32.06,56.13 31.87,56.32 v4(31.35,56.32) ; v6(130.35,40.96) 130.48,40.96 130.76,40.68 130.76,34.71 130.02,33.97 106.52,33.97 106.23,34.26 102.37,34.26 101.78,33.67 83.58,33.67 80.39,30.47 80.39,30.17 79.87,29.65 79.87,25.78 76.88,22.79 v8(76.66,22.79)
  BOTTOM w0.095: RT27.2 30.72,56.85 RT431.1 v4(31.35,56.32) ; v4(37.55,39.92) 37.55,39.94 36.05,41.44 36.05,43.84 38.7,46.49 38.7,47.54 38.35,47.89 37.37,47.89 37.16,47.68 37.16,47.62 36.37,46.82 35.49,46.82 34.84,47.47 34.84,53.28 v5(34.69,53.42)
PD1_EE_CLK: length 35.3
  TOP w0.095: R5778.1 34.93,34.82 34.87,34.75 v1(34.73,34.75)
  GND1 w0.095: v1(34.73,34.75) 34.75,34.73 34.75,34.44 v3(34.78,34.41) ; v3(22.99,31.38) 23.13,31.53 23.13,31.61 23.23,31.71 v1(23.43,31.71)
  IN2 w0.064: v3(8.39,30.94) 8.43,30.9 9.28,30.9 12.87,27.31 15.41,27.31 17.25,29.16 19.9,29.16 21.29,30.55 21.83,30.55 22.53,31.25 22.85,31.25 v3(22.99,31.38) 23.53,31.38 23.84,31.07 24.43,31.07 25.4,30.1 28.79,30.1 29.37,30.68 30.09,30.68 31.27,31.86 32.66,31.86 33.61,32.81 34.58,32.81 35.02,33.25 35.02,34.17 v3(34.78,34.41)
  GND3 w0.095: v4(7.63,30.94) v3(8.39,30.94)
PD1_EE_CLK_F: length 1.6
  TOP w0.076: 22.75,31.8 22.24,32.31 U19.A3
  TOP w0.095: R5777.2 22.75,31.8
PD1_EE_CS#: length 30.8
  TOP w0.095: v1(25.02,30.42) 25.02,30.78 v2(24.3,31.5) 24.07,31.73 24.07,32.02 23.82,32.27 R5776.1 ; v1(34.71,35.14) 34.71,35.15 34.96,35.4 R5781.1
  GND1 w0.095: v3(25.47,30.61) 25.21,30.61 v1(25.02,30.42) ; v1(34.71,35.14) 34.62,35.04 v3(34.37,35.04)
  IN2 w0.064: v3(34.37,35.04) 34.37,35.02 34.09,34.74 34.09,34.43 34.78,33.74 34.78,33.28 34.5,33 33.53,33 32.58,32.05 31.19,32.05 30.01,30.87 29.29,30.87 28.72,30.3 25.77,30.3 v3(25.47,30.61) 24.81,31.26 24.07,31.26 23.83,31.5 23.83,31.5 23.55,31.78 22.27,31.78 20.81,33.24 18.36,33.24 17.86,33.74 v3(16.72,33.74)
  GND3 w0.095: v4(16.38,33.74) v3(16.72,33.74)
  BOTTOM w0.095: UT4.1 14.9,33.48 15.09,33.29 15.93,33.29 v4(16.38,33.74)
PD1_EE_CS#_F: length 1.9
  IN1 w0.076: v7(20.98,32.31) 22.35,32.31 22.38,32.27 v7(22.85,32.27)
PD1_EE_DI: length 33.3
  TOP w0.095: R5779.1 35.03,33.22 34.79,32.98 v1(34.79,32.86)
  GND1 w0.095: v3(23.37,30.73) 23.37,31.06 v1(23.43,31.11) ; v1(34.79,32.86) v3(34.79,32.49)
  IN2 w0.064: v3(34.79,32.49) 34.66,32.62 33.69,32.62 32.74,31.67 31.35,31.67 30.17,30.49 29.44,30.49 28.87,29.91 25.25,29.91 24.87,30.29 23.82,30.29 v3(23.37,30.73) 22.36,30.73 21.59,29.96 21.59,29.34 21.22,28.97 17.33,28.97 15.49,27.12 12.79,27.12 10.03,29.88 v3(8.33,29.88)
  GND3 w0.095: v3(8.33,29.88) 8.12,29.67 v4(7.63,29.67)
PD1_EE_DI_F: length 2.2
  IN1 w0.076: v7(20.98,31.81) 22.15,31.81 v7(22.85,31.11)
PD1_EE_DO: length 30
  TOP w0.095: R5775.1 23.75,30.23 v1(24.13,30.23) 24.75,30.23 v2(25.03,29.94)
  GND1 w0.095: v1(24.13,30.23) v3(24.6,29.75) ; v1(35.37,33.81) 35.37,33.74 v3(35.62,33.49)
  IN2 w0.064: v3(24.6,29.75) 24.64,29.71 28.94,29.71 29.36,30.13 30.89,30.13 31.08,30.32 31.08,30.98 31.58,31.48 32.82,31.48 33.75,32.41 34.23,32.41 34.6,32.05 35.09,32.05 35.42,32.37 35.42,33.29 v3(35.62,33.49)
  IN3 w0.064: v3(24.6,29.75) 23.37,29.75 22.35,30.78 22.35,31.42 21.55,32.22 18.38,32.22 17.84,32.76 17.14,32.76 v3(16.71,33.2)
  GND3 w0.095: v4(16.38,33.1) 16.61,33.1 v3(16.71,33.2)
  BOTTOM w0.095: v4(16.38,33.1) 16.12,32.84 15.14,32.84 14.52,32.21 UT4.2
PD1_EE_DO_F: length 1.9
  TOP w0.076: U19.A4 21.58,31.81 22.75,30.64
  TOP w0.095: R5775.2 22.75,30.64
PD1_EE_WP#: length 3.8
  BOTTOM w0.095: UT4.3 R169.2 v2(16.38,30)
PD1_GPIO0: length 3
  TOP w0.076: 22.21,33.06 21.59,33.06 21.58,33.06 21.37,33.06 21.37,33.06 21.36,33.06 21.36,33.06 21.1,32.81 U19.B2
  TOP w0.095: TC3.1 22.86,34.25 22.47,33.85 22.47,33.32 22.21,33.06
PD1_GPIO1: length 4.3
  TOP w0.076: 21.38,33.75 21.01,33.75 20.73,33.47 20.73,33.06 U19.C2
  TOP w0.095: 21.38,33.75 21.52,33.75 22.57,34.8 R5751.1 22.48,35.22 R173.1
PD1_GPIO2: length 2.6
  GND1 w0.095: v1(19.98,28.81) 19.98,28.34 v3(19.97,28.33)
  GND3 w0.095: v4(19.97,27.98) v3(19.97,28.33)
  BOTTOM w0.095: v4(19.97,27.98) 20.18,28.2 R5749.1 TC48.1
PD1_GPIO4: length 2.6
  TOP w0.076: 22.75,28.28 22.01,28.28 21.73,28.56 20.73,28.56 U19.C10
  TOP w0.095: R175.1 22.75,28.28
PD1_GPIO5: length 2.3
  TOP w0.076: U19.E10 19.22,28.55 19.22,28.12 19.36,27.98 19.36,27.85
  TOP w0.095: 19.36,27.85 19.36,27.59 18.9,27.12
  TOP w0.127: 18.9,27.12 18.89,27.11 TC5.1
PD1_GPIO6: length 3.9
  IN1 w0.076: v7(15.18,28.06) 15.59,28.47 17.21,28.47 17.85,29.1 18.18,29.1 v7(18.48,28.81)
PD1_GPIO7: length 4
  IN1 w0.076: v7(19.98,30.31) 20.15,30.48 20.56,30.48 20.99,30.06 20.99,29.8 v9(20.87,29.67)
  GND1 w0.095: v3(21.12,29.42) v9(20.87,29.67)
  GND3 w0.095: v4(21.63,29.88) 21.58,29.88 v3(21.12,29.42)
  BOTTOM w0.095: v2(22.44,30.8) 22.44,30.69 v4(21.63,29.88)
PD1_GPIO8: length 8.9
  IN1 w0.076: v7(17.98,30.81) 17.71,31.07 17.71,31.88 17.28,32.31 14.63,32.31 13.88,33.06 13.08,33.06 12.26,33.87 v7(12.26,35.35)
PD1_GPIO8_EXT: length 3.1
  TOP w0.095: v2(10.58,35.03) 10.95,35.03 R5752.2 11.53,35.2 R178.2 11.68,36.04 R5756.1
PD1_HOLD#: length 4
  BOTTOM w0.095: v2(4.98,31.56) R170.2 5.44,32.22 6.96,32.22 6.97,32.21 UT4.7
PD1_LPS1: length 2.7
  TOP w0.095: PR213.2 v1(33.49,15.53)
  GND1 w0.095: v3(33.44,14.94) 33.49,14.99 v1(33.49,15.53)
  GND3 w0.095: v4(33.64,15.31) 33.64,15.15 v3(33.44,14.94)
  BOTTOM w0.095: PQ133.2 33.77,15.44 v4(33.64,15.31)
PD2_EE_CLK: length 2.8
  TOP w0.095: R5783.2 36.03,34.86 R5778.2 35.76,34.6 35.76,34.57 35.64,34.45 34.12,34.45 U20.A3
PD2_EE_CS#: length 4.7
  TOP w0.095: v2(37.35,36.04) 37.25,36.14 R5782.2 35.99,35.69 v7(35.99,35.4)
  IN1 w0.076: v7(33.52,34.54) 34.44,35.46 35.93,35.46 35.98,35.4 v7(35.99,35.4)
PD2_EE_DI: length 3.5
  TOP w0.095: v7(35.96,33.22) 36.54,33.22 R5784.2
  IN1 w0.076: v7(35.96,33.22) 35.45,33.22 34.52,34.15 33.63,34.15 v7(33.52,34.04)
PD2_EE_DO: length 2.8
  TOP w0.095: R5785.2 35.96,33.81 R5780.2 35.96,33.87 35.63,34.2 34.19,34.2 U20.A4
PD2_GPIO0: length 2
  IN1 w0.076: v7(33.52,35.04) 33.73,35.24 33.73,36.65 v7(33.94,36.86)
PD2_GPIO1: length 6.8
  TOP w0.095: v7(33.13,34.68) 33.02,34.79 U20.C2 ; v2(35.97,39.34) 35.97,38.73 R201.1 35.65,38.46 35.13,37.94 R5761.1 v7(34.98,38.07)
  IN1 w0.076: v7(33.13,34.68) 33.13,35.14 33.47,35.48 33.47,36.9 34.63,38.07 v7(34.98,38.07)
PD2_GPIO2: length 5
  TOP w0.095: v7(31.84,28.71) 31.84,28.37 32.17,28.04 R5760.1 ; v7(32.32,31.3) 32.52,31.1 U20.D10
  IN1 w0.076: v7(32.32,31.3) 32.3,31.27 32.3,30.81 32.14,30.66 31.95,30.66 31.23,29.94 31.23,29.57 31.84,28.96 v7(31.84,28.71)
PD2_GPIO4: length 3.5
  TOP w0.095: R203.1 35.33,30.33 v2(35.26,30.33) 35.05,30.33 34.85,30.54 v7(34.45,30.54)
  IN1 w0.076: v7(33.02,31.04) 33.53,30.54 v7(34.45,30.54)
PD2_GPIO5: length 2.3
  IN1 w0.076: v7(30.71,29.33) 30.71,29.73 v7(32.02,31.04)
PD2_GPIO6: length 5.8
  TOP w0.095: TC47.1 29.01,28.11 29.01,28.72 29.2,28.91 v7(29.23,28.91)
  IN1 w0.076: v7(29.23,28.91) 29.23,28.91 29.48,28.66 29.97,28.66 30.22,28.9 30.22,30.06 30.75,30.59 30.75,30.77 v7(31.02,31.04)
PD2_GPIO7: length 7.3
  IN1 w0.076: v7(32.52,32.54) 32.61,32.54 32.91,32.84 33.09,32.84 33.37,32.56 33.51,32.56 33.83,32.23 33.83,31.67 v9(33.57,31.41)
  GND1 w0.095: v3(33.35,30.71) 33.57,30.93 v9(33.57,31.41)
  GND3 w0.095: v3(33.35,30.71) 33.49,30.85 v4(33.49,31.24)
  BOTTOM w0.095: v4(33.49,31.24) 33.89,30.84 33.99,30.84 34.01,30.87 R204.1 34.03,30.91 34.03,31.73 34.69,32.39 v2(34.69,33.17)
PD2_GPIO8: length 5.9
  TOP w0.095: R206.1 27.45,33.08 v2(27.84,33.08)
  IN1 w0.076: v7(30.52,33.04) 30.24,33.33 30.24,34.01 30.05,34.2 28.92,34.2 28.75,34.36 27.79,34.36 27.06,33.63 v7(27.06,33.46)
PD2_GPIO8_EXT: length 4.6
  TOP w0.095: v2(25.63,31.44) 24.77,32.3 R5744.1 24.77,33.6 R5762.2 25.27,33.12 26.1,33.12 R206.2
PD2_LPS1: length 3.9
  TOP w0.095: v2(46.67,18.85) 46.67,18.12 v1(46.52,17.96)
  TOP w0.254: v1(46.52,17.96) 45.95,17.96 PR221.1 45.05,18.22 PR220.2
  GND1 w0.254: v3(46.9,17.99) 46.88,17.96 v1(46.52,17.96)
  GND3 w0.254: v4(47.46,17.82) 47.3,17.99 v3(46.9,17.99)
PD2_LPS2: length 3
  BOTTOM w0.095: v2(49.28,13.35) 47.65,14.98 46.99,14.98
PD3_EE_CLK: length 13.9
  IN1 w0.076: v9(285.88,14.41) 285.88,14.52 285.64,14.76 285.64,15.52 285.98,15.86 286.46,15.86 288.16,17.56 288.16,19.11 285.09,22.18 v7(282.58,22.18)
  GND1 w0.095: v3(285.71,13.94) 285.69,13.95 285.69,14.09 285.88,14.27 v9(285.88,14.41)
  GND3 w0.095: v3(285.71,13.94) 285.82,13.82 v4(286.02,13.82)
PD3_EE_CS#: length 10
  TOP w0.095: v7(289.72,17.49) 289.96,17.49 290.09,17.62 290.09,18.86 290.23,19.01 290.23,19.53 290.13,19.63 UT6.1
  IN1 w0.076: v9(286.02,15.46) 286.28,15.21 286.84,15.21 289.12,17.49 v7(289.72,17.49)
  GND1 w0.095: v3(286.1,15.03) 286.02,15.11 v9(286.02,15.46)
  GND3 w0.095: v3(286.1,15.03) 286.02,14.95 v4(286.02,14.32)
PD3_EE_DI: length 13.3
  IN1 w0.076: v7(282.65,23.44) 284.12,23.44 288.38,19.18 288.38,17.21 286.71,15.55 v9(286.56,15.55)
  GND1 w0.095: v9(286.56,15.55) 286.56,15.11 v3(286.65,15.02)
  GND3 w0.095: v3(286.65,15.02) 286.65,14.82 v4(286.52,14.69)
  BOTTOM w0.095: U21.B4 v4(286.52,14.69)
PD3_EE_DO: length 11
  TOP w0.095: UT6.2 290.13,20.9 290.3,20.73 290.3,19.79 290.53,19.56 v2(290.53,18.76) 290.53,18.7 290.41,18.59 290.41,17.46 289.82,16.86 v7(289.74,16.86)
  IN1 w0.076: v9(286.83,14.58) 286.83,14.82 288.87,16.86 v7(289.74,16.86)
  GND1 w0.095: v9(286.83,14.58) 286.78,14.58 286.68,14.49 v3(286.68,14.25)
  GND3 w0.095: v4(286.52,13.82) 286.53,13.83 286.53,14.16 286.62,14.25 v3(286.68,14.25)
PD3_EE_WP#: length 8.3
  TOP w0.095: UT6.3 290.21,22.17 290.27,22.1 290.27,21.07 290.52,20.83 290.52,20.54 290.72,20.34 v2(290.72,20.11) 290.9,19.93 290.9,18.66 290.73,18.5 290.73,17.22 289.76,16.26 R225.2
