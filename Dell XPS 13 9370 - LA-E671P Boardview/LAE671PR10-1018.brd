# Allegro board LAE671PR10-1018.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VBUS2_20V on BOTTOM (solid shape): 43.37,20.73 43.37,20.02 44.03,19.35 44.03,18.06 43.88,17.9 42.06,17.9 41.92,18.04 40.31,18.04 40.08,18.28 40.08,20.54 40.19,20.65 41.93,20.65 42.14,20.86 43.24,20.86
+VBUS2_PD_20V on TOP (solid shape): 13.05,61.87 13.05,60.85 12.73,60.52 11.09,60.52 11.04,60.57 11.04,61.63 11.38,61.97 12.95,61.97
+VBUS2_PD_20V on TOP (solid shape): 6.97,62.01 7.86,62.01 7.94,61.93 7.94,61.78 7.84,61.68 6.88,61.68 6.65,61.91 5.43,61.91 5.3,62.03 5.3,62.19 5.38,62.26 6.72,62.26
+VBUS2_PD_20V on TOP (solid shape): 7.02,64.45 7.9,64.45 7.97,64.38 7.97,64.23 7.89,64.16 6.79,64.16 6.69,64.06 6.47,64.06 6.14,64.39 5.49,64.39 5.4,64.47 5.4,64.64 5.47,64.71 6.76,64.71
+VBUS2_PD_20V on TOP (solid shape): 26.65,27.71 26.65,27.07 26.99,26.73 28.51,26.73 28.81,26.43 28.81,25.4 28.8,25.39 28.8,25.14 28.81,25.14 28.81,24.9 28.61,24.7 27.19,24.7 26.76,24.27 25.96,24.27 25.86,24.37 25.86,26.54 25.88,26.55 25.49,26.94 25.49,27.82 25.62,27.94 26.42,27.94
+VBUS2_PD_20V on TOP (solid shape): 45.64,21.9 46.17,21.9 46.27,21.8 46.27,20.36 46.46,20.17 46.46,19.78 46.45,19.78 46.45,19.54 46.3,19.39 45.36,19.39 43.78,20.97 43.78,21.18 43.79,21.18 43.79,21.36 43.94,21.52 44.53,21.52 44.67,21.66 44.67,21.67 44.67,21.88 44.9,22.12 45.42,22.12
+VBUS2_PD_20V on BOTTOM (solid shape): 27.78,27.75 27.78,27.45 28.05,27.18 30,27.18 30.13,27.06 30.13,25.52 29.96,25.36 25.34,25.36 24.87,25.82 24.87,27.91 25.07,28.11 27.42,28.11
+VBUS2_PD_20V on BOTTOM (solid shape): 46.22,21.84 46.22,20.43 46.38,20.27 46.38,19.91 45.99,19.52 44.21,19.52 43.57,20.15 43.57,21.26 43.83,21.52 44.63,21.52 44.69,21.58 44.69,21.9 44.79,22.01 44.81,22.01 44.88,22.08 45.98,22.08
+VBUS2_PD_20V on BOTTOM (solid shape): 6.3,64.66 6.54,64.6 6.79,64.66 8.41,64.66 8.5,64.56 8.5,64.18 8.31,63.99 6.56,63.99 6.51,63.94 6.49,63.94 6.19,63.71 6.26,63.34 6.28,63.32 6.28,63.22 6.26,63.21 6.19,62.85 6.47,62.62 6.49,62.61 6.57,62.54 6.69,62.54 6.91,62.32 6.91,62.26 6.97,62.26 7.05,62.19 8.48,62.19 8.76,61.9 8.76,61.66 8.75,61.63 8.72,61.61 8.63,61.59 8.56,61.54 8.51,61.5 7.72,61.5 7.39,61.68 7.02,61.74 6.97,61.74 6.91,61.8 6.53,61.96 6.14,61.82 5.29,61.82 5.07,62.03 5.07,64.31 5.42,64.66
+VBUS2_PD_20V on GND1 (solid shape): 7.88,64.36 7.88,64.25 7.82,64.19 5.88,64.19 5.71,64.02 5.71,62.82 6.25,62.29 6.87,62.29 7.07,62.09 7.7,62.09 7.87,61.92 7.87,61.72 7.78,61.64 7.08,61.64 6.81,61.91 6.28,61.91 6.28,61.91 5.78,61.91 4.67,63.03 4.67,64.32 5.02,64.67 7.57,64.67
+VBUS2_PD_20V on GND3 (solid shape): 5.84,64.07 5.84,63.06 5.9,63 5.93,63 6.21,62.71 6.21,62.52 6.18,62.49 6.18,62.19 6.06,62.07 5.28,62.07 5.17,62.18 5.17,62.55 4.65,63.07 4.65,64.09 4.84,64.29 5.63,64.29
+VBUS2_PD_20V on GND1: 34.14,15.13 33.78,15.49 33.78,16.05 33.39,16.44 32.38,16.44 29.6,19.22 29.19,19.22 26,22.41 26,27.74 26.23,27.97 27.24,27.97 27.74,27.48 28.31,27.48 30.01,25.78 32.1,25.78 34.3,23.58 34.86,23.58 35.13,23.31 36.96,23.31 37.85,24.2 41.87,24.2 43.75,22.32 45.17,22.32 46.39,21.1 46.39,18.46 46.04,18.11 46.04,15.86 45.65,15.48 35.19,15.48 34.85,15.13
+VBUS2_PD_20V on VCC: 16.88,24.04 9.79,31.13 9.79,51.52 3.24,58.07 3.24,64.09 4.18,65.03 16,65.03 16.08,65.02 16.5,64.6 16.5,51.65 16.98,51.16 16.98,49.47 16.5,48.98 16.5,42.2 16.09,41.79 13.57,41.79 13.04,41.26 13.04,36.76 13.52,36.28 20.55,36.28 21.07,35.76 21.07,34.37 24.88,30.56 26.12,30.56 28.59,28.1 28.59,28.1 28.66,28.03 28.77,27.91 28.77,27.91 28.97,27.72 28.97,24.58 28.43,24.04
+VBUS3_20V on BOTTOM (solid shape): 194.22,9.09 194.22,8.99 194.32,8.99 194.37,8.94 198.34,8.94 198.95,8.33 198.95,7.67 198.57,7.29 198.57,5.73 199.06,5.24 199.06,3.72 199.07,3.71 199.07,3.18 199.36,2.89 199.36,1.99 199.32,1.95 199.24,1.92 199.18,1.87 198.56,1.87 198.48,1.95 198.48,3 198.03,3.46 198.03,5.17 197.57,5.63 196.99,5.63 196.79,5.82 194.17,5.82 193.82,6.17 192.82,6.17 192.73,6.26 192.73,8.38 192.74,8.39 192.74,8.67 192.74,8.68 192.74,9.43 192.86,9.54 193.76,9.54
+VBUS3_20V on IN4 (solid shape): 199.05,2.24 199.05,1.76 198.97,1.68 197.39,1.68 197.32,1.76 197.32,2.14 197.59,2.41 198.88,2.41
+VBUS3_PD_20V on TOP (solid shape): 295.97,16.15 295.97,10.71 295.95,10.69 295.95,9.51 295.72,9.27 295.15,9.27 294.01,10.41 292.72,10.41 292.37,10.76 292.37,11.38 292.95,11.96 293.72,11.96 294.17,12.41 294.17,16.12 294.48,16.43 295.7,16.43
+VBUS3_PD_20V on TOP (solid shape): 290.83,49.28 290.83,48.91 290.8,48.85 290.74,48.79 289.76,48.79 289.7,48.85 289.39,48.85 289.3,48.89 289.2,48.91 288.68,48.91 288.62,48.97 288.62,49.12 288.75,49.24 290.1,49.24 290.27,49.42 290.69,49.42
+VBUS3_PD_20V on TOP (solid shape): 290.83,51.7 290.84,51.67 290.84,51.33 290.82,51.3 290.8,51.25 290.74,51.19 290.08,51.19 289.93,51.34 288.71,51.34 288.63,51.42 288.63,51.68 288.65,51.7 289.2,51.7 289.31,51.71 289.4,51.76 289.74,51.76 289.85,51.87 290.65,51.87
+VBUS3_PD_20V on BOTTOM (solid shape): 200.71,6.92 200.71,6.17 201.06,5.82 202.62,5.82 202.76,5.68 202.76,4.71 203.91,3.56 203.91,1.67 203.75,1.51 201.41,1.51 201.3,1.61 201.3,4.13 201.22,4.21 199.73,4.21 199.64,4.3 199.64,5.56 199.19,6.01 199.19,7.08 199.35,7.25 200.38,7.25
+VBUS3_PD_20V on BOTTOM (solid shape): outline of 100 points within 286.41,47.94 290.67,51.8
+VBUS3_PD_20V on GND1 (solid shape): 290.81,49.26 290.81,48.96 289.68,47.83 288.82,47.83 288.72,47.94 288.72,48.99 289.14,49.41 290.66,49.41
+VBUS3_PD_20V on GND1 (solid shape): 290.78,51.89 290.79,51.79 290.83,51.7 290.83,51.33 290.62,51.12 290.47,51.13 290.32,51.09 289.52,51.09 288.56,50.13 288.1,50.13 288.03,50.2 288.03,50.82 288.03,50.83 288.03,51.01 289.1,52.08 290.59,52.08
+VBUS3_PD_20V on IN3 (solid shape): outline of 138 points within 264.9,1.84 295.99,13.38
+VBUS3_PD_20V on GND3 (solid shape): 266.34,2.69 266.34,2.38 266.26,2.31 266.26,1.86 266.09,1.69 264.89,1.69 264.77,1.81 264.77,2.6 264.92,2.75 266.28,2.75
+VBUS3_PD_20V on IN4 (solid shape): outline of 312 points within 286.59,47.97 290.7,51.82
+VBUS3_PD_20V on IN4 (solid shape): outline of 1098 points within 202.7,1.27 295.99,13.42
+VBUS3_PD_20V on VCC: 293.6,8.41 293.21,8.81 293.21,13.62 291.36,15.48 288.77,15.48 288.28,15.97 288.28,27.84 289.68,29.24 289.68,36.76 282.39,44.08 282.39,50.93 282.82,51.37 285.99,51.37 286.32,51.03 288.35,51.03 289.12,50.27 289.12,45.9 295.62,39.4 295.99,39.4 295.99,8.86 295.55,8.41
+VBUS3_PD_20V on GND3: 286.66,49.25 286.53,49.38 286.53,50.84 286.67,50.97 287.4,50.97 287.5,50.88 287.5,50.88 287.55,50.83 287.55,50.55 287.36,50.36 287.36,49.73 287.2,49.57 287.07,49.5 287,49.37 287,49.35 286.89,49.25
+VCC0V9_CIO on TOP (solid shape): 25.16,49.99 25.16,49.11 24.96,48.9 24.15,48.9 24.04,49 24.04,49.33 24.1,49.39 24.57,49.39 24.72,49.54 24.72,49.99 24.78,50.04 25.11,50.04
+VCC0V9_CIO on BOTTOM (solid shape): 24.89,49.6 24.89,47.59 24.89,47.58 24.89,47.47 24.84,47.42 24.24,47.42 24.14,47.52 24.14,49.59 24.25,49.7 24.79,49.7
+VCC0V9_CIO on GND1 (solid shape): 25.12,49.89 25.12,49.18 24.94,49.01 24.79,49.01 24.78,49.02 24.76,49.02 24.46,48.72 24.46,48.72 24.41,48.67 24.41,48.24 24.51,48.15 24.89,48.15 24.99,48.04 24.99,47.76 24.95,47.71 24.11,47.71 24.03,47.79 24.03,49.23 24.12,49.32 24.42,49.32 24.55,49.45 24.55,49.78 24.73,49.95 25.06,49.95
+VCC0V9_CIO on GND3 (solid shape): 24.62,49.56 24.62,48.04 24.29,47.71 24.22,47.71 24.05,47.88 24.05,48.01 24.14,48.11 24.14,48.3 24.01,48.44 24.01,48.6 24.14,48.74 24.14,48.97 24.03,49.08 24.03,49.28 24.38,49.63 24.56,49.63
+VCC0V9_DP on TOP (solid shape): 23.25,50.58 23.25,49.51 23.33,49.43 23.33,49.02 23.25,48.94 22.77,48.94 22.65,49.06 22.65,50.58 22.79,50.72 23.1,50.72
+VCC0V9_DP on TOP (solid shape): 26.31,48.67 26.31,46.87 26.32,46.86 26.32,46.46 26.27,46.41 25.33,46.41 25.22,46.52 25.22,47.15 25.42,47.35 25.42,47.35 25.67,47.6 25.67,47.95 25.66,47.96 25.66,48.55 25.84,48.73 26.25,48.73
+VCC0V9_DP on GND1 (solid shape): 25.91,48.46 25.92,48.41 25.94,48.36 25.94,47.98 25.9,47.93 25.85,47.88 25.85,47.61 26.02,47.44 26.14,47.44 26.26,47.33 26.26,47.13 26.14,47.01 25.88,47.01 25.74,46.87 25.74,46.55 25.65,46.46 25.39,46.46 25.24,46.61 25.24,48.52 25.42,48.7 25.67,48.7
+VCC0V9_DP on GND3 (solid shape): 23.29,50.19 23.29,49.45 22.92,49.08 22.79,49.08 22.41,49.46 22.41,50.22 22.47,50.28 23.2,50.28
+VCC0V9_DP on GND3 (solid shape): 25.81,48.45 25.81,48.3 25.87,48.24 25.87,48.06 25.77,47.96 25.77,47.61 25.87,47.51 25.87,46.83 25.81,46.77 25.66,46.77 25.03,47.41 25.03,48.34 25.36,48.67 25.59,48.67
+VCC0V9_DP on IN4 (solid shape): outline of 724 points within 22.16,46.42 25.91,50.35
+VCC0V9_PCIE on TOP (solid shape): 23.08,46.75 23.08,45.07 23.28,44.86 23.57,44.86 23.74,44.69 23.74,44.49 23.62,44.37 23.3,44.37 23.29,44.37 23.26,44.37 23.15,44.26 23.15,42.61 23.08,42.53 22.4,42.53 22.11,42.83 22.11,44.18 22.24,44.3 22.47,44.3 22.57,44.41 22.57,46.21 22.5,46.29 22.5,46.77 22.55,46.82 23.01,46.82
+VCC0V9_PCIE on BOTTOM (solid shape): 23.45,46.98 23.45,45.78 23.13,45.46 23.13,45.21 23.13,45.21 23.13,45.15 23.34,44.94 23.67,44.94 23.75,45.02 23.88,45.02 23.95,44.95 23.95,44.29 23.88,44.23 23.82,44.23 23.48,44.57 23.07,44.57 22.72,44.21 22.5,44.21 22.4,44.31 22.4,45.1 22.81,45.5 22.81,45.74 22.65,45.89 22.65,45.97 22.93,46.26 22.93,47.04 22.97,47.07 23.36,47.07
+VCC0V9_USB on TOP (solid shape): 24.88,46.16 24.88,44.8 24.9,44.78 24.9,44.63 25.1,44.44 25.1,43.55 25.07,43.52 24.68,43.52 24.58,43.62 24.58,44.31 24.3,44.6 24.3,45.04 23.92,45.42 23.92,45.99 24.15,46.22 24.82,46.22
+VCC_CORE on TOP (solid shape): outline of 836 points within 72.08,49.24 121.18,70.66
+VCC_CORE on BOTTOM (solid shape): outline of 239 points within 69.57,53.03 93.57,67.39
+VCC_CORE on BOTTOM (solid shape): outline of 643 points within 114.39,49.3 119.43,52.35
+VCC_CORE on BOTTOM (solid shape): outline of 685 points within 112.84,59.82 120.4,62.68
+VCC_CORE on IN1 (solid shape): outline of 2587 points within 71.24,50.81 120.33,66.48
+VCC_CORE on IN2 (solid shape): outline of 3319 points within 71.92,49.3 119.71,63.84
+VCC_CORE on GND2: 108.2,50.74 107.17,51.77 104.32,51.77 102.19,53.91 98.47,53.91 98.04,53.47 97.06,53.47 95.7,54.83 90.71,54.83 88.76,52.88 72.46,52.88 70.89,54.44 70.89,66.82 71.37,67.29 75.87,67.29 76.83,66.33 91.36,66.33 93.17,64.52 96.42,64.52 98.52,66.62 103.99,66.62 105.67,68.29 107.28,68.29 108.73,69.74 110.32,69.74 111.32,68.75 111.32,68.08 114.33,65.07 114.33,64.63 117.16,61.81 119.06,61.81 119.52,62.27 119.52,62.47 119.78,62.73 120.03,62.73 120.08,62.68 120.08,62.05 119.94,61.91 119.94,51.55 119.54,51.15 116.43,51.15 116.03,50.74
+VCC_CORE on VCC: 82.92,45.48 82.92,45.27 82.92,41.9 82.19,41.17 81.03,41.17 81.03,41.17 80.72,41.17 79.72,41.17 79.66,41.19 79.62,41.17 71.91,41.17 70.93,42.15 70.9,66.81 71.24,67.1 71.28,67.12 71.31,67.17 71.36,67.21 71.36,67.26 71.38,67.3 71.38,67.32 77.97,67.32 78.35,66.95 79.49,66.95 79.49,66.84 79.64,66.69 84.4,66.69 86.33,68.61 93.32,68.61 93.6,68.34 94.93,68.34 95.21,68.61 97.53,68.61 107.92,68.64 108.65,69.37 110.54,69.37 111.69,68.22 111.79,68.22 111.79,67.64 112.2,67.23 112.2,67.09 116.44,62.85 116.47,62.85 116.5,62.82 119.87,62.82 120.08,62.61 120.08,62.06 119.93,61.91 119.93,51.59 119.55,51.21 116.22,51.21 116.16,51.27 116.16,51.71 113.98,53.89 112.55,53.89 111.99,53.33 111.99,51.37 111.37,50.76 104.39,50.76 103.04,52.1 103.04,52.65 101.76,53.93 96.85,53.93 96.4,54.38 92.54,54.38 91.08,52.92 90.36,52.92 ; 1 cut-out
+VCC_EDRAM on TOP (solid shape): 103.89,58.86 103.89,57.28 104.08,57.09 104.3,57.09 104.45,56.94 104.45,55.95 104.32,55.82 103.93,55.82 103.93,55.81 103.76,55.81 103.66,55.71 103.66,55.3 103.51,55.15 102.29,55.15 102.05,55.39 102.05,55.6 102.16,55.71 102.16,56.44 102.51,56.44 102.51,56.39 102.52,56.34 102.54,56.29 102.56,56.24 102.59,56.2 102.63,56.16 102.67,56.12 102.72,56.1 102.76,56.08 102.82,56.07 102.87,56.06 102.92,56.07 102.97,56.08 103.02,56.1 103.07,56.12 103.11,56.16 103.15,56.2 103.18,56.24 103.2,56.29 103.22,56.34 103.23,56.39 103.23,56.44 103.22,56.5 103.2,56.55 103.18,56.6 103.15,56.64 103.11,56.68 103.07,56.71 103.02,56.74 102.97,56.76 102.92,56.77 102.87,56.77 102.82,56.77 102.76,56.76 102.72,56.74 102.67,56.71 102.63,56.68 102.59,56.64 102.56,56.6 102.54,56.55 102.52,56.5 102.51,56.44 102.16,56.44 102.16,56.45 102.11,56.5 102.11,58.13 102.23,58.25 103.21,58.25 103.38,58.42 103.38,58.83 103.45,58.9 103.85,58.9
+VCC_EDRAM on BOTTOM (solid shape): 65.52,38.19 65.52,36.13 65.46,36.06 64.02,36.06 63.44,36.64 63.44,38.17 63.55,38.28 63.67,38.28 63.67,38.28 65.43,38.28
+VCC_EDRAM on BOTTOM (solid shape): 103.52,58.67 103.52,54.85 103.39,54.72 102.57,54.72 102.45,54.84 102.45,55.08 102.51,55.14 102.51,55.46 103.28,56.22 103.28,56.54 103.09,56.73 103.04,56.73 103.03,56.74 102.87,56.77 102.71,56.74 102.7,56.73 102.52,56.73 102.45,56.8 102.45,56.92 102.9,57.37 102.9,58 102.89,58 102.89,58.08 102.45,58.52 102.45,58.76 102.52,58.83 103.37,58.83
+VCC_EDRAM on IN3 (solid shape): outline of 768 points within 63.38,33.12 83.1,43.48
+VCC_EDRAM on IN3 (solid shape): outline of 1507 points within 81.86,47.63 103.74,58.54
+VCC_EDRAM_P on TOP (solid shape): 63.31,38.01 63.31,35.85 62.89,35.43 61.44,35.43 61.34,35.54 61.34,38.53 61.46,38.65 62.66,38.65
+VCC_EDRAM_P on BOTTOM (solid shape): 63.31,38.13 63.31,36.49 63.9,35.9 65.04,35.9 65.09,35.84 65.09,34.4 64.89,34.2 60.78,34.2 60.71,34.27 60.71,34.48 61.32,35.1 61.32,37.27 62.28,38.23 62.31,38.26 63.18,38.26
+VCC_EOPIO on TOP (solid shape): outline of 126 points within 102.01,51.9 104.6,55.63
+VCC_EOPIO on BOTTOM (solid shape): 77.12,38.37 77.12,37.2 76.84,36.92 74.73,36.92 74.25,37.4 74.25,38.2 74.67,38.63 76.86,38.63
+VCC_EOPIO on BOTTOM (solid shape): 102.82,53.31 102.82,53.3 103.04,53.09 103.33,53.13 103.34,53.14 103.46,53.14 103.53,53.06 103.53,52.35 103.84,52.35 103.93,52.26 103.93,52.08 103.67,51.82 102.57,51.82 102.44,51.94 102.44,53.28 102.54,53.38 102.74,53.38
+VCC_EOPIO on IN4 (solid shape): 82.33,38.89 82.33,36.91 81.3,35.88 76.89,35.88 75.86,36.91 75.86,38.75 76.22,39.12 82.09,39.12
+VCC_EOPIO on IN4 (solid shape): outline of 1027 points within 82.39,51.35 104.25,57.74
+VCC_EOPIO_P on BOTTOM (solid shape): 72.8,36.79 75.69,36.79 75.83,36.65 75.83,34.24 75.57,33.98 71.49,33.98 71.42,34.06 71.42,34.21 71.71,34.5 71.71,37.02 71.76,37.07 72.51,37.07
+VCCGT on TOP (solid shape): 85.65,31.73 77.65,31.73 77.65,44.73 85.65,44.73
+VCCGT on TOP (solid shape): outline of 3233 points within 75.34,33.47 109.42,61.95
+VCCGT on BOTTOM (solid shape): outline of 534 points within 103.6,49.37 108.16,52.35
+VCCGT on BOTTOM (solid shape): outline of 1117 points within 75.46,38.97 107.57,62.12
+VCCGT on IN1 (solid shape): outline of 2248 points within 74.73,44.29 109.19,61.9
+VCCGT on IN4 (solid shape): outline of 1902 points within 82.76,51 110.34,67.73
+VCCGT on GND3: 76.1,44.6 75.74,44.95 75.74,47.45 76.68,48.39 76.68,56.3 78.72,58.34 82.3,58.34 82.62,58.66 93.3,58.66 94.77,60.13 99,60.13 99.36,60.48 103.61,60.48 104.8,59.29 107.78,59.29 108.98,58.09 108.98,51.99 108.51,51.52 108.51,49.54 108.2,49.23 104.3,49.23 103.94,49.59 103.94,50.78 103.41,51.32 103.41,52.92 102.51,53.82 98.6,53.82 98.49,53.7 97.5,53.7 97.12,54.09 92.61,54.09 92.09,53.57 92.09,53.29 90.78,51.98 89.97,51.98 88.89,50.9 86.37,50.9 85.87,50.39 85.87,48.38 82.08,44.6
+VCCIA_GT on TOP (solid shape): outline of 102 points within 107.09,49.98 113.07,67.03
+VCCIA_GT on BOTTOM (solid shape): outline of 306 points within 108.83,59.82 112.68,61.9
+VCCIA_GT on BOTTOM (solid shape): outline of 547 points within 108.26,49.47 114.25,52.35
+VCCPLL_OC on IN1 (solid shape): outline of 472 points within 123.56,42.53 126.35,52.25
+VCCSA on TOP (solid shape): 59.39,58.33 59.39,53.4 56.47,53.4 56.18,53.68 56.18,54.82 56.38,55.02 57.81,55.02 58.25,55.45 58.25,56.13 57.72,56.65 56.8,56.65 56.8,58.34 56.96,58.5 59.22,58.5
+VCCSA on TOP (solid shape): 113.95,73.18 113.95,72.29 113.89,72.1 113.95,71.92 113.95,71.31 113.7,71.06 110.31,71.06 109.94,71.43 109.94,73.06 110.23,73.35 113.77,73.35
+VCCSA on TOP (solid shape): 122.94,55.13 122.94,54.71 123.1,54.55 123.3,54.55 123.36,54.54 123.43,54.55 123.78,54.55 124.26,54.06 124.26,53.19 124.5,52.95 124.5,52.47 124.39,52.36 123.88,52.36 123.64,52.13 123.64,51.93 123.38,51.67 122.92,51.67 122.82,51.76 122.82,52.07 122.92,52.17 122.95,52.17 123.01,52.23 123.46,52.23 123.5,52.27 123.5,53.01 123.15,53.36 123.15,53.9 123.02,54.03 122.63,54.03 122.59,54.07 122.59,54.1 122.49,54.19 122.49,55.1 122.55,55.16 122.56,55.16 122.6,55.2 122.87,55.2
+VCCSA on TOP (solid shape): outline of 84 points within 120.1,56.61 125.82,64.1
+VCCSA on BOTTOM (solid shape): 60.32,58.21 60.32,58.19 60.34,58.08 60.39,57.97 60.41,57.87 60.46,57.79 60.47,57.77 60.47,57.65 60.43,57.58 60.41,57.52 60.4,57.45 60.4,57.3 60.46,57.15 60.47,57.14 60.47,57.11 60.52,57.05 60.9,57.05 60.95,57 60.95,54.57 60.64,54.26 60.34,54.26 59.55,53.47 56.83,53.47 56.43,53.88 56.43,55.03 56.68,55.28 58.76,55.28 58.95,55.46 58.95,56.07 58.85,56.17 56.69,56.17 56.43,56.43 56.43,58 56.9,58.47 57.65,58.4 58.39,58.48 58.39,58.48 60.06,58.48
+VCCSA on BOTTOM (solid shape): 123.77,52.17 123.77,52.16 123.72,52.03 123.73,51.89 123.74,51.85 123.74,51.81 123.72,51.71 123.63,51.68 123.4,51.1 123.85,51.53 123.85,51.59 123.91,51.6 123.94,51.59 123.96,51.57 123.97,51.57 124.11,51.43 124.11,50.83 124,50.72 122.63,50.72 122.39,50.97 122.39,51.48 122.61,51.65 122.6,51.94 122.6,52.03 122.92,52.35 123.77,52.35
+VCCSA on BOTTOM (solid shape): outline of 566 points within 120.11,59.82 124.69,62.86
+VCCSA on IN1 (solid shape): outline of 518 points within 121.06,51.52 124.06,62.79
+VCCSA on VCC: 120.96,51.59 120.48,52.07 120.48,52.08 120.44,52.12 120.44,61.7 120.59,61.85 120.59,62.82 120.08,63.33 116.68,63.33 112.56,67.45 112.42,67.45 112.1,67.77 112.1,68.39 112.05,68.44 112.05,68.58 111.9,68.73 111.9,68.73 110.75,69.88 108.44,69.88 107.71,69.15 97.52,69.12 94.99,69.12 94.72,68.84 93.81,68.84 93.53,69.12 86.11,69.12 84.19,67.2 79.85,67.2 79.85,67.2 79.67,67.2 79.67,67.2 78.45,67.2 78.07,67.58 71.2,67.58 71.18,67.58 71.14,67.6 71.08,67.59 71.02,67.59 71.01,67.58 70.77,67.58 70.75,67.6 70.54,67.6 70.52,67.58 62.19,67.58 62.06,67.71 61.69,67.71 58.46,64.48 58.46,54.29 57.85,53.68 52.22,53.68 49.93,55.97 49.93,74.32 50.33,74.73 124.36,74.73 124.68,74.41 124.68,52.02 124.25,51.59 ; 1 cut-out
+VSS_PLL on TOP (solid shape): 28.25,15.26 28.25,14.53 27.95,14.23 27.36,14.23 27.12,13.99 25.9,13.99 25.41,14.47 24.6,14.47 24.54,14.54 24.54,15.01 24.61,15.08 25.77,15.08 26.27,14.59 27.12,14.59 27.17,14.64 27.17,15.2 27.31,15.34 28.17,15.34
AGND on TOP (solid shape): outline of 89 points within 277.52,57.11 291.22,67.52
AGND on BOTTOM (solid shape): 278.95,59.21 278.95,58.58 279.09,58.44 279.64,58.44 279.67,58.47 279.88,58.47 279.92,58.43 279.92,58.32 279.83,58.23 278.93,58.23 278.75,58.41 278.75,59.21 278.8,59.26 278.9,59.26
AGND on BOTTOM (solid shape): 288.67,58.44 288.67,57.26 288.63,57.22 287.32,57.22 287.13,57.41 287.13,57.98 287.17,58.02 287.69,58.02 287.83,58.16 287.83,58.54 287.9,58.61 288.5,58.61
AGND on IN1 (solid shape): outline of 346 points within 277.15,55.86 294.38,69.55
AGND on IN2 (solid shape): outline of 708 points within 277.15,55.86 294.38,69.55
AGND on IN3 (solid shape): outline of 509 points within 277.15,55.86 294.38,69.55
AGND on IN4 (solid shape): outline of 650 points within 277.15,55.86 294.37,69.56
AGND on GND1, GND2: 279.38,55.86 277.71,57.53 277.71,59.12 277.87,59.28 278.94,59.28 279.26,59.6 279.26,64.16 278.92,64.5 277.41,64.5 277.15,64.76 277.15,67.11 277.56,67.52 285.3,67.52 286.28,66.54 287.75,66.54 288.21,67 290.05,67 290.46,67.41 290.46,69.55 293.38,69.55 294.38,68.56 294.38,63.52 291.7,63.52 291.23,63.04 291.23,62.19 290.41,61.37 290.16,61.37 289.68,60.89 289.68,60.28 289.62,60.23 287.95,60.23 287.75,60.03 287.75,59.2 288.25,58.69 288.92,58.69 288.95,58.66 288.95,57.53 288.62,57.19 284.77,57.19 283.44,55.86
AGND on VCC: 279.39,55.84 277.71,57.52 277.71,57.72 277.59,57.85 277.59,59.31 277.65,59.38 277.76,59.27 278.96,59.27 279.26,59.57 279.26,64.15 278.91,64.5 277.41,64.5 277.15,64.76 277.15,65.87 277.14,65.88 277.18,65.92 277.18,67.16 277.55,67.53 285.29,67.53 286.18,66.64 286.39,66.64 286.4,66.65 287.26,66.65 287.36,66.54 287.75,66.54 288.19,66.99 290.04,66.99 290.04,66.99 290.46,67.41 290.46,69.55 293.38,69.55 294.38,68.56 294.38,63.52 291.7,63.52 291.23,63.04 291.23,62.19 290.41,61.37 290.16,61.36 289.69,60.89 289.69,60.22 287.97,60.22 287.93,60.21 287.75,60.03 287.75,59.2 288.24,58.71 288.93,58.71 288.93,57.47 288.63,57.17 287.5,57.17 287.29,57.17 284.78,57.16 284.77,57.16 284.75,57.16 283.42,55.84
AGND on GND3: 279.38,55.86 277.71,57.53 277.71,59.12 277.87,59.28 278.94,59.28 279.26,59.6 279.26,64.16 278.92,64.5 277.41,64.5 277.15,64.76 277.15,67.11 277.56,67.52 285.3,67.52 286.28,66.54 287.75,66.54 288.21,67 290.05,67 290.46,67.41 290.46,69.55 293.38,69.55 294.38,68.56 294.38,63.52 291.7,63.52 291.23,63.04 291.23,62.19 290.41,61.37 290.16,61.37 289.68,60.89 289.68,60.28 289.62,60.23 287.95,60.23 287.75,60.03 287.75,59.2 288.25,58.69 288.92,58.69 288.95,58.66 288.95,57.53 288.62,57.19 284.77,57.19 283.44,55.86
DV12S on BOTTOM (solid shape): 286.88,32.9 286.88,32.8 286.83,32.75 285.99,32.75 285.8,32.55 285.8,32.01 285.15,31.37 284.52,31.37 284.47,31.42 284.47,32.34 284.6,32.48 285.27,32.48 285.74,32.95 286.83,32.95
DV12S on BOTTOM (solid shape): 285.06,35.55 285.06,35.05 285.26,34.85 285.43,34.54 285.78,34.53 286.81,34.53 286.86,34.47 286.86,34.42 286.78,34.35 286.05,34.35 286,34.3 285.31,34.3 285.31,34.3 284.63,34.3 284.42,34.52 284.42,35.57 284.49,35.65 284.96,35.65
DV12S on IN4 (solid shape): 285.23,32.32 285.23,31.57 285.09,31.43 284.55,31.43 284.46,31.53 284.46,32.24 284.45,32.25 284.45,32.7 284.54,32.79 284.76,32.79
GND on TOP (solid shape): 65.55,66.57 57.55,66.57 57.55,74.57 65.55,74.57
GND on TOP (solid shape): 296,49.18 295.5,49.18 295.5,51.42 296,51.42
GND on TOP (solid shape): 20.23,23.96 20.23,23.2 20.11,23.07 18.2,23.07 18.07,23.2 18.07,24.09 18.2,24.21 19.98,24.21
GND on TOP (solid shape): 42.42,18.16 42.42,17.21 42.19,16.98 40.68,16.98 40.5,17.16 40.5,17.75 41.03,18.27 42.3,18.27
GND on TOP (solid shape): 68.73,8.55 68.73,7.37 68.59,7.23 68.18,7.23 68.02,7.38 68.02,8.55 68.16,8.69 68.59,8.69
GND on TOP (solid shape): 90.92,52.16 90.92,51.55 90.91,51.53 86.42,51.53 86.4,51.54 86.4,52.18 86.41,52.19 90.89,52.19
GND on TOP (solid shape): 106.69,60.64 106.69,60.38 106.62,60.31 103.49,60.31 103.44,60.36 103.44,60.66 103.48,60.7 106.63,60.7
GND on TOP (solid shape): 145.15,36.53 145.15,35.83 145.07,35.75 144.03,35.75 143.9,35.88 143.9,36.56 143.98,36.64 145.05,36.64
GND on TOP (solid shape): 147.08,50.48 147.08,49.04 146.85,48.82 146.56,48.82 146.35,49.03 146.35,50.43 146.55,50.63 146.93,50.63
GND on TOP (solid shape): 219.17,10.22 219.17,8.8 219.11,8.74 218.56,8.74 218.44,8.86 218.44,10.18 218.53,10.27 219.11,10.27
GND on TOP (solid shape): 265.39,27.27 265.39,25.85 265.29,25.76 264.81,25.76 264.73,25.84 264.73,27.29 264.81,27.38 265.28,27.38
GND on TOP (solid shape): 42.47,4.4 42.47,2.05 42.34,1.92 41.95,1.92 41.73,2.14 41.73,4.42 41.86,4.55 41.86,4.56 42.32,4.56
GND on TOP (solid shape): 132.88,19.83 132.88,18.28 132.77,18.17 131.62,18.17 131.12,18.68 131.12,19.82 131.23,19.93 132.78,19.93
GND on TOP (solid shape): 60.21,11.46 59.58,11.46 59.37,11.26 59.37,10.52 59.32,10.47 58.79,10.47 58.71,10.55 58.71,11.97 58.76,12.02 60.21,12.02
GND on TOP (solid shape): 77.7,11.42 77.7,8.92 76.68,7.89 75.11,7.89 75.08,7.93 75.08,11.01 75.95,11.89 77.23,11.89
GND on TOP (solid shape): 112.92,57.52 112.92,54.32 112.87,54.27 111.76,54.27 111.68,54.36 111.68,57.39 111.84,57.55 112.89,57.55
GND on TOP (solid shape): 125.44,12.84 125.96,12.84 126.01,12.79 126.01,9.29 125.95,9.23 123.21,9.23 122.87,9.57 122.87,12.63 123.09,12.84 125.44,12.84
GND on TOP (solid shape): 142.04,42.88 142.04,41.9 141.92,41.78 141.51,41.78 141.14,42.15 141.14,42.86 141.22,42.94 141.98,42.94
GND on TOP (solid shape): 132.9,64.34 132.9,62.93 132.88,62.91 132.67,62.91 132.63,62.96 132.48,62.96 131.96,63.48 131.96,64.54 131.97,64.55 132.69,64.55
GND on TOP (solid shape): 47.93,35.4 47.93,33.51 47.83,33.41 47.1,33.41 46.82,33.68 46.82,35.35 46.91,35.43 47.9,35.43
GND on TOP (solid shape): 54.85,34.92 54.85,33.46 54.71,33.32 54.62,33.32 54.61,33.32 53.96,33.32 53.71,33.57 53.71,34.93 53.83,35.05 54.72,35.05
GND on TOP (solid shape): 55.79,51.77 55.79,49.99 55.16,49.36 51.4,49.36 51.32,49.44 51.32,50.22 51.37,50.27 51.73,50.27 53.49,52.03 55.54,52.03
GND on TOP (solid shape): 61.51,58.24 61.51,53.03 61.16,52.68 60.12,52.68 59.66,53.14 59.66,58.43 59.73,58.5 61.24,58.5
GND on TOP (solid shape): 118.18,7.92 118.18,6.62 117.94,6.38 115.93,6.38 115.06,7.25 113.24,7.25 113.1,7.4 113.1,8.39 113.53,8.82 117.28,8.82
GND on TOP (solid shape): 124.35,64.93 124.35,64.42 124.28,64.36 123.29,64.36 123.09,64.15 123.09,63.77 123.04,63.72 122.16,63.72 122.09,63.8 122.09,64.75 122.54,65.21 124.07,65.21
GND on TOP (solid shape): 285.31,18.45 285.31,16.81 285.13,16.63 284.31,16.63 284.14,16.8 283.61,16.8 283.54,16.86 283.54,17.66 283.66,17.77 283.66,18.53 285.23,18.53
GND on TOP (solid shape): 286.53,51.01 287.44,51.01 287.49,50.96 287.49,50.39 287.43,50.33 287.07,50.33 286.7,50.71 286.17,50.71 286.12,50.75 286.12,51.04 286.15,51.08 286.47,51.08
GND on TOP (solid shape): 226.87,9.62 226.92,9.56 226.98,9.52 227.02,9.47 227.02,8.9 226.67,8.54 225.8,8.54 225.69,8.64 225.69,10.04 225.77,10.12 226.38,10.12
GND on TOP (solid shape): 276.93,15.95 276.93,15.43 277.18,15.18 277.64,15.18 277.7,15.12 277.7,14.3 277.57,14.16 276.68,14.16 276.3,14.54 276.3,15.89 276.43,16.02 276.86,16.02
GND on TOP (solid shape): 279.49,33.65 279.49,33.32 279.5,33.32 279.5,32.67 279.82,32.35 279.82,31.94 279.67,31.79 278.8,31.79 278.65,31.94 278.65,33.59 278.76,33.7 279.44,33.7
GND on TOP (solid shape): 288.62,66.39 288.49,66.39 288.49,64.48 290.73,64.48 290.73,64.85 292.57,64.85 292.57,64.48 294.81,64.48 294.81,64.85 296.95,64.85 296.95,63.89 287.55,63.89 287.55,68.51 288.62,68.51
GND on TOP (solid shape): 25.69,26.37 25.69,24.59 25.44,24.34 22.9,24.34 22.65,24.59 20.23,24.59 20.11,24.72 20.11,25.23 20.21,25.34 24.78,25.34 25.19,25.74 25.19,26.37 25.31,26.5 25.57,26.5
GND on TOP (solid shape): 111.52,75.66 113.28,75.66 113.38,75.57 113.38,75.34 112.51,74.47 112.51,73.78 112.33,73.61 107.11,73.61 106.76,73.96 106.76,74.95 106.29,75.42 106.29,75.66 106.34,75.7 111.48,75.7
GND on TOP (solid shape): 9.39,39.03 9.39,38.49 9.31,38.41 8.64,38.41 8.32,38.09 8.32,36.78 8.24,36.7 7.85,36.7 7.78,36.77 7.78,38.64 7.7,38.72 7.29,38.72 7.23,38.78 7.23,39.36 7.33,39.47 8.96,39.47
GND on TOP (solid shape): 38.32,53.94 38.32,53.49 38.19,53.36 36.05,53.36 35.73,53.04 35.73,50.61 35.58,50.46 35.58,48.49 35.44,48.35 34.95,48.35 34.81,48.5 34.81,48.86 34.14,49.53 34.14,53.69 34.48,54.03 38.23,54.03
GND on TOP (solid shape): 253.91,8.69 253.91,7.67 254,7.58 254.8,7.58 254.84,7.53 254.84,7.38 254.77,7.31 254.03,7.31 253.91,7.19 253.91,6.16 253.84,6.09 252.99,6.09 252.95,6.14 252.95,8.7 252.99,8.73 253.86,8.73
GND on TOP (solid shape): 271.2,3.76 271.2,3.17 271.31,3.05 273.05,3.05 273.11,2.99 273.11,2.41 273.02,2.32 273.02,1.39 272.93,1.29 270.48,1.29 270.39,1.38 270.39,3.71 270.56,3.87 271.08,3.87
GND on TOP (solid shape): 278.83,60.28 278.83,59.77 278.75,59.7 277.56,59.7 277.36,59.49 277.36,57.94 277.18,57.77 276.49,57.77 276.29,57.97 276.29,58.88 275.86,59.32 274.59,59.32 274.41,59.49 274.41,60.23 274.59,60.41 278.7,60.41
GND on TOP (solid shape): 109.01,64.04 109.01,63.73 108.75,63.48 108.75,60.84 108.75,60.84 108.75,59.76 108.73,59.73 108.69,59.73 108.28,59.73 108.23,59.79 108.23,61.91 108.24,61.91 108.24,63.4 108.28,63.44 108.28,63.94 108.49,64.16 108.88,64.16
GND on TOP (solid shape): 223.59,7.04 223.67,7.03 223.76,7.04 225.44,7.04 225.62,6.86 225.62,6.15 225.61,6.14 225.61,5.73 225.36,5.48 221.31,5.48 221.16,5.63 221.16,6.42 221.26,6.51 222.23,6.51 222.76,7.04
GND on TOP (solid shape): 94.55,48.26 94.55,47.64 94.35,47.64 91.68,44.97 91.68,41.55 89.94,39.8 87.51,39.8 86.32,41 86.32,45.52 85.21,46.63 85.21,48.11 88.79,48.11 89.17,47.73 91.07,47.73 91.08,47.73 91.85,47.73 92.4,48.28 94.54,48.28
GND on TOP (solid shape): 47.19,21.79 47.19,21.65 48.82,20.02 48.82,19.4 48.39,18.98 47.26,18.98 46.71,19.53 46.71,20.01 46.72,20.03 46.72,20.23 46.4,20.55 46.4,21.85 46.51,21.97 47.01,21.97
GND on TOP (solid shape): 69.72,21.04 69.72,17.43 70.8,16.35 70.8,12.45 71.02,12.24 71.02,11.86 70.89,11.73 69.84,11.73 69.55,12.02 69.55,15.55 68.26,16.83 67.74,16.83 67.65,16.92 67.65,21.85 67.69,21.89 68.87,21.89
GND on TOP (solid shape): 86.03,58.9 86.03,58.72 83.23,55.91 82.14,55.91 81.61,55.38 78.9,55.38 77.72,54.2 76.19,54.2 75.17,55.21 75.17,56.27 75.5,56.6 80.02,56.6 80.2,56.78 80.2,58.19 81.18,59.17 85.77,59.17
GND on TOP (solid shape): 98.56,61.47 98.56,60.88 98.78,60.66 100.42,60.66 100.55,60.54 100.55,60.11 100,59.56 95.91,59.56 95.85,59.62 95.85,60.22 95.86,60.22 95.86,61.29 96.07,61.5 97.75,61.5 97.77,61.52 98.52,61.52
GND on TOP (solid shape): 265.39,38.77 271.96,38.77 273.53,37.2 273.53,34.84 271.33,32.63 265.33,32.63 264.06,31.37 263.93,31.37 263.82,31.47 263.82,31.89 263.98,32.05 263.98,33.44 264.1,33.56 264.1,34.36 264.09,34.36 264.09,39.92 264.12,39.94 264.22,39.94
GND on TOP (solid shape): 91.29,68.82 91.29,66.85 90.04,65.6 86.99,65.6 86.21,66.38 82.3,66.38 82.1,66.57 78.12,66.57 77.92,66.38 73.1,66.38 72.77,66.71 72.77,68.56 72.91,68.7 76.59,68.7 76.59,68.7 77.44,68.7 77.6,68.54 85.25,68.54 87.52,70.8 89.3,70.8
GND on TOP (solid shape): 132.94,6.98 134.1,6.98 134.28,6.81 134.28,5.68 134.75,5.21 134.75,4.6 134.56,4.4 133.75,4.4 132.56,5.59 131.17,5.59 130.71,5.13 130.17,5.13 129.98,5.32 129.98,6.75 130.56,7.32 132.6,7.32
GND on TOP (solid shape): 142.04,9.86 142.08,9.86 142.84,9.86 142.87,9.83 148.37,9.83 150.27,7.93 150.27,5.27 148.95,3.96 146.28,3.96 144.35,5.89 144.35,7.98 143.39,8.93 140.2,8.93 140.03,9.11 140.03,9.68 140.21,9.86 142,9.86
GND on TOP (solid shape): 7.84,49.78 7.84,49.29 7.78,49.23 7.1,49.23 7,49.33 7,49.43 6.8,49.63 6.69,49.63 6.58,49.65 6.47,49.63 6.27,49.63 6.11,49.48 5.5,49.48 5.4,49.58 5.4,49.78 5.48,49.86 6.46,49.86 6.75,50.15 7.46,50.15
GND on TOP (solid shape): 101.5,54.23 101.5,53.91 101.82,53.59 101.82,52.95 101.65,52.78 100.95,52.78 100.92,52.76 99.39,52.76 99.16,52.53 93.45,52.53 93.41,52.57 93.41,53.22 96.77,53.22 96.78,53.22 99.86,53.22 100.01,53.37 100.67,53.37 101.09,53.79 101.09,54.25 101.21,54.37 101.35,54.37
GND on TOP (solid shape): 222.15,21.1 222.71,20.38 223.31,19.67 224.31,18.44 224.44,18.44 224.78,18.1 224.78,17.87 224.77,17.87 224.77,16.43 224.63,16.29 216.2,16.29 214.36,18.14 211.99,18.14 211.86,18.26 211.86,18.36 212.92,19.42 213.02,19.42 215.63,22.85 220.7,22.87
GND on TOP (solid shape): 277.15,28.95 277.15,27.83 277.95,27.04 277.95,24.47 277.88,24.4 277.54,24.4 277.48,24.46 277.48,26.05 277.48,26.24 277.48,26.75 277.39,26.84 275.93,26.84 275.93,27.89 276.16,28.12 276.16,28.87 276.35,29.06 277.04,29.06
GND on TOP (solid shape): 61.05,38.38 61.05,32.8 60.83,32.58 59.23,32.58 58.48,33.33 58.48,34.06 58.16,34.37 55.39,34.37 55.03,34.73 55.03,36.07 55.2,36.24 58.41,36.24 58.88,36.71 58.88,38.18 59.41,38.71 60.73,38.71
GND on TOP (solid shape): 61.65,28.63 61.65,26.14 61.52,26.02 56.77,26.02 56.25,25.5 56.25,18.38 56.2,18.33 55.63,18.33 55.56,18.4 55.56,20.29 55.42,20.43 55.42,21 55.16,21.27 54.79,21.27 54.65,21.41 54.65,26.05 56.32,27.72 57.62,27.72 58.82,28.92 61.36,28.92
GND on TOP (solid shape): 6.18,60.62 6.4,60.45 6.68,60.48 7.87,60.48 7.94,60.41 7.94,60.05 7.87,59.98 6.41,59.98 6.36,60.02 6.36,60.04 6.31,60.1 5.58,60.1 5.3,60.38 5.3,60.56 5.45,60.71 6.09,60.71
GND on TOP (solid shape): 71.47,36.83 71.47,35.57 71.26,35.36 70.84,35.36 70.56,35.08 70.56,34.25 71.25,33.56 71.25,32.95 70.65,32.36 69.2,32.36 68.72,32.84 68.72,34.82 68.53,35.01 66.73,35.01 66.48,35.25 65.86,35.25 65.73,35.39 65.73,35.53 65.73,35.53 65.73,36.72 66.07,37.06 71.23,37.06
GND on TOP (solid shape): 22.22,51.61 22.22,51.29 22.37,51.14 22.69,51.14 22.76,51.07 22.76,50.91 22.66,50.81 21.84,50.81 21.76,50.73 21.76,49.06 21.67,48.97 20.82,48.97 20.73,49.06 20.73,49.32 20.83,49.42 21.07,49.42 21.25,49.6 21.25,50.75 21.6,51.1 21.69,51.1 21.88,51.29 21.88,51.63 21.93,51.68 22.16,51.68
GND on TOP (solid shape): 20.61,46.09 20.61,44.42 20.57,44.38 20.27,44.38 20.12,44.53 20.12,45.23 19.99,45.36 19.41,45.36 19.34,45.3 19.34,44.38 19.24,44.28 18.63,44.28 18.43,44.48 18.43,44.69 18.44,44.77 18.43,44.85 18.59,45.01 18.59,45.23 18.29,45.53 18.29,45.88 18.34,45.92 19.98,45.92 19.99,45.94 20.04,45.94 20.26,46.15 20.55,46.15
GND on TOP (solid shape): 112.93,65.43 112.93,61 112.85,60.92 112.85,60.22 112.84,60.21 112.82,60.08 112.84,59.94 112.85,59.93 112.85,59.84 112.8,59.79 112.44,59.79 112.4,59.84 112.4,59.9 112.41,59.9 112.41,60.93 112.37,60.97 112.03,60.97 111.87,61.13 111.87,62.08 112.26,62.47 112.26,64.53 112.5,64.78 112.5,65.4 112.56,65.45 112.91,65.45
GND on TOP (solid shape): 27.47,48.75 27.55,48.74 27.63,48.75 27.68,48.75 27.9,48.52 27.9,46.82 27.89,46.81 27.89,44.22 26.76,43.09 25.78,43.09 25.69,43.1 25.61,43.09 25.56,43.09 25.27,43.37 25.27,44.46 25.06,44.67 25.06,46.04 25.28,46.26 25.33,46.26 25.34,46.25 26.4,46.25 26.48,46.33 26.48,48.67 26.56,48.75
GND on TOP (solid shape): 104.48,58.88 104.48,58.84 104.47,58.84 104.47,58.17 104.71,57.94 108.14,57.94 108.33,57.74 109.06,57.74 109.17,57.63 109.17,54.33 109.17,54.33 109.06,54.22 108.1,54.22 107.39,53.5 104.18,53.5 104.04,53.65 104.04,54.39 104.23,54.58 104.68,54.58 104.77,54.67 104.77,57.08 104.58,57.27 104.16,57.27 104.07,57.37 104.07,58.91 104.07,58.91 104.45,58.91
GND on TOP (solid shape): 37.25,35.78 37.29,35.76 37.51,35.55 37.51,32.91 36.81,32.22 36.81,31.62 36.7,31.51 36.47,31.51 36.31,31.68 36.31,32.04 36.18,32.17 36.18,32.78 36.21,32.81 36.69,32.81 36.8,32.91 36.86,32.91 36.86,32.97 36.89,33 36.89,33.99 36.87,34 36.87,34.12 36.76,34.12 36.66,34.22 36.66,34.36 36.86,34.56 36.89,34.56 36.89,35.17 36.85,35.17 36.68,35.34 36.68,35.61 36.85,35.78
GND on TOP (solid shape): 119.88,64.99 119.88,64.61 119.82,64.54 119.76,64.5 119.72,64.44 119.63,64.36 119.58,64.31 119.53,64.26 119.38,64.1 119.1,64.1 118.93,63.93 118.93,63.3 119.15,63.08 119.15,62.5 118.96,62.31 118.96,62.06 118.96,62.06 118.96,61.22 118.87,61.13 118.02,61.13 117.95,61.2 117.95,62.72 117.98,62.75 118.28,62.75 118.46,62.92 118.46,65.03 118.46,65.05 118.61,65.2 119.67,65.2
GND on TOP (solid shape): 36.31,27.44 36.31,26.58 36.31,26.57 36.31,25.84 34.74,24.27 34.74,24.2 34.62,24.07 34.62,23.42 34.47,23.27 33.05,23.27 32.99,23.33 32.99,24.47 33.3,24.78 33.3,26.16 33.19,26.26 32.82,26.26 32.66,26.42 31.09,26.42 30.95,26.57 30.95,27.22 31.05,27.32 31.64,27.32 31.86,27.11 32.42,27.11 32.43,27.11 32.61,27.11 32.69,27.19 32.69,27.59 32.82,27.72 36.03,27.72
GND on TOP (solid shape): 30.7,21.54 30.7,20.81 30.93,20.58 31.48,20.58 31.82,20.25 31.82,18.93 31.95,18.79 32.52,18.79 32.88,18.44 32.88,17.81 32.76,17.69 32.29,17.69 32.13,17.84 32.13,18.37 32.03,18.47 31.32,18.47 31.14,18.29 31.14,17.69 30.95,17.5 30.12,17.5 29.9,17.71 29.9,18.07 29.58,18.39 29.21,18.39 29.09,18.52 29.09,18.94 29.2,19.06 29.81,19.06 29.96,19.22 29.96,21.59 29.96,21.59 29.96,21.66 30.02,21.72 30.52,21.72
GND on TOP (solid shape): 64.51,7.44 64.51,6.89 64.35,6.73 63.88,6.73 63.74,6.59 63.74,5.93 63.83,5.84 64.47,5.84 64.61,5.69 64.61,5.08 64.5,4.97 63.17,4.97 63.01,5.13 63.01,5.7 62.84,5.87 62.19,5.87 62.07,5.99 62.07,6.44 61.76,6.75 61.27,6.75 61.17,6.84 61.17,7.39 61.23,7.45 61.7,7.45 61.78,7.37 61.78,6.96 62.05,6.7 62.8,6.7 62.86,6.75 62.86,7.45 62.93,7.53 64.43,7.53
GND on TOP (solid shape): 24.41,51.7 24.41,50.05 24.54,49.93 24.54,49.64 24.45,49.55 24.01,49.55 23.88,49.42 23.88,48.87 24,48.75 25.07,48.75 25.32,49.01 25.32,49.95 25.4,50.02 25.7,50.02 25.81,49.92 25.81,48.92 25.57,48.69 25.57,48.31 25.51,48.25 24.49,48.25 24.33,48.09 24.33,47.75 24.23,47.65 23.8,47.65 23.72,47.74 23.72,48.79 23.61,48.9 23.53,48.9 23.5,48.93 23.5,49.46 23.39,49.57 23.39,50.58 23.46,50.65 23.71,50.65 23.99,50.93 23.99,51.73 24.05,51.79 24.32,51.79
GND on TOP (solid shape): 111.62,75.7 126.08,75.7 126.16,75.62 126.16,75.38 124.37,73.59 122.02,73.59 121.03,72.61 121.03,70.29 120.85,70.11 116.05,70.11 115.1,71.06 114.77,71.06 114.41,71.42 114.41,71.78 114.61,72.1 114.41,72.43 114.41,73.33 114.13,73.61 107.11,73.61 106.76,73.96 106.76,74.95 106.29,75.42 106.29,75.66 106.34,75.7 111.61,75.7
GND on TOP (solid shape): 107.07,66.32 107.07,62.53 107.03,62.5 106.8,62.5 106.67,62.61 106.5,62.65 106.24,62.53 106.17,62.25 106.15,62.16 106.07,62.12 103.1,62.12 103.05,62.18 103.05,62.77 103.12,62.84 103.62,62.84 104.77,64 104.77,64.9 106.3,66.43 106.95,66.43
GND on TOP (solid shape): 22.49,47.92 22.49,47.4 22.53,47.36 23.04,47.36 23.11,47.42 23.11,47.48 23.17,47.55 23.58,47.55 23.63,47.5 23.63,46.47 23.59,46.43 23.4,46.43 23.39,46.43 23.26,46.43 23.2,46.49 23.2,46.81 23.19,46.82 23.19,46.88 23.13,46.94 22.46,46.94 22.38,46.86 22.38,46.42 22.28,46.32 22.05,46.32 21.89,46.17 21.89,46.11 21.88,46.1 21.88,44.61 21.89,44.6 21.89,43.24 21.55,43.24 21.46,43.32 21.46,44.44 21.46,44.44 21.46,46.14 21.23,46.37 21.23,46.74 21.3,46.82 21.83,46.82 22.01,47 22.01,47.94 22.06,47.99 22.42,47.99
GND on TOP (solid shape): 90.82,61.29 90.82,61.09 90.81,61.03 90.82,60.97 90.82,60.86 91.04,60.64 91.3,60.64 91.54,60.88 91.54,61.32 91.59,61.37 92.03,61.37 92.05,61.37 92.07,61.36 92.07,61.12 92.06,61.03 92.07,60.95 92.07,60.89 92.12,60.84 92.17,60.78 92.23,60.74 92.31,60.65 92.55,60.65 92.78,60.89 92.78,61.28 92.87,61.37 93.23,61.37 93.79,60.8 93.79,59.95 89.19,59.95 89.16,59.98 89.16,61.16 89.29,61.28 89.46,61.28 89.61,61.14 89.6,61.08 89.61,61.02 89.61,60.81 89.75,60.67 90.15,60.67 90.33,60.84 90.33,61.25 90.45,61.37 90.74,61.37
GND on TOP (solid shape): 70.96,65.82 70.96,65.09 70.8,64.94 70.22,64.94 68.92,63.64 68.92,54.18 68.68,53.94 67.88,53.94 67.68,53.74 67.68,48.79 67.84,48.63 74.23,48.63 75.04,47.82 75.04,44.49 74.32,43.77 71.68,43.77 71.14,43.23 71.14,41.71 69.89,40.47 69.89,38.82 69.38,38.31 66.61,38.31 66.21,38.71 66.21,39.5 65.96,39.75 65.96,40.01 66.08,40.13 66.08,40.82 66.43,41.18 66.43,44.37 65.78,45.03 65.78,45.5 65.48,45.8 65.48,48.68 65.65,48.84 65.65,53.07 65.49,53.23 65.49,56.69 65.86,57.06 65.86,58.67 65.86,58.67 65.86,59.17 65.73,59.3 65.24,59.3 65.07,59.47 65.07,62.51 65.66,63.1 65.66,63.74 65.9,63.98 67.02,63.98 67.03,63.98 68.13,63.98 68.25,64.1 68.25,65.88 68.33,65.96 70.82,65.96
GND on TOP (solid shape): 52.31,26.34 52.31,25.61 52.27,25.54 52.19,25.51 51.83,25.34 51.86,24.94 51.88,24.87 51.85,24.8 51.81,24.75 51.77,24.7 51.82,24.32 52.18,24.2 52.27,24.18 52.31,24.1 52.46,23.94 52.46,22.32 52.27,22.13 51.04,22.13 49.89,23.28 49.16,23.28 48.31,24.13 48.31,24.93 50.38,27 51.65,27
GND on TOP (solid shape): 103.22,58.88 103.22,58.53 103.15,58.46 102.2,58.46 101.98,58.24 101.98,56.59 101.93,56.55 101.59,56.55 101.54,56.6 101.54,56.62 101.52,56.62 96.43,56.62 96.28,56.78 96.28,57.36 96.35,57.43 96.64,57.43 96.69,57.43 96.74,57.43 97.23,57.43 97.32,57.42 97.41,57.44 97.85,57.44 97.91,57.43 97.97,57.44 99.15,57.44 99.28,57.44 99.4,57.49 99.76,57.49 99.77,57.48 99.87,57.47 99.98,57.48 99.99,57.49 100.45,57.49 100.45,57.49 100.55,57.47 100.65,57.49 100.66,57.49 101.1,57.49 101.17,57.48 101.34,57.49 101.52,57.67 101.52,57.84 101.52,57.9 101.52,58.72 101.75,58.96 103.14,58.96
GND on TOP (solid shape): 121.48,61.85 121.48,61.36 121.35,61.23 121.35,61.13 121.34,61.12 121.62,60.62 122.02,61.03 122.02,61.05 122.27,61.3 122.45,61.3 122.71,61.05 122.71,60.8 122.64,60.73 122.2,60.29 122.2,57.42 121.35,56.57 121.35,54.79 121.47,54.67 122.18,54.67 122.31,54.55 122.31,53.96 122.41,53.86 122.71,53.86 122.96,53.61 122.96,53.28 123.32,52.92 123.32,52.42 123.26,52.36 123,52.36 122.96,52.4 122.96,52.64 122.55,53.05 119.41,53.05 119.28,53.18 119.28,53.68 119.41,53.81 120.19,53.81 120.31,53.92 120.3,53.96 120.3,56.22 120.35,56.26 120.35,59.63 120.35,60.05 120.35,60.17 120.41,60.23 120.62,60.23 120.68,60.29 120.68,60.8 120.55,60.92 120.55,61.18 120.68,61.3 120.92,61.3 120.92,61.33 121.09,61.5 121.09,61.88 121.1,61.89 121.44,61.89
GND on TOP (solid shape): 296.93,6.13 296.93,2.6 296.64,2.32 274.62,2.32 274.12,1.82 274.12,0.55 273.86,0.29 269.85,0.29 269.72,0.42 269.72,0.74 270.39,1.41 270.39,1.41 270.39,3.71 270.56,3.87 271.08,3.87 271.2,3.76 271.2,3.17 271.31,3.05 274.4,3.05 274.67,3.33 274.67,3.98 274.99,4.29 275.85,4.29 276.2,3.94 276.26,3.86 276.34,3.8 276.4,3.74 276.83,3.74 277.16,4.07 278.19,4.07 278.29,3.96 278.29,3.35 278.47,3.18 279.36,3.18 279.49,3.31 279.49,4.52 279.61,4.63 285.33,4.63 285.58,4.89 285.58,5.19 286.05,5.66 289.64,5.66 290.52,4.78 292.21,4.78 292.71,4.28 294.44,2.9 295.99,4.49 296.5,5 296.5,6.05 296.7,6.26 296.8,6.26
GND on TOP (solid shape): 128.27,50.2 128.27,49.93 128.27,49.93 128.43,49.77 128.54,49.77 128.6,49.71 128.6,49.6 128.55,49.55 128.37,49.55 128.34,49.57 128.11,49.84 127.78,49.73 127.71,49.55 127.75,49.37 127.76,49.36 127.76,49.08 127.74,49.03 127.73,48.97 127.65,48.89 127.65,48.48 127.63,48.42 127.34,48.14 126.37,48.14 126.27,48.04 126.17,48.04 125.84,48.37 125.84,48.9 126.22,49.28 126.48,49.28 126.73,49.03 126.73,49.01 126.75,48.82 126.88,48.67 127.36,48.64 127.42,49.12 127.42,49.4 127.45,49.45 127.47,49.51 127.48,49.64 127.44,49.77 127.44,49.78 127.44,50.17 127.72,50.45 128.02,50.45
GND on TOP (solid shape): outline of 106 points within 37.57,20.78 43.22,30.92
GND on TOP (solid shape): 4.08,59.8 4.15,59.77 4.18,59.7 4.18,59.66 4.18,59.48 4.77,58.9 5.35,59.48 5.35,59.66 5.35,59.7 5.38,59.77 5.45,59.8 7.69,59.8 8,59.49 8,58.48 6.88,57.35 6.88,57.33 6.67,57.13 6.67,56.33 6.88,56.13 6.88,54.11 8.02,52.97 8.02,52.06 7.98,52.02 7.98,50.89 7.57,50.47 6.74,50.47 6.52,50.26 6.52,50.26 6.49,50.23 5.39,50.23 5.31,50.26 5.28,50.33 4.89,50.87 4.24,50.68 4.16,50.64 4.09,50.67 4.04,50.71 2.94,50.71 2.61,50.38 0.41,50.38 0.32,50.47 0.32,51.05 0.25,51.05 0.25,51.98 0.27,52.08 0.33,52.16 1.63,53.46 1.8,53.71 1.85,54 1.85,55.88 1.8,56.17 1.63,56.42 0.33,57.72 0.27,57.8 0.25,57.9 0.25,58.65 0.32,58.65 0.32,59.59 2.55,59.59 2.77,59.8
GND on TOP (solid shape): outline of 148 points within 288.48,49.99 292.32,55.6
GND on TOP (solid shape): outline of 149 points within 20.63,61.43 88.03,75.74
GND on TOP (solid shape): outline of 157 points within 0.26,29.66 8.55,44.24
GND on TOP (solid shape): outline of 137 points within 113.57,53.82 118.94,58.73
GND on TOP (solid shape): outline of 111 points within 264.03,42.61 278.81,68.5
GND on TOP (solid shape): outline of 198 points within 78.78,71.52 84.27,77
GND on TOP (solid shape): outline of 198 points within 145.89,71.52 151.37,77
GND on TOP (solid shape): 7.13,73.89 7.3,73.82 7.37,73.65 7.37,69.3 7.59,68.76 8.13,68.54 23.24,68.54 23.24,67.42 22.74,66.91 21.76,66.91 21.74,66.94 21.43,67.13 21.11,66.94 21.1,66.91 18.91,66.91 17.42,67.95 15.86,67.01 14.79,67.01 14.3,67.5 12.65,67.5 12.33,67.18 11.92,67.18 11.91,67.22 10.39,67.98 9.75,66.42 9.74,66.32 9.65,66.27 8.4,66.27 7.79,65.66 7,65.66 6.93,65.69 6.9,65.76 6.63,66.11 6.23,65.93 6.22,65.91 4.66,65.91 4.55,66.02 4.53,66.13 4.64,66.19 5.11,67.18 4.12,66.71 4.06,66.6 3.95,66.62 3.86,66.71 0.26,66.71 0.26,73.65 0.33,73.82 0.5,73.89
GND on TOP (solid shape): outline of 254 points within 101.27,35.91 116.6,47.96
GND on TOP (solid shape): outline of 274 points within 17.27,29.04 21.1,32.54
GND on TOP (solid shape): outline of 367 points within 11.38,36.7 24.76,64.83
GND on TOP (solid shape): outline of 389 points within 29.83,31.28 33.64,34.79
GND on TOP (solid shape): outline of 541 points within 171.18,1.5 226.19,16.26
GND on TOP (solid shape): outline of 571 points within 0.25,0.26 297,51.7
GND on TOP (solid shape): outline of 577 points within 213.18,1.5 266.18,16.88
GND on TOP (solid shape): outline of 885 points within 282.32,19.41 297.51,71.74
GND on TOP (solid shape): outline of 106 points within 0.25,12.18 297.01,75.74
GND on TOP (solid shape): outline of 1070 points within 141.52,40.03 172.37,75.72
GND on BOTTOM (solid shape): 4.03,34.41 2.98,34.41 2.98,36.05 4.03,36.05
GND on BOTTOM (solid shape): 4.1,30.49 2.96,30.49 2.96,32.26 4.1,32.26
GND on BOTTOM (solid shape): 10.25,50.07 9.44,50.07 9.44,57.44 10.25,57.44
GND on BOTTOM (solid shape): 10.25,44.41 9.44,44.41 9.44,47.94 10.25,47.94
GND on BOTTOM (solid shape): 152.28,13.41 152.28,12.14 152.2,12.06 151.49,12.06 151.49,13.39 151.58,13.47 152.22,13.47
GND on BOTTOM (solid shape): 27.1,29.95 27.1,28.68 26.78,28.36 24.88,28.36 24.27,28.98 24.27,29.46 24.89,30.09 26.96,30.09
GND on BOTTOM (solid shape): 61.69,47.4 61.69,44.33 61.51,44.15 58.46,44.15 58.28,44.33 58.28,47.35 58.51,47.58 61.51,47.58
GND on BOTTOM (solid shape): 91.1,50.71 91.1,50.18 90.99,50.07 86.5,50.07 86.37,50.2 86.37,50.59 86.55,50.77 91.04,50.77
GND on BOTTOM (solid shape): 92.41,11.13 92.41,8.13 92.34,8.07 90.12,8.07 90.03,8.16 90.03,11.26 90.12,11.35 92.19,11.35
GND on BOTTOM (solid shape): 151.16,58.37 151.16,57.75 150.92,57.5 149.7,57.5 149.65,57.55 149.65,58.41 149.73,58.49 151.05,58.49
GND on BOTTOM (solid shape): 160.82,50.78 160.82,50.14 160.63,49.96 157.47,49.96 157.1,50.33 157.1,50.83 157.18,50.91 160.69,50.91
GND on BOTTOM (solid shape): 166.58,65.01 166.58,63.56 166.3,63.28 162.35,63.28 162.32,63.31 162.32,65.29 162.43,65.4 166.19,65.4
GND on BOTTOM (solid shape): 167.64,52.33 167.64,51.7 166.64,50.69 164.73,50.69 164.66,50.75 164.66,52.37 164.88,52.59 167.39,52.59
GND on BOTTOM (solid shape): 267.9,13.26 267.9,12.54 267.86,12.5 266.56,12.5 266.07,13 266.07,13.35 266.14,13.42 267.74,13.42
GND on BOTTOM (solid shape): 282.94,51.21 282.94,44.57 282.41,44.05 270.48,44.05 269.82,44.71 269.82,51.19 270.41,51.78 282.36,51.78
GND on BOTTOM (solid shape): 290.33,58.37 290.33,57.13 290.14,56.95 289.52,56.95 289.36,57.1 289.36,58.4 289.41,58.45 290.25,58.45
GND on BOTTOM (solid shape): 154.28,6.55 154.28,4.27 154.18,4.17 152.79,4.17 152.79,5.77 152.81,5.79 152.81,6.58 152.83,6.6 154.22,6.6
GND on BOTTOM (solid shape): 34,35.52 9.44,35.52 9.44,43.17 10.25,43.17 10.25,36.3 33.24,36.3 33.24,59.27 13.1,59.27 13.1,60.05 34,60.05
GND on BOTTOM (solid shape): 36.36,3.89 37.5,3.89 37.63,3.77 37.63,3.26 37.5,3.13 35.09,3.13 34.71,3.51 34.71,4.02 34.96,4.27 35.98,4.27
GND on BOTTOM (solid shape): 56.13,36.08 56.13,34.83 56.09,34.8 55.16,34.8 55.06,34.89 55.06,36.05 55.17,36.16 56.05,36.16
GND on BOTTOM (solid shape): 112.39,10.97 112.39,8.23 112.12,7.97 110.62,7.97 110.44,8.15 110.44,11.22 110.6,11.38 111.97,11.38
GND on BOTTOM (solid shape): 129.39,73.08 129.39,71.64 129.21,71.46 126.63,71.46 126.42,71.67 126.42,72.95 126.71,73.24 129.23,73.24
GND on BOTTOM (solid shape): 142.34,51.2 142.34,49.36 142.22,49.24 142.22,48.01 142.16,47.94 141.77,47.94 141.71,48.01 141.71,51.25 141.72,51.27 142.27,51.27
GND on BOTTOM (solid shape): 253.76,7.52 253.76,6.55 253.53,6.32 252.04,6.32 251.88,6.48 251.88,7.38 252.27,7.77 253.51,7.77
GND on BOTTOM (solid shape): 293.85,17.05 293.85,12.7 293.65,12.5 292.9,12.5 292.85,12.56 292.85,17.17 292.88,17.2 293.7,17.2
GND on BOTTOM (solid shape): 47.92,35.35 47.92,34.23 47.91,34.22 47.91,33.68 47.74,33.51 47,33.51 46.83,33.68 46.83,35.31 46.95,35.43 47.84,35.43
GND on BOTTOM (solid shape): 197.88,5.04 197.88,3.83 197.77,3.71 197.4,3.71 197.25,3.87 197.25,4.1 196.99,4.36 196.99,5.22 197.03,5.26 197.66,5.26
GND on BOTTOM (solid shape): 294.96,33.2 295.81,33.2 295.89,33.12 295.89,32.18 295.78,32.07 294.64,32.07 294.25,32.46 294.25,33.34 294.3,33.38 294.78,33.38
GND on BOTTOM (solid shape): 54.78,34.91 54.78,33.97 54.85,33.9 54.85,33.27 54.76,33.18 53.93,33.18 53.7,33.41 53.7,34.77 53.91,34.98 54.7,34.98
GND on BOTTOM (solid shape): 109.01,15.09 109.01,13.32 107.85,12.16 102.64,12.16 101.98,12.83 101.98,13.36 102.13,13.5 102.81,13.5 102.94,13.63 102.94,15.43 103.12,15.62 108.49,15.62
GND on BOTTOM (solid shape): 153.71,41.36 153.71,39.96 153.41,39.66 150,39.66 149.92,39.58 149.77,39.58 149.53,39.82 149.53,40.16 151.04,41.68 153.39,41.68
GND on BOTTOM (solid shape): 167.65,56.25 167.65,55.34 167.56,55.25 165.58,55.25 165.41,55.42 165.41,55.89 165.43,55.92 165.82,55.92 165.82,55.93 165.94,55.93 166.41,56.4 167.5,56.4
GND on BOTTOM (solid shape): 195.23,3.41 195.23,2.79 195.11,2.67 194.89,2.67 194.57,2.35 194.03,2.35 194.02,2.36 194.02,3.85 194.06,3.9 194.75,3.9
GND on BOTTOM (solid shape): 257.51,9.22 257.51,4.65 257.36,4.5 256.34,4.5 255.7,5.14 255.7,7.8 255.44,8.07 255.44,8.09 255.22,8.3 255.22,10.14 255.33,10.25 256.48,10.25
GND on BOTTOM (solid shape): 289.17,50.27 289.17,48.96 289.1,48.9 286.8,48.9 286.74,48.96 286.74,49.44 286.81,49.5 287.4,49.5 287.6,49.7 287.6,50.29 287.63,50.32 289.11,50.32
GND on BOTTOM (solid shape): 125.5,13.34 125.5,9.88 125.41,9.79 120.62,9.79 120.37,10.04 120.37,13.1 121.45,14.18 124.66,14.18
GND on BOTTOM (solid shape): 282.13,39.17 282.13,38.31 282.06,38.24 281.66,38.24 281.07,37.64 280.44,37.64 280.38,37.71 280.38,38.35 280.22,38.5 280.22,39.38 280.26,39.41 281.88,39.41
GND on BOTTOM (solid shape): 284.18,29.48 284.18,29.17 284.06,29.04 281.77,29.04 281.39,28.66 281.39,28.12 281.31,28.05 280.52,28.05 280.44,28.13 280.44,28.57 281.47,29.61 284.04,29.61
GND on BOTTOM (solid shape): 15.08,29.85 15.08,28.51 14.9,28.33 14.06,28.33 13.97,28.34 13.89,28.33 13.31,28.33 12.96,28.68 12.96,29.81 13.19,30.04 14.89,30.04
GND on BOTTOM (solid shape): 281.47,9.57 281.47,8.99 281.42,8.94 281.19,8.94 281.19,8.94 281.01,8.94 280.74,8.67 280.42,8.67 280.24,8.85 280.24,9.35 280.63,9.74 281.3,9.74
GND on BOTTOM (solid shape): 287.17,47.12 287.17,46.2 287.42,45.95 287.92,45.95 288.11,45.76 288.11,45.55 287.94,45.39 287.05,45.39 286.85,45.59 286.85,47.09 286.92,47.16 287.13,47.16
GND on BOTTOM (solid shape): 24.83,18.05 24.83,17.06 25.19,16.69 25.19,16.59 25.12,16.52 24.84,16.52 24.67,16.69 24.67,17.58 24.53,17.72 24.11,17.72 24.03,17.8 24.03,18.09 24.09,18.16 24.71,18.16
GND on BOTTOM (solid shape): 67.7,36.22 67.7,35.59 67.77,35.52 67.77,35.14 67.64,35 66.86,35 66.72,35.14 66.72,35.6 66.78,35.65 66.78,36.21 66.8,36.23 67.18,36.23 67.19,36.24 67.68,36.24
