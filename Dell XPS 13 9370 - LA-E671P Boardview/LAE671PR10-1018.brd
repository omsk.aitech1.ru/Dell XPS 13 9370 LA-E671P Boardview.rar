# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDI2_PTX_TBRX_N3_C: length 2.5
  BOTTOM w0.076: UT2.AC21 28.17,43.41 28.1,43.48 28.1,43.56 28.18,43.64 28.42,43.64 28.68,43.38 29.26,43.38 29.53,43.11 29.8,43.11 29.95,43.25
  BOTTOM w0.102: 29.95,43.25 CT34.1
DDI2_PTX_TBRX_P0: length 102.7
  IN3 w0.076: v3(108.16,68.44) 107.96,68.64 107.96,68.75 106.91,69.8 106.63,69.8 106.54,69.89 106.52,69.89 ; 31.29,46.52 v3(31.28,46.51)
  IN3 w0.089: 106.52,69.89 105.66,69.89 105.52,69.75 94.97,69.75 94.54,69.31 91.25,69.31 89.86,70.7 87.43,70.7 86.8,70.07 85.84,69.12 79.5,69.12 77.88,70.73 71.8,70.73 71.35,70.28 62.33,70.28 62.23,70.39 54.12,70.39 51.02,67.29 45.19,67.29 39.19,61.29 39.19,55.67 36.66,53.14 33.95,53.14 33.77,53.31 32.71,53.31 31.93,52.53 31.93,46.74 31.71,46.52 31.29,46.52
  GND3 w0.102: v4(30.62,46.51) v3(31.28,46.51) ; v4(108.21,68.06) 108.1,68.18 108.1,68.37 v3(108.16,68.44)
  BOTTOM w0.076: UCPU1.D50 109.38,64.39 109.42,64.39 109.73,64.7 109.73,65.03 109.65,65.16 109.65,65.29 109.72,65.46 109.72,65.59 109.66,65.79 arc(109.65,65.83) 109.65,65.87 arc(109.66,65.95) 109.68,66.02 109.69,66.06 arc(109.71,66.31) 109.59,66.53 109.34,66.79 108.92,66.79 108.14,67.56 108.14,68 v4(108.21,68.06)
DDI2_PTX_TBRX_P0_C: length 2.5
  BOTTOM w0.076: 29.29,46.3 29.2,46.3 29.17,46.34 28.62,46.34 28.54,46.41 28.11,46.41 27.87,46.17 UT2.AB15
  BOTTOM w0.102: 29.29,46.3 29.82,46.3 CT27.1
DDI2_PTX_TBRX_P1: length 98.5
  IN3 w0.076: v3(107.45,67.28) 107.53,67.28 107.67,67.14 107.67,67.14 107.78,67.03 107.78,66.43 107.53,66.17 107.2,66.17 106.5,66.87 106.5,67 106.46,67.05
  IN3 w0.089: 106.46,67.05 105.75,67.75 105.46,67.75 98.62,67.75 96.47,65.59 91.35,65.59 90.34,64.58 86.94,64.58 84.43,67.1 82.99,67.1 82.47,67.62 78.64,67.62 76.97,69.29 72.4,69.29 71.91,68.8 61.64,68.8 61.51,68.93 54.92,68.93 51.73,65.74 46.66,65.74 40.72,59.8 40.72,55.01 35.05,49.34 35.05,46.46 34.19,45.6 v3(33.44,45.6)
  GND3 w0.102: v4(107.64,66.97) 107.63,66.98 107.63,67.1 v3(107.45,67.28) ; v3(33.44,45.6) 33.44,45.6 33.31,45.46 32.59,45.46 v4(32.37,45.68)
  BOTTOM w0.076: UCPU1.D52 107.97,64.44 107.89,64.44 107.64,64.68 107.64,64.84 107.66,65 107.75,65.18 107.75,65.3 107.7,65.55 107.7,65.71 107.75,65.88 107.75,65.93 107.7,66.04 107.7,66.51 107.74,66.56 107.74,66.87 v4(107.64,66.97)
DDI2_PTX_TBRX_P1_C: length 4.2
  BOTTOM w0.076: 29.92,45.49 29.9,45.47 28.08,45.47 27.87,45.25 UT2.AB17
  BOTTOM w0.102: CT29.1 31.6,45.49 29.92,45.49
DDI2_PTX_TBRX_P2: length 100.1
  IN3 w0.076: 106.47,65.65 106.49,65.65 106.58,65.55 108.36,65.55 108.54,65.73 108.54,65.91 108.42,66.02 v3(108.24,66.02)
  IN3 w0.089: 106.47,65.65 97.77,65.65 96.46,64.34 91.16,64.34 90.56,63.74 85.4,63.74 82.8,66.34 79.78,66.34 79.25,66.86 78.33,66.86 77.18,68.01 61.28,68.01 61.1,68.19 55.28,68.19 51.96,64.86 46.98,64.86 41.48,59.36 41.48,54.63 37.5,50.65 37.5,50.03 37.12,49.66 36.48,49.66 36.12,49.3 36.12,45.61 33.47,42.95 32.84,42.95 32.53,43.27 32.53,44.55 32.11,44.96 31.14,44.96 v3(31.04,44.86)
  GND3 w0.102: v4(30.62,44.86) v3(31.04,44.86) ; v3(108.24,66.02) 108.53,65.73 v4(108.53,65.64)
  BOTTOM w0.076: UCPU1.B50 109.26,65.67 109.05,65.88 108.73,65.88 108.53,65.68 v4(108.53,65.64)
DDI2_PTX_TBRX_P2_C: length 2.6
  BOTTOM w0.076: UT2.AB19 27.86,44.33 28.09,44.56 28.41,44.56 28.54,44.43 28.9,44.43 29.08,44.62 29.79,44.62 29.95,44.78
  BOTTOM w0.102: 29.95,44.78 CT31.1
DDI2_PTX_TBRX_P3: length 98.7
  IN3 w0.076: 106.47,64.51 106.49,64.51 106.58,64.61 107.34,64.61 107.66,64.28 108.63,64.28 108.86,64.51 108.86,64.72 v3(109.04,64.9)
  IN3 w0.089: 106.47,64.51 98.26,64.51 96.97,63.23 91.93,63.23 90.52,61.82 83.5,61.82 80.07,65.25 79.19,65.25 78.67,65.76 77.86,65.76 76.69,66.93 60.44,66.93 60.26,67.11 55.81,67.11 52.43,63.73 49.82,63.73 48.26,62.17 45.96,62.17 43.84,60.05 43.84,58.6 42.72,57.48 42.72,54.26 38.76,50.31 38.76,49.39 37.96,48.58 37.96,45.71 33.89,41.65 32.57,41.65 32,42.22 31.46,42.22 v3(31.02,42.66)
  GND3 w0.102: v4(108.7,65.25) 109.04,64.91 v3(109.04,64.9) ; v4(30.62,42.7) 30.98,42.7 v3(31.02,42.66)
DDI2_PTX_TBRX_P3_C: length 2.6
  BOTTOM w0.076: 29.95,42.79 29.79,42.94 29.46,42.94 29.19,43.21 28.44,43.21 28.41,43.19 28.09,43.19 27.87,43.41 UT2.AB21
  BOTTOM w0.102: 29.95,42.79 CT33.1
DDR_A0_ZQ0: length 5
  TOP w0.095: UD42.B3 84.81,19.58 84.13,19.58 82.63,18.08 82.56,18.02 82.31,17.76 RD1.1 82.19,16.97 v2(82.33,16.83)
DDR_A0_ZQ1: length 3.9
  TOP w0.095: UD42.B4 84.86,21.23 84.47,21.23 v2(83.13,19.9) 82.91,19.67 RD3.1
DDR_A1_ZQ0: length 4.9
  TOP w0.095: 99.78,19.43 99.78,16.08 RD2.1
  TOP w0.112: UD41.B3 100.78,19.99 100.43,19.64 99.99,19.64 99.78,19.43
DDR_A1_ZQ1: length 6.5
  TOP w0.095: 99.54,20.68 99.54,17.22 99.12,16.8 RD4.1
  TOP w0.112: 99.54,20.68 99.59,20.73 100,21.14 100.46,21.14 UD41.B4
DDR_A_CA1_0: length 46.2
  TOP w0.152: UD42.R2 94.11,18.83 95.37,18.83 95.56,18.64 97.05,18.64 v8(97.76,17.93) 97.76,17.67 96.65,16.55 RD21.1
  IN1 w0.114: v9(107.34,39.01) 107.34,39 107.26,38.92 107.26,38.31 107.21,38.26 107.21,37.91 107.04,37.75 107.04,36.91 106.71,36.57 106.71,35.53 99.26,28.08 99.26,22.41 99.13,22.28 99.13,21.5 99.22,21.41 99.49,21.41 99.58,21.31 99.58,21.12 99.49,21.03 99.22,21.03 99.13,20.93 99.13,20.74 99.22,20.65 99.49,20.65 99.58,20.55 99.58,20.36 99.49,20.27 99.22,20.27 99.13,20.17 99.13,19.98 99.22,19.89 99.49,19.89 99.58,19.79 99.58,19.6 99.49,19.5 99.22,19.5 99.13,19.41 99.13,19.22 99.22,19.12 99.49,19.12 99.58,19.03 99.58,18.84 99.49,18.74 99.22,18.74 99.13,18.65 99.13,18.46 99.22,18.36 99.67,18.36 99.76,18.27 99.76,18.08 99.67,17.98 99.22,17.98 99.13,17.88 99.13,17.32 98.39,16.58 97.86,16.58 97.76,16.68 97.76,16.93 97.94,17.1 98.19,17.1 98.29,17.2 98.29,17.39 98.19,17.49 97.86,17.49 97.76,17.58 v8(97.76,17.93)
  GND1 w0.152: v3(107.69,39.25) 107.58,39.26 107.36,39.04 107.36,39.04 v9(107.34,39.01)
  GND3 w0.152: v4(108.05,39.26) 107.69,39.26 v3(107.69,39.25)
  BOTTOM w0.076: v4(108.05,39.26) 108.05,39.45 108.35,39.75 v2(108.35,40.54) 108.18,40.71 108.18,43.11 108.43,43.36 108.43,43.73 108.4,43.82 108.4,44.02 108.43,44.1 108.43,44.11 108.44,44.12 108.44,44.35 UCPU1.BA51
DDR_A_CA1_1: length 44.6
  TOP w0.152: UD42.P2 94.51,17.77 v8(95.35,17.77) 95.35,17.79 95.76,18.19 96.67,18.19 96.92,17.95 96.92,17.3 96.06,16.45 RD23.1
  IN1 w0.114: v9(106.57,38.25) 106.57,37.82 106.74,37.65 106.74,37.23 105.9,36.39 105.9,36.23 106.29,35.84 106.29,35.55 98.95,28.21 98.95,22.76 98.21,22.02 98.21,18.56 98.07,18.42 97.62,18.42 97.26,18.05 97.26,16.7 97.12,16.57 96.83,16.57 96.74,16.65 96.74,17.2 96.63,17.31 96.4,17.31 96.28,17.2 96.28,16.84 96.17,16.73 95.41,16.73 95.25,16.88 95.25,17.17 95.38,17.29 95.81,17.29 95.92,17.41 95.92,17.66 95.81,17.77 v8(95.35,17.77)
  GND1 w0.152: v3(106.86,38.57) 106.86,38.55 v9(106.57,38.25)
  GND3 w0.152: v4(106.5,38.56) 106.51,38.57 v3(106.86,38.57)
  BOTTOM w0.076: UCPU1.BB54 106.97,42.95 106.59,42.56 106.59,41.48 106.15,41.04 106.15,38.91 v4(106.5,38.56)
DDR_A_CA1_2: length 44.7
  TOP w0.152: UD42.N2 92.41,18.81 93.49,17.74 v8(93.49,17.66) 92.69,16.86 RD25.1
  IN1 w0.114: v8(93.49,17.66) 94.01,18.18 94.4,18.18 94.5,18.09 94.5,17.4 94.36,17.26 92.56,17.26 92.44,17.15 92.44,16.97 92.56,16.85 94.77,16.85 94.88,16.97 94.88,18.09 94.98,18.18 95.55,18.18 97.6,20.23 97.6,22.37 98.34,23.11 98.34,28.46 103.86,33.98 103.86,35.48 105.91,37.53 105.91,39.14 106.42,39.65 v9(106.52,39.65)
  GND1 w0.152: v9(106.52,39.65) 106.84,39.65 v3(106.86,39.67)
  GND3 w0.152: v3(106.86,39.67) 106.5,39.67 v4(106.49,39.67)
  BOTTOM w0.076: v4(106.49,39.67) 106.49,39.88 v2(106.7,40.09) 107.82,41.22 107.82,43.23 107.73,43.32 107.73,43.98 UCPU1.BA52
DDR_A_CA1_3: length 45.8
  TOP w0.076: UD42.N3 92.72,19.71 92.72,19.06
  TOP w0.152: RD27.1 95.48,16.35 96.47,17.34 v8(96.47,17.75) 95.99,17.75 95.46,17.22 94.56,17.22 92.72,19.06
  IN1 w0.114: v9(107.44,40.22) 107.37,40.15 107.37,39.63 107.01,39.27 106.93,39.27 106.22,38.56 106.22,37.35 105.36,36.49 105.36,36.13 105.82,35.66 105.82,35.54 105.7,35.42 105.52,35.42 105.09,35.86 104.95,35.86 104.82,35.72 104.82,35.59 105.26,35.14 105.26,35.01 105.15,34.9 104.96,34.9 104.55,35.32 104.41,35.32 104.28,35.18 104.28,35.05 104.75,34.58 104.75,34.43 98.65,28.34 98.65,22.98 97.91,22.24 97.91,20.01 97.57,19.67 97.57,19.32 97.71,19.18 97.71,19.04 97.58,18.91 97.44,18.91 97.14,19.21 97.01,19.21 96.87,19.07 96.87,18.94 97.17,18.64 97.17,18.5 97.04,18.37 96.91,18.37 96.64,18.63 96.48,18.63 96.3,18.45 96.3,17.92 v8(96.47,17.75)
  GND1 w0.152: v9(107.44,40.22) 107.44,40.27 v3(107.66,40.48)
  GND3 w0.152: v4(107.92,40.25) 107.68,40.48 v3(107.66,40.48)
  BOTTOM w0.076: v4(107.92,40.25) 108.01,40.34 108.01,43.19 108.27,43.44 108.27,43.7 108.23,43.79 108.23,44.09 108.27,44.18 108.28,44.19 108.28,44.51 108.1,44.69 UCPU1.AY52
DDR_A_CA1_4: length 45.4
  TOP w0.076: UD42.M3 92.09,19.7 92.09,18.75
  TOP w0.152: RD29.1 92.11,17.01 v8(92.78,17.67) 92.09,18.36 92.09,18.75
  IN1 w0.114: v9(106.56,40.74) 106.56,40.23 105.61,39.27 105.61,37.66 102.94,34.99 102.94,34.64 103.44,34.14 103.44,34 103.31,33.87 103.17,33.87 102.71,34.33 102.55,34.33 102.44,34.21 102.44,34.06 102.87,33.63 102.87,33.47 102.75,33.36 102.61,33.36 102.18,33.79 102.01,33.79 101.9,33.67 101.9,33.52 102.32,33.1 102.32,32.94 102.21,32.83 102.05,32.83 101.63,33.26 101.48,33.26 101.34,33.12 101.34,33 101.66,32.69 101.66,32.27 98.04,28.65 98.04,23.28 97.3,22.54 97.3,20.36 95.45,18.52 93.63,18.52 v8(92.78,17.67)
  GND1 w0.152: v3(106.82,40.96) 106.6,40.74 v9(106.56,40.74)
  GND3 w0.152: v4(106.56,40.72) 106.58,40.72 v3(106.82,40.96)
  BOTTOM w0.076: UCPU1.AW52 108.1,45.33 107.81,45.04 107.81,44.51 107.57,44.26 107.57,43.25 107.66,43.16 107.66,41.91 107.21,41.46 107.15,41.46 106.56,40.87 v4(106.56,40.72)
DDR_A_CA1_5: length 46
  TOP w0.076: v8(88.56,18.63) 88.56,18.63 88.18,19 88.18,19.71 UD42.F3
  TOP w0.152: RD31.1 86.48,16.54 v8(88.56,18.63)
  IN1 w0.114: v8(88.56,18.63) 88.9,18.28 91.5,18.28 92.96,19.74 94.96,19.74 96.09,20.87 96.09,23.1 96.77,23.78 96.77,29.21 97.48,29.93 97.48,30.28 97.61,30.42 97.75,30.42 97.82,30.34 97.94,30.34 98.12,30.52 98.12,30.64 97.72,31.03 97.72,31.17 97.86,31.3 97.99,31.3 98.35,30.95 98.48,30.95 98.61,31.08 98.61,31.22 98.26,31.57 98.26,31.7 98.4,31.84 98.53,31.84 98.83,31.54 98.97,31.54 99.1,31.67 99.1,31.81 98.8,32.11 98.8,32.57 103.67,37.44 103.67,40.12 104.08,40.53 104.45,40.53 104.66,40.75 104.66,41.26 v9(105.13,41.73)
  GND1 w0.152: v3(105.46,41.88) 105.28,41.88 v9(105.13,41.73)
  GND3 w0.152: v4(105.66,42.18) 105.66,42.08 v3(105.46,41.88)
  BOTTOM w0.076: UCPU1.AY55 106.56,44.87 106.56,44.44 106.53,44.35 106.53,44.21 106.57,44.07 106.57,44.07 106.6,43.96 106.6,43.87 106.24,42.73 106.24,42.72 106.24,42.45 105.97,42.18 v4(105.66,42.18)
DDR_A_CA1_6: length 46.5
  TOP w0.076: UD42.E3 86.88,19.69 86.88,18.99
  TOP w0.152: 86.65,18.62 86.88,18.85 86.88,18.99 ; RD33.1 85.32,16.63 v8(86.65,17.96)
  TOP w0.173: 86.65,18.62 v8(86.65,17.96)
  IN1 w0.114: v8(86.65,17.96) 87.2,17.41 91.86,17.41 93.32,18.87 95.38,18.87 96.38,19.86 96.38,19.88 96.95,20.45 96.95,22.63 97.73,23.41 97.73,28.81 101.02,32.1 101.02,33.5 105.3,37.78 105.3,39.4 106.25,40.35 106.25,41.14 v9(106.5,41.39)
  GND1 w0.152: v9(106.5,41.39) 106.65,41.54 v3(106.81,41.54)
  GND3 w0.152: v4(107.09,41.75) 107.08,41.74 106.98,41.74 106.81,41.57 v3(106.81,41.54)
  BOTTOM w0.076: v4(107.09,41.75) 107.49,42.16 107.49,43.05 107.4,43.14 107.4,44.28 107.18,44.51 107.18,45.02 106.87,45.32 UCPU1.AW54
DDR_A_CA1_7: length 44.2
  TOP w0.152: UD42.E2 87.23,19.2 v8(87.23,17.93) 85.9,16.61 RD35.1
  IN1 w0.114: v8(87.23,17.93) 87.47,17.7 91.74,17.7 93.2,19.16 95.2,19.16 96.66,20.62 96.66,22.77 97.42,23.52 97.42,28.92 100.19,31.7 100.19,31.98 100.29,32.08 100.51,32.08 100.6,32.17 100.6,32.36 100.51,32.46 100.29,32.46 100.2,32.55 100.2,32.78 100.29,32.87 100.58,32.87 100.7,33 100.7,33.61 105,37.91 105,39.52 105.95,40.47 105.95,41.81 106.66,42.52 v9(107.09,42.52)
  GND1 w0.152: v9(107.09,42.52) 107.33,42.52 v3(107.44,42.41)
  GND3 w0.152: v4(107.19,42.71) 107.44,42.46 v3(107.44,42.41)
  BOTTOM w0.076: v4(107.19,42.71) 107.24,42.75 107.24,43.77 106.97,44.03 UCPU1.BA54
DDR_A_CA1_8: length 45.5
  TOP w0.152: RD37.1 84.74,16.61 86.21,18.08 86.21,18.84 v8(86.22,18.84) 86.22,18.88 UD42.D2
  IN1 w0.114: v8(86.22,18.84) 86.92,18.84 87.26,19.18 91.15,19.18 91.42,19.45 92.25,19.45 92.84,20.03 94.84,20.03 95.8,20.99 95.8,23.24 96.38,23.82 96.38,23.82 96.46,23.9 96.46,29.53 96.72,29.8 96.82,29.8 96.92,29.89 96.92,30.08 96.82,30.18 96.24,30.18 96.15,30.26 96.15,30.46 96.28,30.59 97.04,30.59 97.25,30.79 97.25,31.45 102.96,37.17 102.96,37.6 103.36,38 103.36,41.66 103.86,42.16 104.33,42.16 104.98,42.81 105.77,42.81 v9(105.8,42.8)
  GND1 w0.152: v9(105.8,42.8) 105.87,42.8 v3(106.07,43)
  GND3 w0.152: v3(106.07,43) 106.07,42.78 v4(105.92,42.64)
  BOTTOM w0.076: v4(105.92,42.64) 105.95,42.66 105.95,44.21 UCPU1.BA55
DDR_A_CA1_9: length 44.9
  TOP w0.152: UD42.C2 85.64,18.95 85.64,18.41 v8(85.77,18.28) 84.15,16.66 RD39.1
  IN1 w0.114: v9(105.1,40.41) 104.69,40 104.69,38.04 99.51,32.85 99.51,32.24 99.6,32.14 99.7,32.14 99.8,32.05 99.8,31.86 99.7,31.76 99.6,31.76 99.51,31.66 99.51,31.48 97.08,29.05 97.08,23.65 97.05,23.63 97.05,23.62 96.38,22.95 96.38,22.3 96.38,20.75 95.08,19.45 93.08,19.45 91.62,17.99 88.58,17.99 88.25,18.32 87.48,18.32 87.42,18.37 85.87,18.37 v8(85.77,18.28)
  GND1 w0.152: v9(105.1,40.41) 105.24,40.55 v3(105.42,40.55)
  GND3 w0.152: v4(105.6,40.9) 105.42,40.72 v3(105.42,40.55)
  BOTTOM w0.076: UCPU1.AY54 106.73,44.75 106.73,44.41 106.7,44.32 106.7,44.23 106.77,43.99 106.77,43.84 106.42,42.76 106.42,41.74 v2(106.23,41.55) 105.6,40.92 v4(105.6,40.9)
DDR_A_CA2_0: length 43.4
  TOP w0.152: RD41.1 109.77,17.43 v8(109.77,17.84) 109.36,18.25 109.36,19.09 UD41.R2
  IN3 w0.095: v8(110.7,46.38) 110.7,45.5 109.62,44.42 109.62,31.9 112.45,29.07 112.45,23.36 112.35,23.26 111.64,23.26 111.55,23.17 111.55,22.98 111.64,22.88 112.35,22.88 112.45,22.79 112.45,22.6 112.35,22.5 111.44,22.5 111.34,22.41 111.34,22.22 111.44,22.12 112.35,22.12 112.45,22.03 112.45,21.84 112.35,21.74 111.49,21.74 111.39,21.64 111.39,21.45 111.49,21.36 112.35,21.36 112.45,21.26 112.45,20.96 111.2,19.71 110.91,19.71 110.65,19.98 110.51,19.98 110.38,19.84 110.38,19.71 110.79,19.3 110.79,19.16 110.65,19.03 110.52,19.03 110.2,19.35 110.06,19.35 109.93,19.21 109.93,19.08 110.1,18.9 110.1,18.45 109.77,18.12 v8(109.77,17.84)
  BOTTOM w0.152: UCPU1.AU46 110.8,46.38 v8(110.7,46.38)
DDR_A_CA2_1: length 40.8
  TOP w0.152: UD41.P2 108.93,18.88 108.93,18.06 v8(109.13,17.85) 109.13,17.76 107.74,16.36 RD43.1
  IN1 w0.114: v8(109.13,17.85) 109.59,18.31 110.21,18.31 112.18,20.27 112.18,29.63 111.94,29.87 111.94,30 112.22,30.29 112.22,30.42 112.09,30.56 111.95,30.56 111.67,30.27 111.53,30.27 111.4,30.41 111.4,30.54 111.73,30.88 111.73,31.01 111.6,31.15 111.46,31.15 111.13,30.81 110.99,30.81 110.86,30.95 110.86,31.08 111.15,31.38 111.15,31.51 111.02,31.65 110.89,31.65 110.67,31.44 110.54,31.44 110.32,31.66 110.32,31.88 110.41,31.98 110.64,31.98 110.73,32.07 110.73,32.26 110.64,32.36 110.45,32.36 110.35,32.45 110.35,32.64 110.45,32.74 110.64,32.74 110.73,32.83 110.73,33.03 110.64,33.12 110.35,33.12 110.25,33.22 110.25,33.41 110.35,33.5 110.64,33.5 110.73,33.6 110.73,33.79 110.64,33.88 110.43,33.88 110.22,34.09 110.22,39.15 109.98,39.39 109.98,44.42 109.49,44.92 109.49,45.51 109.77,45.79 v8(109.77,46.38)
  BOTTOM w0.152: UCPU1.AU48 109.88,46.38 v8(109.77,46.38)
DDR_A_CA2_2: length 40.8
  TOP w0.152: RD45.1 106.57,16.3 107.77,17.51 v8(107.77,18.34) 107.77,18.89 107.93,19.05 UD41.N2
  IN3 w0.095: v8(107.77,18.34) 107.77,18.92 107.96,19.11 108.89,19.11 109.01,19.23 109.01,19.44 108.91,19.54 107.84,19.54 107.74,19.64 107.74,19.9 107.84,20 108.64,20 108.77,20.12 108.77,20.64 108.28,21.14 108.28,22.07 108.66,22.46 110.31,22.46 112,24.15 112,29.09 109.33,31.76 109.33,45.56 109.65,45.88 110.14,45.88 110.29,46.02 110.29,46.6 v8(110.7,47.01)
  BOTTOM w0.152: v8(110.7,47.01) 110.78,47.01 UCPU1.AT46
DDR_A_CA2_3: length 41.3
  TOP w0.127: UD41.N3 108.25,19.7 108.25,18.71 v8(108.26,18.71)
  TOP w0.152: RD47.1 107.15,16.35 108.26,17.46 v8(108.26,18.71)
  IN1 w0.114: v8(108.26,18.71) 108.5,18.95 109.65,18.95 110.38,19.68 110.38,22.19 110.63,22.44 111.29,22.44 111.51,22.65 111.51,23.11 111.41,23.21 111.08,23.21 110.99,23.3 110.99,23.5 111.08,23.59 111.41,23.59 111.51,23.69 111.51,23.88 111.41,23.97 111.08,23.97 110.99,24.07 110.99,24.26 111.08,24.35 111.41,24.35 111.51,24.45 111.51,26.94 111.32,27.13 110.8,27.13 110.71,27.23 110.71,27.51 110.8,27.61 111.4,27.61 111.5,27.7 111.5,27.89 111.4,27.99 110.8,27.99 110.71,28.08 110.71,29.04 110.8,29.14 111.35,29.14 111.44,29.23 111.44,29.43 111.35,29.52 110.35,29.52 109.61,30.26 109.61,38.89 109.37,39.13 109.37,43.93 108.71,44.59 108.71,46.25 v8(108.84,46.38)
  BOTTOM w0.152: v8(108.84,46.38) 108.97,46.38 UCPU1.AU50
DDR_A_CA2_4: length 41.2
  TOP w0.076: v8(107.27,18.68) 107.61,19.03 107.61,19.7 UD41.M3
  TOP w0.152: RD49.1 105.98,16.26 107.27,17.55 v8(107.27,18.68)
  IN1 w0.114: v8(107.87,46.38) 108.17,46.08 108.17,44.28 109.07,43.38 109.07,39.01 109.31,38.77 109.31,30.11 109.72,29.7 109.72,28.94 109.62,28.85 109.36,28.85 109.26,28.75 109.26,28.56 109.36,28.47 109.62,28.47 109.72,28.37 109.72,28.18 109.62,28.09 109.18,28.09 109.08,27.99 109.08,27.8 109.18,27.71 109.62,27.71 109.72,27.61 109.72,27.39 110,27.11 110.43,27.11 110.63,26.91 110.63,22.89 110,22.26 110,21.04 109.79,20.83 109.39,20.83 109.07,20.52 109.07,19.83 108.93,19.69 108.52,19.69 108.42,19.6 108.42,19.3 108.33,19.21 108.14,19.21 108.04,19.3 108.04,19.6 107.95,19.69 107.76,19.69 107.66,19.6 107.66,19.3 107.56,19.21 107.37,19.21 107.28,19.3 107.28,19.6 107.18,19.69 106.96,19.69 106.75,19.48 106.75,18.96 107.02,18.68 v8(107.27,18.68)
  BOTTOM w0.152: v8(107.87,46.38) 108.06,46.38 UCPU1.AU52
DDR_A_CA2_5: length 41.3
  TOP w0.076: v8(103.71,19.63) 103.71,18.48 103.35,18.13
  TOP w0.152: RD51.1 103.06,17.84 103.35,18.13 ; v8(103.71,19.63) 103.71,19.7 UD41.F3
  IN1 w0.114: v9(107.91,38.45) 108.16,38.21 108.16,35.64 108.03,35.51 108.03,35.51 103.67,31.15 103.67,31.02 103.86,30.84 103.86,30.71 103.72,30.57 103.59,30.57 103.42,30.73 103.29,30.73 103.03,30.47 103.03,30.25 103.12,30.15 103.81,30.15 103.91,30.06 103.91,29.87 103.81,29.77 103.08,29.77 102.99,29.68 102.99,29.49 103.08,29.39 103.33,29.39 103.42,29.29 103.42,29.1 103.33,29.01 103.04,29.01 102.95,28.91 102.95,28.72 103.04,28.63 103.33,28.63 103.42,28.53 103.42,28.34 103.33,28.25 103.06,28.25 102.97,28.15 102.97,27.96 103.06,27.87 103.33,27.87 103.42,27.77 103.42,27.58 102.94,27.09 102.94,26.96 103.19,26.71 103.19,26.57 103.06,26.45 102.91,26.45 102.67,26.69 102.53,26.69 102.33,26.49 102.33,23.77 102.15,23.58 102.15,23.04 102.62,22.57 103.15,22.57 103.46,22.26 103.46,20.83 103.37,20.74 102.67,20.74 102.58,20.64 102.58,20.45 102.67,20.36 103.37,20.36 103.46,20.26 103.46,20.03 103.71,19.78 v8(103.71,19.63)
  GND1 w0.152: v9(107.91,38.45) 107.85,38.45 v3(107.65,38.66)
  GND3 w0.152: v3(107.65,38.66) 107.66,38.67 v4(108,38.67)
  BOTTOM w0.076: v4(108,38.67) v2(108.46,39.13) 109.07,39.74 109.07,43.19 108.9,43.37 108.9,43.73 108.94,43.85 108.95,43.87 108.95,43.94 108.89,44.17 108.89,44.35 108.93,44.47 108.93,44.99 UCPU1.AY51
DDR_A_CA2_6: length 43.8
  TOP w0.076: v8(103.06,19.63) 103.06,19.05 102.73,18.73 102.73,18.43
  TOP w0.152: v8(103.06,19.63) 103.06,19.7 UD41.E3 ; 102.73,18.43 102.63,18.33 102.63,17.32 102.48,17.16 RD53.1
  IN1 w0.114: v8(109.77,47.01) 109.29,46.53 109.29,46.13 109.17,46.01 109.17,44.8 109.68,44.29 109.68,39.26 109.92,39.02 109.92,31.41 111.81,29.51 111.81,20.46 110.01,18.65 108.91,18.65 107.74,17.48 105.87,17.48 104.21,19.15 103.54,19.15 v8(103.06,19.63)
  BOTTOM w0.152: v8(109.77,47.01) 109.87,47.01 UCPU1.AT48
DDR_A_CA2_7: length 40.3
  TOP w0.152: UD41.E2 102.27,18.76 v8(102.27,18.67) 102.17,18.57 102.17,17.6 101.89,17.32 RD55.1
  IN3 w0.095: v8(102.27,18.67) 102.27,19.81 103.75,21.29 103.75,22.1 104.57,22.92 110.09,22.92 110.61,23.45 110.61,29.9 109.05,31.46 109.05,44 108.38,44.67 108.38,46.52 v8(108.84,46.98)
  BOTTOM w0.152: UCPU1.AT50 108.92,46.98 v8(108.84,46.98)
DDR_A_CA2_8: length 41.1
  TOP w0.152: v8(101.76,19.63) 101.76,19.55 UD41.D2 101.83,18.97 101.83,18.04 101.31,17.52 RD57.1
  IN1 w0.114: v8(101.76,19.63) 100.78,18.65 100.34,18.65 100.05,18.94 100.05,19.37 100.15,19.46 100.55,19.46 100.65,19.56 100.65,19.75 100.55,19.84 100.15,19.84 100.05,19.94 100.05,21.01 100.15,21.1 100.75,21.1 100.85,21 100.85,20.45 100.95,20.35 101.16,20.35 101.28,20.47 101.28,21.39 101.19,21.48 100.15,21.48 100.05,21.58 100.05,22.44 99.68,22.81 99.68,24.39 100.06,24.77 100.06,26.12 99.94,26.25 99.94,27.8 100.5,28.36 100.64,28.36 100.94,28.06 101.07,28.06 101.21,28.2 101.21,28.33 100.91,28.63 100.91,28.77 102.16,30.02 102.16,30.5 102.3,30.64 102.3,30.65 107.47,35.81 v9(107.47,35.99)
  GND1 w0.152: v9(107.47,35.99) 107.46,36 v3(107.46,36.4)
  GND3 w0.152: v4(107.82,36.37) 107.48,36.37 v3(107.46,36.4)
  BOTTOM w0.076: v4(107.82,36.37) v2(108.4,36.96) 109.4,37.95 109.4,43.52 UCPU1.BB50
DDR_A_CA2_9: length 38.3
  TOP w0.152: UD41.C2 101.31,19.1 v8(101.31,18.58) 101.31,18.19 100.73,17.61 RD59.1
  IN1 w0.114: v8(101.31,18.58) 101.54,18.58 102.27,19.32 102.27,22.3 102.01,22.56 100.7,22.56 100.6,22.66 100.6,23.84 100.73,23.96 101.09,23.96 101.23,24.1 101.23,25.41 101.14,25.51 100.73,25.51 100.47,25.76 100.47,27.06 100.75,27.34 102.4,27.34 102.61,27.54 102.61,30.52 107.86,35.77 107.86,37.3 v9(107.81,37.35)
  GND1 w0.152: v9(107.81,37.35) 107.6,37.56 v3(107.5,37.56)
  GND3 w0.152: v3(107.5,37.56) 107.89,37.56 v4(107.9,37.55)
  BOTTOM w0.076: v4(107.9,37.55) 107.94,37.55 109.24,38.85 109.24,43.26 109.06,43.44 109.06,43.67 109.12,43.79 109.12,43.96 109.05,44.19 109.05,44.27 109.09,44.39 109.09,44.66 UCPU1.AY50
DDR_A_CKE0: length 54.6
  TOP w0.076: v8(90.79,19.63) 90.79,18.9 90.9,18.79 90.9,18.63
  TOP w0.152: RD65.1 91.53,16.86 90.9,17.49 90.9,18.63 ; v8(90.79,19.63) 90.79,19.7 UD42.K3
  IN1 w0.114: v8(90.79,19.63) 91.02,19.86 92.09,19.86 93.56,21.33 93.56,22.17 94.61,23.22 94.86,23.22 95.11,23.48 95.11,24.67 96.07,25.63 96.07,28.18 95.68,28.57 94.65,28.57 94.55,28.67 94.55,28.86 94.65,28.95 95.48,28.95 95.58,29.05 95.58,29.24 95.48,29.33 94.65,29.33 94.55,29.43 94.55,29.62 94.65,29.72 95.68,29.72 95.77,29.81 95.77,30 95.68,30.1 94.65,30.1 94.55,30.19 94.55,30.38 94.65,30.48 95.54,30.48 95.72,30.65 95.72,30.89 95.23,31.38 95.23,31.51 95.36,31.65 95.5,31.65 96.1,31.04 96.24,31.04 96.37,31.17 96.37,31.31 95.76,31.92 95.76,32.05 95.9,32.19 96.03,32.19 96.64,31.58 96.78,31.58 96.91,31.71 96.91,31.85 96.3,32.46 96.3,32.59 96.44,32.73 96.57,32.73 97.18,32.12 97.32,32.12 97.45,32.25 97.45,32.39 96.84,33 96.84,33.13 96.98,33.27 97.11,33.27 97.72,32.66 97.86,32.66 97.99,32.79 97.99,32.93 97.38,33.54 97.38,33.67 97.52,33.81 97.65,33.81 98.26,33.2 98.4,33.2 98.55,33.35 98.55,33.49 97.98,34.06 97.98,34.19 98.12,34.33 98.25,34.33 98.53,34.05 98.82,34.05 102.94,38.18 102.94,41.84 103.69,42.58 104.16,42.58 104.8,43.23 105.47,43.23 105.58,43.34 105.58,44.17 v9(105.5,44.26)
  GND1 w0.152: v9(105.5,44.26) 105.44,44.26 v3(105.23,44.47)
  GND3 w0.152: v3(105.23,44.47) 105.24,44.46 105.43,44.46 v4(105.65,44.24)
DDR_A_CKE1: length 57.9
  TOP w0.152: UD42.K4 90.79,21.15 v8(90.79,21.23) ; RD67.1 88.29,16.03 v8(88.29,16.71)
  IN1 w0.114: v9(104.8,43.61) 104.05,43.61 102.53,42.08 102.53,38.2 99.09,34.75 98.01,34.75 97.19,33.93 97.05,33.93 96.48,34.51 96.34,34.51 96.21,34.38 96.21,34.24 96.78,33.66 96.78,33.53 96.65,33.4 96.51,33.4 95.94,33.97 95.78,33.97 95.66,33.85 95.66,33.72 96.24,33.13 96.24,32.99 96.11,32.86 95.98,32.86 95.4,33.43 95.22,33.43 95.13,33.34 95.13,33.16 95.71,32.59 95.71,32.45 95.57,32.32 95.41,32.32 94.86,32.87 94.73,32.87 94.59,32.73 94.59,32.6 95.15,32.04 95.15,31.9 95.03,31.78 94.9,31.78 94.45,32.23 94.18,32.23 93.98,32.03 93.98,31.9 94.64,31.24 94.64,31.11 94.51,30.97 94.37,30.97 93.72,31.63 93.58,31.63 93.45,31.49 93.45,31.36 93.94,30.87 93.94,30.73 93.8,30.6 93.67,30.6 93.18,31.09 93.04,31.09 92.39,30.44 92.39,30.25 92.49,30.16 94.03,30.16 94.12,30.06 94.12,29.87 94.03,29.77 92.49,29.77 92.39,29.68 92.39,29.49 92.49,29.39 94.03,29.39 94.12,29.3 94.12,28.2 94.22,28.1 95.11,28.1 95.2,28 95.2,25.93 94.76,25.48 94.5,25.48 92.97,23.95 92.97,23.17 93.19,22.94 93.19,21.89 93.16,21.86 93.16,21.86 92.94,21.63 92.26,21.63 92.25,21.63 91.19,21.63 v8(90.79,21.23)
  GND1 w0.152: v3(105.15,43.61) 104.8,43.61 v9(104.8,43.61)
  GND3 w0.152: v3(105.15,43.61) 105.17,43.59 v4(105.65,43.59)
  BOTTOM w0.152: v8(90.79,21.23) 90.79,21.13 89.68,20.03 88.65,20.03 88.13,19.5 88.13,17.44 88.29,17.28 v8(88.29,16.71)
DDR_A_CKE2: length 56.5
  TOP w0.076: 106.43,17.55 106.43,18.45 106.31,18.57 v8(106.31,19.63)
  TOP w0.152: v8(106.31,19.63) 106.31,19.7 UD41.K3 ; RD69.1 105.4,16.52 106.43,17.55
  IN1 w0.114: v8(106.31,19.63) 106.7,20.02 108.43,20.02 108.66,20.26 108.66,20.72 108.4,20.99 108.4,21.16 108.3,21.25 108.11,21.25 108.02,21.35 108.02,21.54 108.11,21.63 108.3,21.63 108.4,21.73 108.4,21.92 108.3,22.02 108.11,22.02 108.02,22.11 108.02,22.3 108.11,22.4 108.3,22.4 108.4,22.49 108.4,22.71 108.47,22.79 109.75,22.79 109.84,22.89 109.84,23.13 109.75,23.22 107.74,23.22 107.58,23.07 107.58,22.6 107.46,22.49 107.27,22.49 107.15,22.6 107.15,23.22 107.03,23.34 107.03,24.15 107.13,24.25 109.72,24.25 109.82,24.34 109.82,24.53 109.72,24.63 107.13,24.63 107.03,24.72 107.03,27.18 106.73,27.49 106.73,29.93 106.83,30.03 107.56,30.03 107.66,29.93 107.66,27.52 108.07,27.11 108.07,26.57 108.19,26.44 108.38,26.44 108.47,26.54 108.47,27.29 108.01,27.74 108.01,29.92 108.11,30.01 108.36,30.01 108.45,29.92 108.45,29.8 108.56,29.7 108.75,29.7 108.89,29.83 108.89,38.59 108.65,38.83 108.65,40.46 108.19,40.91 108.19,43.33 v9(106.35,45.17)
  GND1 w0.152: v3(105.98,45.28) 106.24,45.28 v9(106.35,45.17)
  GND3 w0.152: v3(105.98,45.28) 105.41,45.28 v4(105.36,45.24)
  BOTTOM w0.076: UCPU1.AW56 v4(105.36,45.24)
DDR_A_CKE3: length 56.9
  TOP w0.102: UD41.K4 105.58,20.43 105.26,20.43 105,20.17 105,19.05 104.89,18.94
  TOP w0.152: 104.89,18.94 104.88,18.93 104.88,17.72 103.65,16.49 RD71.1 ; UD41.K4 106.33,21.17 v8(106.33,21.24)
  IN1 w0.114: v8(106.33,21.24) 106.9,21.81 106.9,23.06 106.74,23.22 106.74,24.2 106.64,24.29 106.38,24.29 106.29,24.39 106.29,24.58 106.38,24.67 106.64,24.67 106.74,24.77 106.74,24.96 106.64,25.05 106.38,25.05 106.29,25.15 106.29,25.34 106.38,25.43 106.64,25.43 106.74,25.53 106.74,27.03 106.5,27.27 106.12,27.27 105.92,27.07 105.79,27.07 105.66,27.2 105.66,27.34 105.97,27.65 106.27,27.65 106.39,27.77 106.39,27.98 106.29,28.07 106.14,28.07 106.03,28.18 106.03,28.37 106.13,28.47 106.32,28.47 106.41,28.56 106.41,28.75 106.32,28.85 105.95,28.85 105.86,28.94 105.86,29.13 105.95,29.23 106.32,29.23 106.41,29.32 106.41,29.49 106.32,29.58 105.7,29.58 105.61,29.67 105.61,29.88 105.7,29.97 106.29,29.97 106.41,30.09 106.41,30.28 106.32,30.37 105.72,30.37 105.62,30.47 105.62,32.29 105.73,32.39 105.94,32.39 106.06,32.27 106.06,30.85 106.16,30.75 106.32,30.75 106.47,30.9 106.47,31.08 106.58,31.19 106.74,31.19 107.53,30.41 107.69,30.41 107.81,30.53 107.81,30.67 106.9,31.57 106.9,31.73 107.02,31.86 107.16,31.86 108.31,30.71 108.44,30.71 108.56,30.83 108.56,30.99 106.44,33.12 106.44,33.28 106.56,33.4 106.69,33.4 108.15,31.95 108.28,31.95 108.42,32.08 108.42,32.22 108.05,32.58 108.05,32.58 107.03,33.6 107.03,33.83 107.19,33.99 107.33,33.99 108.07,33.24 108.21,33.24 108.34,33.38 108.34,33.51 107.55,34.3 107.55,34.43 107.69,34.57 107.82,34.57 108.03,34.37 108.16,34.37 108.58,34.79 108.58,38.47 108.34,38.71 108.34,40.32 107.93,40.73 107.93,40.74 107.89,40.78 107.89,42.8 v9(106.42,44.27)
  GND1 w0.152: v3(106.26,44.64) 106.42,44.47 v9(106.42,44.27)
  GND3 w0.152: v4(105.97,44.82) 106.04,44.82 106.22,44.64 v3(106.26,44.64)
  BOTTOM w0.076: v4(105.97,44.82) 105.72,44.82 UCPU1.AY56
DDR_A_CLK0: length 55.3
  TOP w0.076: v8(89.49,19.62) 89.49,19.14 89.52,19.1 89.52,18.28 89.3,18.05 89.24,18.05 89.23,18.03
  TOP w0.14: v8(89.49,19.62) 89.49,19.7 UD42.J3 ; RD75.1 87.24,16.16 87.24,16.66 88.25,17.67 88.86,17.67 89.23,18.03
  IN1 w0.076: v8(107.01,47.08) 106.84,46.91 106.65,46.91 106.47,46.74 106.47,46.14 106.22,45.89 105.73,45.89 105.7,45.92 105.68,45.92
  IN1 w0.114: v8(89.49,19.62) 89.68,19.81 89.68,20.07 90.03,20.42 90.03,22.37 90.31,22.65 90.31,23.93 90.69,24.31 90.69,30.02 91.21,30.54 91.21,30.69 90.05,31.85 90.05,32.24 90.36,32.56 90.75,32.56 91.91,31.4 92.07,31.4 92.65,31.98 92.65,32.14 91.72,33.06 91.72,33.41 92.1,33.79 92.45,33.79 93.37,32.87 93.53,32.87 93.78,33.11 93.78,33.27 92.9,34.14 92.9,34.5 93.28,34.87 93.63,34.87 94.51,34 94.67,34 94.91,34.24 94.91,34.4 94.2,35.11 94.2,35.46 94.58,35.84 94.93,35.84 95.64,35.13 95.8,35.13 98.01,37.34 100.76,37.34 101.37,37.95 101.37,42.91 104.38,45.92 105.68,45.92
  BOTTOM w0.14: v8(107.01,47.08) 107.19,47.08 UCPU1.AT53
DDR_A_CLK1: length 51.5
  TOP w0.076: v8(105.66,19.63) 105.66,18.83 105.71,18.78 105.71,18.48 105.54,18.31 105.54,17.39 105.34,17.19 105.34,17.14 105.33,17.13
  TOP w0.14: v8(105.66,19.63) 105.66,19.7 UD41.J3 ; RD79.1 104.63,16.17 104.63,16.43 105.33,17.13
  IN2 w0.076: 106.55,44.89 106.35,45.09 106.35,45.49 106.08,45.76 105.8,45.76 105.5,46.06 105.5,46.46 105.67,46.64 105.85,46.64 106.05,46.84 v8(106.05,47.03)
  IN2 w0.108: 106.55,44.89 106.64,44.8 106.64,44.12 107.4,43.37 107.4,42.99 107.96,42.43 107.96,40.81 108.27,40.5 108.27,34.29 111.46,31.1 111.46,29.7 112.08,29.08 112.08,28.73 112.08,24.84 111.97,24.74 111.57,24.74 111.33,24.49 111.33,23.98 111.57,23.74 111.97,23.74 112.08,23.63 112.08,20.23 111.97,20.12 111.58,20.12 111.47,20.23 111.47,22.79 111.16,23.11 110.45,23.11 110.2,22.86 110.2,18.6 110.1,18.5 109.65,18.5 109.54,18.61 109.54,18.94 109.29,19.18 108.81,19.18 108.2,19.79 107.21,19.79 106.57,19.16 105.81,19.16 105.66,19.31 v8(105.66,19.63)
  BOTTOM w0.14: UCPU1.AT55 106.22,47.03 v8(106.05,47.03)
DDR_A_CLK#0: length 54.9
  TOP w0.076: 89.4,17.86 89.41,17.88 89.41,17.93 89.69,18.21 89.69,19.1 UD42.J2
  TOP w0.14: v8(90.12,19.62) 90.12,19.53 UD42.J2 ; RD77.1 87.48,16.16 87.48,16.55 88.35,17.43 88.96,17.43 89.4,17.86
  IN1 w0.076: v8(107.04,46.34) 107.08,46.38 107.08,46.64 106.99,46.72 106.86,46.72 106.85,46.74 106.71,46.74 106.64,46.67 106.64,46.07 106.29,45.73 105.73,45.73 105.7,45.7 105.68,45.7
  IN1 w0.114: v8(90.12,19.62) 90.05,19.62 89.91,19.77 89.91,19.97 90.26,20.33 90.26,22.28 90.54,22.56 90.54,23.84 90.92,24.22 90.92,29.93 91.44,30.44 91.44,30.79 90.28,31.95 90.28,32.15 90.46,32.33 90.66,32.33 91.82,31.17 92.16,31.17 92.88,31.88 92.88,32.23 91.95,33.16 91.95,33.32 92.19,33.56 92.35,33.56 93.28,32.64 93.63,32.64 94.01,33.01 94.01,33.36 93.13,34.24 93.13,34.4 93.38,34.64 93.54,34.64 94.41,33.77 94.76,33.77 95.14,34.15 95.14,34.5 94.43,35.21 94.43,35.37 94.67,35.61 94.83,35.61 95.54,34.9 95.89,34.9 98.11,37.12 100.86,37.12 101.6,37.85 101.6,42.81 104.48,45.7 105.68,45.7
  BOTTOM w0.14: UCPU1.AU53 107.1,46.34 v8(107.04,46.34)
DDR_A_CLK#1: length 50.5
  TOP w0.076: v8(105.36,18.63) 105.37,18.61 105.37,17.46 105.22,17.31 105.17,17.31 105.16,17.3
  TOP w0.14: RD81.1 104.38,16.14 104.38,16.53 105.16,17.3 ; UD41.J2 105.33,18.66 v8(105.36,18.63)
  IN2 w0.076: 106.71,45.05 106.7,45.06 106.63,45.06 106.62,45.07 106.6,45.07 106.51,45.16 106.51,45.56 106.15,45.92 105.87,45.92 105.66,46.13 105.66,46.39 105.74,46.47 106,46.47 v8(106.09,46.38)
  IN2 w0.108: 106.71,45.05 106.87,44.89 106.87,44.22 107.63,43.46 107.63,43.09 108.19,42.52 108.19,40.91 108.5,40.6 108.5,34.38 111.69,31.19 111.69,29.8 112.31,29.17 112.31,28.73 112.31,24.75 112.07,24.51 111.67,24.51 111.56,24.4 111.56,24.08 111.67,23.97 112.07,23.97 112.31,23.73 112.31,20.14 112.07,19.9 111.49,19.9 111.24,20.14 111.24,22.7 111.06,22.88 110.55,22.88 110.43,22.76 110.43,18.5 110.19,18.27 109.56,18.27 109.31,18.52 109.31,18.84 109.2,18.96 108.71,18.96 108.1,19.56 107.3,19.56 106.67,18.93 105.66,18.93 v8(105.36,18.63)
  BOTTOM w0.14: v8(106.09,46.38) 106.22,46.38 UCPU1.AU55
DDR_A_CS#0: length 68.4
  TOP w0.152: UD42.L3 91.44,20.35 v8(91.44,20.43) ; RD61.1 97.23,16.49 98.22,17.48 v2(98.22,17.55) 98.22,18.2 v8(98.65,18.62) ; UD41.L3 106.96,20.35 v8(106.96,20.43)
  IN2 w0.095: v8(106.96,20.43) 106.56,20.83 105.76,20.83 105.49,20.56 103.3,20.56 102.76,20.02 100.4,20.02 99,18.62 v8(98.65,18.62) 98.11,19.16 98.11,19.59 97.77,19.93 95.85,19.93 95.73,20.04 95.73,20.54 95.62,20.66 95.39,20.66 95.27,20.54 95.27,20.04 95.16,19.93 91.93,19.93 v8(91.44,20.43)
  IN3 w0.095: v8(98.65,18.62) 100.09,18.62 101.76,16.96 110.23,16.96 110.84,17.58 110.84,18.2 113.31,20.67 113.31,29.22 110.31,32.22 110.31,44.06 111.57,45.32 111.57,46.26 v8(111.66,46.35)
  BOTTOM w0.152: UCPU1.AU45 111.68,46.35 v8(111.66,46.35)
DDR_A_CS#1: length 69.7
  TOP w0.152: UD42.L4 90.79,20.5 v8(90.79,20.43) ; UD41.L4 106.29,20.49 v8(106.29,20.41) ; v8(98.65,17.99) 98.65,17.42 97.8,16.57 RD63.1
  IN2 w0.095: v8(90.79,20.43) 92.46,18.75 97.56,18.75 98.32,17.99 v8(98.65,17.99) 99.32,17.99 100.56,19.23 104.36,19.23 104.64,19.51 104.64,19.89 104.87,20.11 105.48,20.11 105.78,20.41 v8(106.29,20.41)
  IN3 w0.095: v8(112.5,46.38) 111.85,45.73 111.85,44.99 110.59,43.73 110.59,32.36 113.69,29.26 113.69,20.53 111.25,18.09 111.25,17.36 110.4,16.52 100.12,16.52 99.86,16.78 99.86,16.91 100.18,17.23 100.18,17.37 100.05,17.5 99.91,17.5 99.59,17.18 99.46,17.18 99.32,17.32 99.32,17.45 99.69,17.82 99.69,17.96 99.56,18.09 99.42,18.09 99.05,17.72 98.92,17.72 v8(98.65,17.99)
  BOTTOM w0.152: UCPU1.AU43 112.62,46.38 v8(112.5,46.38)
DDR_A_D0: length 41.2
  TOP w0.152: UD42.C8 85.59,23.7 v8(85.59,23.63)
  IN3 w0.095: v8(85.59,23.63) 84.73,23.63 84,24.36 83.56,24.36 81.98,25.94 81.98,28.73 83.13,29.87 83.13,33.4 83.96,34.23 83.96,44.91 90.39,51.34 94.86,51.34 v3(95.55,50.65)
  GND3 w0.152: v4(95.59,50.3) 95.59,50.61 v3(95.55,50.65)
  BOTTOM w0.076: v4(95.59,50.3) 95.71,50.42 UCPU1.AL71
DDR_A_D1: length 43
  TOP w0.152: UD42.B11 84.94,26.75 v8(84.94,26.83)
  IN3 w0.095: v8(84.94,26.83) 84.53,27.24 84.53,27.83 85.15,28.45 85.15,29.48 85.59,29.92 85.59,36.18 86.75,37.35 87.93,37.35 88.03,37.44 88.03,37.63 87.93,37.73 86.75,37.73 86.65,37.82 86.65,38.01 86.75,38.11 87.93,38.11 88.03,38.2 88.03,38.39 87.93,38.49 86.75,38.49 86.65,38.58 86.65,38.77 86.75,38.87 87.7,38.87 87.8,38.96 87.8,39.16 87.7,39.25 86.75,39.25 86.65,39.35 86.65,40.04 85.59,41.1 85.59,44.15 88.93,47.49 90.91,47.49 92.17,48.75 92.92,48.75 v3(93.05,48.88)
  GND3 w0.152: v4(93.39,48.88) 93.05,48.88 v3(93.05,48.88)
  BOTTOM w0.076: v4(93.39,48.88) 93.45,48.95 94.37,48.95 94.93,49.51 95.7,49.51 95.93,49.28 96.3,49.28 96.54,49.52 97.1,49.52 97.25,49.46 97.51,49.53 97.7,49.53 97.83,49.49 98.69,49.49 98.88,49.68 UCPU1.AL68
DDR_A_D2: length 43.8
  TOP w0.152: UD42.C9 86.24,24.5 v8(86.24,24.43)
  IN3 w0.095: v3(93.74,47.05) 93.13,46.44 93.13,45.97 93.04,45.88 92.73,45.88 92.64,45.78 92.64,45.59 92.73,45.5 93.09,45.5 93.18,45.4 93.18,45.21 93.09,45.12 92.73,45.12 92.64,45.02 92.64,44.83 92.73,44.74 93.04,44.74 93.13,44.64 93.13,44.45 93.04,44.35 92.73,44.35 92.64,44.26 92.64,44.07 92.73,43.97 93.04,43.97 93.13,43.88 93.13,43.69 93.04,43.59 92.73,43.59 92.64,43.5 92.64,43.31 92.73,43.21 93.04,43.21 93.13,43.12 93.13,42.93 93.04,42.83 92.73,42.83 92.64,42.74 92.64,42.55 92.73,42.45 93.04,42.45 93.13,42.35 93.13,42.16 93.04,42.07 92.73,42.07 92.64,41.97 92.64,41.78 92.73,41.69 93.04,41.69 93.13,41.59 93.13,41.29 91.47,39.63 91.47,37.72 90.74,36.99 90.74,35.97 90.07,35.3 90.07,35.17 90.54,34.71 90.54,34.57 90.4,34.44 90.27,34.44 89.81,34.9 89.67,34.9 89.54,34.77 89.54,34.63 90,34.17 90,34.03 89.86,33.9 89.73,33.9 89.27,34.36 89.13,34.36 89,34.23 89,34.09 89.46,33.63 89.46,33.49 89.32,33.36 89.19,33.36 88.73,33.82 88.59,33.82 88.46,33.69 88.46,33.55 88.92,33.09 88.92,32.96 88.78,32.82 88.65,32.82 88.19,33.28 88.05,33.28 87.83,33.06 87.83,28.7 88.28,28.25 88.28,27.49 87.47,26.68 87.47,26.68 87.13,26.34 87.13,25.74 87.3,25.57 87.3,24.94 87.19,24.83 86.64,24.83 v8(86.24,24.43)
  GND3 w0.152: v3(93.74,47.05) 93.85,47.16 v4(94.07,47.16)
  BOTTOM w0.076: UCPU1.AN68 98.73,49.19 98.41,48.88 97.86,48.88 97.8,48.83 97.46,48.83 97.29,48.66 96.67,48.66 96.63,48.62 95.72,48.62 95.52,48.41 95.2,48.41 94.44,47.65 94.44,47.45 94.15,47.16 v4(94.07,47.16)
DDR_A_D3: length 43.5
  TOP w0.152: UD42.B10 84.94,25.95 v8(84.94,26.03)
  IN3 w0.095: v3(93.07,48.34) 92.95,48.47 92.29,48.47 91.73,47.91 91.73,41.1 90.62,39.98 90.62,39.3 90.46,39.14 90.32,39.14 89.85,39.62 89.71,39.62 89.58,39.48 89.58,39.35 90.05,38.87 90.05,38.74 89.92,38.6 89.78,38.6 88.98,39.41 88.84,39.41 88.71,39.27 88.71,39.14 89.51,38.33 89.51,38.2 89.38,38.06 89.24,38.06 88.59,38.72 88.46,38.72 88.32,38.58 88.32,38.45 88.97,37.79 88.97,37.66 87.9,36.59 87.77,36.59 87.35,37.01 87.21,37.01 87.08,36.88 87.08,36.74 87.5,36.32 87.5,36.18 87.37,36.05 87.23,36.05 86.64,36.64 86.51,36.64 86.37,36.5 86.37,36.37 86.96,35.78 86.96,35.65 86.83,35.51 86.69,35.51 86.18,36.02 86.04,36.02 85.91,35.89 85.91,35.75 86.42,35.24 86.42,35.11 85.87,34.56 85.87,29.8 85.43,29.36 85.43,26.52 v8(84.94,26.03)
  GND3 w0.152: v4(93.46,48.35) 93.45,48.34 v3(93.07,48.34)
  BOTTOM w0.076: UCPU1.AN69 98.17,49.26 97.83,49.26 97.76,49.33 97.66,49.37 97.53,49.37 97.23,49.28 97.04,49.36 96.67,49.36 96.43,49.11 95.83,49.11 95.6,49.34 95.01,49.34 v2(94.24,48.58) 94.01,48.35 v4(93.46,48.35)
DDR_A_D4: length 42.7
  TOP w0.152: v8(85.59,24.43) 85.59,24.5 UD42.B9
  IN3 w0.095: v8(85.59,24.43) 85.18,24.02 84.77,24.02 84.12,24.66 83.68,24.66 82.28,26.06 82.28,28.62 83.42,29.75 83.42,32.24 83.51,32.34 84.16,32.34 84.26,32.43 84.26,32.62 84.16,32.72 83.51,32.72 83.42,32.82 83.42,33.18 84.25,34.02 84.25,44.8 90.59,51.14 94.4,51.14 v3(94.91,50.63)
  GND3 w0.152: v4(94.83,50.29) 94.83,50.55 v3(94.91,50.63)
  BOTTOM w0.076: v4(94.83,50.29) 95.13,50.6 96.43,50.6 96.51,50.68 97.03,50.68 97.09,50.66 97.17,50.65 97.24,50.64 97.36,50.6 97.54,50.42 UCPU1.AL70
DDR_A_D5: length 42.7
  TOP w0.152: v8(84.94,24.43) 84.94,24.35 UD42.B8
  IN3 w0.095: v3(94.13,50.48) 93.67,50.94 90.81,50.94 84.55,44.67 84.55,31.97 84.45,31.88 83.8,31.88 83.7,31.78 83.7,31.59 83.8,31.5 84.45,31.5 84.55,31.4 84.55,31.21 84.45,31.12 83.8,31.12 83.7,31.02 83.7,30.83 83.8,30.74 84.45,30.74 84.55,30.64 84.55,30.36 82.58,28.4 82.58,26.19 83.81,24.96 84.4,24.96 v8(84.94,24.43)
  GND3 w0.152: v4(94.47,50.43) 94.41,50.48 v3(94.13,50.48)
  BOTTOM w0.076: v4(94.47,50.43) 94.8,50.76 96.36,50.76 96.46,50.86 97,50.86 97.07,50.84 97.13,50.82 97.2,50.81 97.28,50.8 97.41,50.76 97.41,50.76 97.6,50.68 97.76,50.68 98.03,50.42 UCPU1.AL69
DDR_A_D6: length 41.7
  TOP w0.152: UD42.C11 86.24,26.75 v8(86.24,26.83)
  IN3 w0.095: v3(93.65,47.59) 93.06,47.59 92.35,46.88 92.35,40.91 91.19,39.75 91.19,37.84 89.99,36.64 89.99,36.5 90.32,36.17 90.32,36.03 90.19,35.9 90.05,35.9 89.72,36.23 89.58,36.23 89.45,36.1 89.45,35.96 89.78,35.63 89.78,35.5 89.65,35.36 89.51,35.36 89.18,35.69 89.04,35.69 88.91,35.56 88.91,35.43 89.24,35.09 89.24,34.96 89.11,34.82 88.97,34.82 88.64,35.16 88.51,35.16 88.37,35.02 88.37,34.89 88.7,34.55 88.7,34.42 88.57,34.28 88.44,34.28 88.1,34.62 87.97,34.62 87.83,34.48 87.83,34.35 88.17,34.01 88.17,33.88 88.03,33.74 87.9,33.74 87.56,34.08 87.43,34.08 87.29,33.94 87.29,33.81 87.63,33.47 87.63,33.34 87.49,33.2 87.36,33.2 87.02,33.54 86.89,33.54 86.69,33.34 86.69,32.92 86.79,32.83 87.45,32.83 87.55,32.73 87.55,32.54 87.45,32.45 86.79,32.45 86.69,32.35 86.69,32.16 86.79,32.07 87.45,32.07 87.55,31.97 87.55,31.78 87.45,31.69 86.79,31.69 86.69,31.59 86.69,31.4 86.79,31.31 87.45,31.31 87.55,31.21 87.55,31.02 87.45,30.92 86.79,30.92 86.69,30.83 86.69,30.64 86.79,30.54 87.37,30.54 87.47,30.45 87.47,30.26 87.37,30.16 86.79,30.16 86.69,30.07 86.69,27.28 v8(86.24,26.83)
  GND3 w0.152: v3(93.65,47.59) 93.9,47.84 v4(93.9,47.87)
  BOTTOM w0.076: v4(93.9,47.87) 93.98,47.95 94.48,47.95 94.97,48.43 94.97,48.43 95.11,48.57 95.43,48.57 95.64,48.78 96.56,48.78 96.6,48.82 97.22,48.82 97.49,49.09 UCPU1.AN70
DDR_A_D7: length 40.6
  TOP w0.152: v8(85.59,26.03) 85.59,25.95 UD42.C10
  IN3 w0.095: v3(94.59,48.52) 94.07,48.52 93.49,47.95 92.98,47.95 92.06,47.03 92.06,46.76 92.06,46.76 92.06,41.03 90.9,39.86 90.9,38.95 90.79,38.84 90.56,38.84 90.29,38.57 90.29,38.44 90.77,37.96 90.77,37.82 90.63,37.69 90.5,37.69 90.02,38.17 89.89,38.17 89.75,38.03 89.75,37.9 90.23,37.42 90.23,37.29 90.09,37.15 89.96,37.15 89.48,37.63 89.35,37.63 89.21,37.49 89.21,37.36 89.69,36.88 89.69,36.75 89.55,36.61 89.42,36.61 88.94,37.09 88.81,37.09 88.67,36.95 88.67,36.82 89.15,36.34 89.15,36.21 89.01,36.07 88.88,36.07 88.4,36.55 88.27,36.55 88.13,36.41 88.13,36.28 88.61,35.8 88.61,35.67 88.47,35.53 88.34,35.53 87.86,36.01 87.73,36.01 87.59,35.87 87.59,35.74 88.07,35.26 88.07,35.13 87.94,34.99 87.8,34.99 87.32,35.47 87.19,35.47 87.06,35.34 87.06,35.2 87.53,34.73 87.53,34.59 87.4,34.46 87.26,34.46 86.79,34.93 86.65,34.93 86.39,34.67 86.39,27.58 85.76,26.96 85.76,26.2 v8(85.59,26.03)
  GND3 w0.152: v4(94.85,48.74) 94.63,48.52 v3(94.59,48.52)
  BOTTOM w0.076: v4(94.85,48.74) 95.3,48.74 95.51,48.95 96.49,48.95 96.64,49.09 UCPU1.AN71
DDR_A_D8: length 29.4
  TOP w0.152: v8(94.04,26.03) 94.04,25.95 UD42.R10
  IN2 w0.095: v8(94.7,46.79) 94.02,46.79 93.81,46.58 93.17,46.58 91.71,45.12 91.71,41.52 90.59,40.4 90.59,31.58 92.34,29.83 92.34,27.32 93.05,26.6 93.46,26.6 v8(94.04,26.03)
  BOTTOM w0.076: UCPU1.AR70 97.41,48.06 97.16,48.32 96.8,48.32 96.77,48.29 95.91,48.29 95.69,48.07 95.37,48.07 94.81,47.5 94.81,46.9 v8(94.7,46.79)
DDR_A_D9: length 29.6
  TOP w0.152: v8(94.04,26.83) 94.04,26.75 UD42.R11
  IN2 w0.095: v8(94.04,26.83) 93.73,27.13 93.16,27.13 92.64,27.65 92.64,29.96 90.95,31.66 90.95,40.32 92.01,41.39 92.01,44.8 92.79,45.58 93.29,45.58 v8(93.66,45.95)
  BOTTOM w0.076: v8(93.66,45.95) 93.66,46.34 94.62,47.31 94.62,47.56 95.31,48.24 95.6,48.24 95.81,48.45 96.7,48.45 96.74,48.49 97.6,48.49 97.83,48.27 98.39,48.27 98.69,47.96 UCPU1.AR68
DDR_A_D10: length 29.2
  TOP w0.152: UD42.R9 94.03,24.5 v8(94.03,24.42)
  IN2 w0.095: v8(93.94,42.55) 93.94,38.76 93.4,38.22 93.4,37.4 94.31,36.49 94.31,31.87 97.09,29.1 97.09,25.09 96.46,24.47 95.91,24.47 95.84,24.53 95.77,24.53 95.47,24.83 94.44,24.83 v8(94.03,24.42)
  BOTTOM w0.076: UCPU1.AU71 96.73,46.74 96.63,46.63 96.12,46.63 96.09,46.61 95.65,46.17 95.65,45.28 95.1,44.72 95.1,44.47 94.67,44.04 94.67,43.3 93.94,42.58 v8(93.94,42.55)
DDR_A_D11: length 29.6
  TOP w0.152: v8(94.69,26.03) 94.69,25.95 UD42.T10
  IN2 w0.095: v8(94.77,45.58) 94.64,45.44 94.16,45.44 93.68,44.96 93.5,44.96 92.66,44.11 92.66,41.16 91.61,40.11 91.61,31.88 95.19,28.3 95.19,26.53 v8(94.69,26.03)
  BOTTOM w0.076: UCPU1.AU68 98.88,47.51 98.66,47.73 98.42,47.73 98.37,47.68 97.81,47.68 97.67,47.62 97.54,47.62 97.3,47.69 97.21,47.69 97.17,47.68 96.92,47.58 96.73,47.49 96.45,47.37 96.09,47.37 95.02,46.3 95.02,45.74 94.86,45.58 v8(94.77,45.58)
DDR_A_D12: length 26.8
  TOP w0.152: UD42.T11 94.69,26.75 v8(94.69,26.83)
  IN2 w0.095: v8(95.19,47.16) 95.19,46.47 94.7,45.99 94.54,45.99 94.29,45.74 94.04,45.74 93.56,45.26 93.15,45.26 92.32,44.44 92.32,41.26 91.3,40.25 91.3,31.76 94.12,28.94 94.12,27.39 v8(94.69,26.83)
  BOTTOM w0.076: UCPU1.AR71 96.87,48.12 95.99,48.12 95.76,47.89 95.43,47.89 95.2,47.66 95.2,47.18 v8(95.19,47.16)
DDR_A_D13: length 32.2
  TOP w0.152: v8(94.04,23.63) 94.04,23.7 UD42.R8
  IN2 w0.095: v8(96.22,47.77) 96.22,46.54 95.53,45.84 95.53,32.69 98.21,30.01 98.21,27.41 98.21,24.65 96.64,23.07 94.59,23.07 v8(94.04,23.63)
  BOTTOM w0.076: UCPU1.AR69 98.09,47.96 97.97,47.84 97.77,47.84 97.66,47.8 97.65,47.79 97.55,47.79 97.32,47.86 97.18,47.86 96.91,47.77 v8(96.22,47.77)
DDR_A_D14: length 28.5
  TOP w0.152: UD42.T9 94.69,24.49 v8(94.69,24.41)
  IN2 w0.095: v8(95.06,43.82) 94.61,43.36 94.61,41.27 94.92,40.96 94.92,31.7 97.39,29.23 97.39,24.97 96.56,24.14 95.83,24.14 95.66,24.31 94.8,24.31 v8(94.69,24.41)
  BOTTOM w0.076: v8(95.06,43.82) 95.29,44.05 95.29,44.65 95.82,45.17 95.82,46.1 96.16,46.44 97.25,46.44 97.54,46.74 UCPU1.AU70
DDR_A_D15: length 29.5
  TOP w0.152: v8(94.69,23.63) 94.69,23.7 UD42.T8
  IN2 w0.095: v8(94.69,23.63) 94.94,23.37 95.96,23.37 96.42,23.83 96.69,23.83 97.78,24.93 97.78,29.47 95.22,32.03 95.22,42.04 95.07,42.19 v8(95.07,42.49)
  BOTTOM w0.076: UCPU1.AU69 97.89,46.39 97.43,46.39 97.31,46.27 96.23,46.27 95.98,46.03 95.98,45.1 95.53,44.65 95.53,42.95 v8(95.07,42.49)
DDR_A_D16: length 41.6
  TOP w0.152: v8(92.1,24.42) 92.1,24.52 UD42.N9
  IN3 w0.095: v8(101.13,52.35) 100.41,53.07 98.98,53.07 96.99,51.09 96.99,47.53 95.84,46.37 95.84,45.31 94.65,44.13 94.65,41.84 92.16,39.34 92.16,37.43 91.43,36.71 91.43,34.48 89.62,32.67 89.62,32.53 90.05,32.11 90.05,31.98 89.91,31.84 89.78,31.84 89.35,32.27 89.22,32.27 89.08,32.13 89.08,32 89.48,31.6 89.48,31.46 89.35,31.33 89.21,31.33 88.81,31.73 88.68,31.73 88.52,31.57 88.52,29.31 89.03,28.8 89.03,26.41 89.68,25.76 89.68,25.1 90.36,24.42 v8(92.1,24.42)
  BOTTOM w0.152: v8(101.13,52.35) 101.13,52.47 UCPU1.AF65
DDR_A_D17: length 40.5
  TOP w0.152: v8(91.55,23.54) 91.55,23.81 UD42.M8
  IN3 w0.095: v8(91.55,23.54) 91.01,24.09 90.24,24.09 89.35,24.98 89.35,25.46 88.71,26.09 88.71,28.48 88.24,28.96 88.24,31.69 91.14,34.6 91.14,36.82 91.87,37.55 91.87,39.46 94.35,41.94 94.35,44.33 95.48,45.46 95.48,46.43 96.71,47.65 96.71,51.23 98.85,53.37 100.74,53.37 v8(101.77,52.34)
  BOTTOM w0.152: UCPU1.AF64 101.77,52.48 v8(101.77,52.34)
DDR_A_D18: length 40.9
  TOP w0.076: UD42.N11 92.75,26.76 92.75,28.02 v8(93.07,28.35)
  IN3 w0.076: 100.77,45.57 100.98,45.78 100.98,50.14 101.18,50.34 v8(101.18,50.55)
  IN3 w0.095: 100.77,45.57 100.17,44.97 100.17,42.87 99.79,42.49 99.49,42.49 99.33,42.32 98.43,42.32 95.66,39.56 95.66,34.27 95.76,34.17 96.39,34.17 96.48,34.07 96.48,33.85 96.39,33.76 95.74,33.76 95.65,33.66 95.65,33.47 95.74,33.38 96.39,33.38 96.48,33.28 96.48,33.09 96.39,33 95.72,33 95.62,32.9 95.62,32.71 95.72,32.61 96.39,32.61 96.48,32.52 96.48,32.33 96.39,32.23 95.69,32.23 95.59,32.14 95.59,31.95 95.69,31.85 96.39,31.85 96.48,31.76 96.48,31.57 96.39,31.47 95.69,31.47 95.59,31.38 95.59,31.19 95.69,31.09 96.39,31.09 96.48,30.99 96.48,30.8 96.39,30.71 95.26,30.71 95.16,30.61 95.16,30.42 95.26,30.33 96.39,30.33 96.48,30.23 96.48,29.93 96.38,29.83 95.86,29.83 95.6,29.57 95.6,28.46 95.21,28.07 94.32,28.07 94.22,28.17 94.22,28.4 93.89,28.73 93.46,28.73 v8(93.07,28.35)
  BOTTOM w0.152: UCPU1.AK65 101.18,50.59 v8(101.18,50.55)
DDR_A_D19: length 41.5
  TOP w0.152: v8(92.74,25.21) 92.74,25.3 UD42.N10
  IN3 w0.076: v8(101.79,50.5) 101.79,50.42 101.15,49.79 101.15,45.53 101.02,45.4
  IN3 w0.095: 101.02,45.4 100.65,45.03 100.65,42.93 99.87,42.15 99.58,42.15 99.42,42 98.51,42 95.95,39.44 95.95,39.15 96.05,39.06 96.67,39.06 96.77,38.96 96.77,38.77 96.67,38.68 96.05,38.68 95.95,38.58 95.95,37.61 96.05,37.51 96.67,37.51 96.77,37.42 96.77,37.23 96.67,37.13 96.05,37.13 95.95,37.03 95.95,36.84 96.05,36.75 96.67,36.75 96.77,36.65 96.77,36.46 96.67,36.37 96.05,36.37 95.95,36.27 95.95,36.08 96.05,35.99 96.67,35.99 96.77,35.89 96.77,35.7 96.67,35.61 96.05,35.61 95.95,35.51 95.95,35.32 96.05,35.22 96.67,35.22 96.77,35.13 96.77,34.94 96.67,34.84 96.05,34.84 95.95,34.75 95.95,34.56 96.05,34.46 96.67,34.46 96.77,34.37 96.77,26.45 95.53,25.21 95.13,25.21 95.04,25.31 95.04,25.49 94.94,25.58 94.75,25.58 94.66,25.49 94.66,25.31 94.56,25.21 94.37,25.21 94.28,25.31 94.28,25.4 94.1,25.58 93.11,25.58 v8(92.74,25.21)
  BOTTOM w0.152: UCPU1.AK64 101.79,50.63 v8(101.79,50.5)
DDR_A_D20: length 41.1
  TOP w0.152: UD42.M9 91.42,25.17 v8(91.42,25.22)
  IN3 w0.095: v8(91.42,25.22) 91.4,25.23 90.8,25.23 89.94,26.09 89.94,26.95 89.4,27.5 89.4,30.12 89.3,30.22 88.9,30.22 88.81,30.32 88.81,30.51 88.9,30.6 89.3,30.6 89.4,30.7 89.4,30.92 90.21,31.73 90.39,31.73 90.46,31.66 90.59,31.66 90.75,31.81 90.75,31.95 90.11,32.59 90.11,32.72 90.24,32.86 90.38,32.86 91.08,32.15 91.22,32.15 91.35,32.29 91.35,32.42 90.65,33.13 90.65,33.26 90.78,33.4 90.92,33.4 91.37,32.95 91.5,32.95 91.71,33.16 91.71,33.47 91.62,33.56 91.35,33.56 91.25,33.66 91.25,33.85 91.35,33.94 91.62,33.94 91.71,34.04 91.71,36.59 92.44,37.32 92.44,39.12 96.12,42.8 96.12,45.03 97.28,46.19 97.28,50.95 99.09,52.76 100.08,52.76 v8(100.49,52.35)
  BOTTOM w0.152: v8(100.49,52.35) 100.49,52.46 UCPU1.AF66
DDR_A_D21: length 40.5
  TOP w0.152: v8(92.73,24.43) 92.73,24.49 UD42.P9
  IN3 w0.095: v8(99.85,52.35) 99.2,52.35 97.57,50.72 97.57,46.07 97.02,45.52 97.02,43.23 92.73,38.94 92.73,37.2 92,36.47 92,32.51 91.32,31.82 91.32,31.69 91.74,31.26 91.74,31.13 91.61,30.99 91.47,30.99 90.97,31.49 90.84,31.49 90.7,31.36 90.7,31.22 91.28,30.65 91.28,30.51 91.14,30.38 91.01,30.38 90.25,31.13 90.12,31.13 89.98,31 89.98,30.86 90.69,30.16 90.69,30.03 90.55,29.89 90.42,29.89 89.98,30.33 89.84,30.33 89.69,30.18 89.69,30.04 90.32,29.41 90.32,26.31 91,25.64 91.57,25.64 92.27,24.94 92.27,24.89 v8(92.73,24.43)
  BOTTOM w0.152: v8(99.85,52.35) 99.85,52.45 UCPU1.AF67
DDR_A_D22: length 39.3
  TOP w0.152: UD42.M11 92.09,26.75 v8(92.09,26.83)
  IN3 w0.095: v8(92.09,26.83) 92.27,27.01 92.27,28.89 92.52,29.14 92.52,29.28 92.14,29.66 92.14,29.8 92.27,29.93 92.41,29.93 92.84,29.5 92.98,29.5 93.11,29.63 93.11,29.77 92.65,30.23 92.65,30.36 92.79,30.5 92.92,30.5 93.41,30.01 93.54,30.01 93.68,30.14 93.68,30.28 93.09,30.87 93.09,31 93.22,31.14 93.36,31.14 93.91,30.59 94.04,30.59 94.18,30.72 94.18,30.86 93.91,31.13 93.91,31.26 94.04,31.4 94.18,31.4 94.41,31.16 94.54,31.16 94.72,31.34 94.72,31.66 94.62,31.76 93.28,31.76 93.18,31.86 93.18,32.05 93.28,32.14 94.62,32.14 94.72,32.24 94.72,32.43 94.62,32.52 93.28,32.52 93.18,32.62 93.18,32.81 93.28,32.9 94.62,32.9 94.72,33 94.72,39.46 98.26,43 98.26,44.38 99.13,45.24 99.13,49.94 99.73,50.55 v8(99.88,50.55)
  BOTTOM w0.152: v8(99.88,50.55) 99.88,50.59 UCPU1.AK67
DDR_A_D23: length 40
  TOP w0.152: v8(92.08,26.02) 92.08,25.94 UD42.M10
  IN3 w0.095: v8(92.08,26.02) 92.57,26.51 92.57,26.85 92.67,26.94 93.41,26.94 93.51,27.04 93.51,27.24 93.42,27.32 92.67,27.32 92.57,27.42 92.57,28.45 93.62,29.5 93.75,29.5 94.53,28.72 94.66,28.72 94.8,28.85 94.8,28.99 94.02,29.77 94.02,29.9 94.15,30.04 94.29,30.04 95.03,29.3 95.17,29.3 95.3,29.43 95.3,29.56 94.56,30.31 94.56,30.44 95.04,30.92 95.04,31.37 95.13,31.47 95.28,31.47 95.38,31.57 95.38,31.76 95.28,31.85 95.13,31.85 95.04,31.95 95.04,32.14 95.13,32.23 95.28,32.23 95.38,32.33 95.38,32.52 95.28,32.61 95.13,32.61 95.04,32.71 95.04,32.9 95.13,32.99 95.28,32.99 95.38,33.09 95.38,33.28 95.28,33.37 95.13,33.37 95.04,33.47 95.04,33.66 95.13,33.76 95.28,33.76 95.38,33.85 95.38,34.04 95.28,34.14 95.13,34.14 95.04,34.23 95.04,34.42 95.13,34.52 95.28,34.52 95.38,34.61 95.38,34.8 95.28,34.9 95.13,34.9 95.04,34.99 95.04,35.18 95.13,35.28 95.28,35.28 95.38,35.38 95.38,35.57 95.28,35.66 95.13,35.66 95.04,35.76 95.04,35.95 95.13,36.04 95.28,36.04 95.38,36.14 95.38,36.33 95.28,36.42 95.13,36.42 95.04,36.52 95.04,36.71 95.13,36.8 95.28,36.8 95.38,36.9 95.38,37.09 95.28,37.18 95.13,37.18 95.04,37.28 95.04,37.47 95.13,37.57 95.28,37.57 95.38,37.66 95.38,37.85 95.28,37.95 95.13,37.95 95.04,38.04 95.04,38.23 95.13,38.33 95.28,38.33 95.38,38.42 95.38,38.61 95.28,38.71 95.13,38.71 95.04,38.8 95.04,39.37 99.49,43.83 99.49,44.89 100.14,45.54 100.14,50.18 v8(100.52,50.55)
  BOTTOM w0.152: UCPU1.AK66 100.52,50.6 v8(100.52,50.55)
