# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_RCIN#: length 9.3
  BOTTOM w0.076: UCPU1.AW13 130.24,45.36 129.97,45.08 129.97,44.63 129.79,44.46 129.79,44.11 129.83,44.07 129.83,43.77 129.8,43.74 129.8,42.57 130.45,41.93 130.59,41.93
  BOTTOM w0.095: RC21.2 133.31,40.41 133.31,41.59 133.12,41.78 132.68,41.78 132.58,41.68 131.93,41.68 v2(131.68,41.93) 131.67,41.93 130.59,41.93
SIO_SLP_A#: length 220.9
  TOP w0.095: v7(16.56,20.61) 16.56,20.03 16.3,19.77 16.3,19.22 UE3.M11 ; v7(142.72,36.1) 142.72,36.36 143.48,37.13 144.23,37.13 144.73,37.62 147.31,37.62 147.6,37.91 152.4,37.91 153.15,38.65 156.85,38.65 157.3,39.11 v2(158.49,39.11) 158.7,39.11 162.15,35.65 162.15,30.95 161.41,30.21 JAPS1.6
  IN1 w0.076: v8(128.05,48.94) 128.56,48.43 128.56,46.91 130.08,45.4 132.59,45.4 134.28,43.72 135.01,43.72 137.43,41.29 137.43,40.24 139.82,37.85 139.82,37.22 140.88,36.17 142.65,36.17 v7(142.72,36.1) 142.72,35.7 150.15,28.27 150.15,22.71 147.82,20.37 147.37,20.37 143.45,16.45 137.31,16.45 136.73,15.87 133.07,15.87 132.84,16.1 132.84,16.48 132.31,17.01 126.98,17.01 126.01,17.98 123.28,17.98 122.87,18.38 113.57,18.38 112.37,17.19 109.26,17.19 108.79,16.72 99.21,16.72 98.68,16.18 97.37,16.18 96.76,15.57 85.46,15.57 84.89,16.14 80.96,16.14 76.38,11.57 74.3,11.57 72.6,9.86 69.77,9.86 69.56,10.07 66.8,10.07 65.3,11.57 61.07,11.57 60.52,12.12 55.11,12.12 50.38,16.85 48.39,16.85 47.83,16.29 43.86,16.29 42.12,18.03 38.05,18.03 36.93,19.14 36.93,19.4 33.73,22.6 31.15,22.6 30.92,22.38 29.57,22.38 29.41,22.54 29.41,23.82 29.11,24.13 28.61,24.13 28.39,24.35 24.9,24.35 23.72,23.17 20.33,23.17 19.69,22.52 18.71,22.52 18.22,22.03 17.53,22.03 17.27,21.77 17.27,21.51 16.56,20.8 16.56,20.61 v7(16.56,20.61)
  BOTTOM w0.112: v8(128.05,48.94) 128.07,48.94 128.44,49.31 UCPU1.AN16
SIO_SLP_S0#: length 128.6
  TOP w0.095: v7(143.45,36.5) 143.8,36.85 144.28,36.85 144.83,37.4 147.4,37.4 147.69,37.68 152.49,37.68 153.24,38.43 156.25,38.43 159.97,34.71 v1(160.57,34.71) ; v1(162.16,14.37) 161.9,14.37 v2(157.07,19.19) 155.29,20.98 155.29,26.01 153.68,27.62 153.02,27.62 152.64,28 151.12,28 v7(151,27.89)
  IN1 w0.076: v7(151,27.89) 151,28.05 143.56,35.49 143.56,36.4 v7(143.45,36.5) 143.3,36.66 140.97,36.66 140.35,37.28 140.35,37.9 137.84,40.41 137.84,41.46 135.18,44.12 134.45,44.12 132.76,45.81 131.76,45.81 131.34,46.23 131.34,46.58 v8(130.89,47.04)
  GND1 w0.095: v1(160.57,34.71) 160.66,34.71 160.95,35.01 161.3,35.01 v3(161.4,35.11) ; v1(162.16,14.37) 162.16,14.32 162.01,14.17 v3(162.01,13.96)
  GND3 w0.095: v3(162.01,13.96) 162.16,14.12 162.58,14.12 v4(162.89,14.43) ; v6(162.3,35.96) 162.25,35.96 v3(161.4,35.11)
  IN4 w0.076: v6(162.3,35.96) 162.3,38.1 163.14,38.95 165.01,38.95 165.75,39.68 165.75,46.26 165.15,46.86 165.15,48.84 v5(165.01,48.99) 164.91,49.08 164.91,49.97 165.16,50.22 165.16,52.45 164.74,52.86 164.74,57.44 161.87,60.32 161.87,64.49 160.2,66.16 158.67,66.16 v5(158.53,66.02) ; v5(168.37,11.49) 168.37,11.7 168.05,12.02 166.35,12.02 v5(166.32,12.06)
  BOTTOM w0.095: PR1400.1 163.37,50.8 163.37,50 164.39,48.99 v5(165.01,48.99) ; v4(162.89,14.43) 162.9,14.42 162.9,12.02 163.34,11.57 UC4.1 164.56,11.57 165.04,12.06 v5(166.32,12.06) 166.32,13.43 166.16,13.6 RE104.1 ; RE2.1 170.12,9.74 v5(168.37,11.49)
  BOTTOM w0.112: UCPU1.AT11 131.21,47.36 v8(130.89,47.04)
SIO_SLP_S3#: length 286.7
  TOP w0.095: UE3.K9 18.7,17.61 18.71,17.61 v8(18.71,17.66) ; UC8.1 9.68,26.23 9.8,26.36 v1(10.08,26.36) ; v1(153.7,29.14) v2(156.02,29.14) 158.1,29.14 159.03,28.21 JAPS1.2 ; UC5.1 7.24,22.55 6.83,22.14 6.83,21.15 6.03,20.35 v8(5.86,20.35)
  IN1 w0.076: v8(5.31,18.85) 5.31,15.27 5.78,14.8 9.16,14.8 9.59,15.23 13.38,15.23 15.68,17.53 18.58,17.53 v8(18.71,17.66)
  GND1 w0.095: v3(153.35,29.04) 153.45,29.14 v1(153.7,29.14) ; v1(10.08,26.36) 10.52,26.36 v3(10.52,26.36)
  IN2 w0.064: v3(153.35,29.04) 153.14,29.04 152.44,29.74 152.44,30.26 148.05,34.65 148.05,36.53 147.62,36.97 145.58,36.97 143.96,35.35 v3(143.4,35.35)
  IN3 w0.064: v8(18.71,17.66) 18.28,18.09 17.45,18.09 14.9,20.65 14.9,20.71 13.42,22.18 13.38,22.18 12.42,23.14 12.42,24.46 v3(10.52,26.36) 9.56,27.32 9.56,30.06 10.09,30.6 10.09,34.51 10.7,35.12 10.7,36.24 11.29,36.83 11.29,39.97 11.69,40.37 11.69,43.42 12.88,44.61 12.88,46.85 13.6,47.57 13.6,50.66 15,52.06 15,53.01 15.64,53.66 18.84,53.66 21.4,56.22 v3(21.4,57.22)
  GND3 w0.095: v3(143.4,35.35) 143.34,35.35 143.29,35.4 v4(143,35.4) ; v3(10.52,26.36) 10.77,26.36 v4(11.03,26.1) ; v4(21.4,57.63) v3(21.4,57.22)
  IN4 w0.076: v5(38.82,21.92) 38.82,21.9 39.17,21.55 39.2,21.55 39.64,21.11 39.64,20.52 38.89,19.77 38.89,18.51 38.81,18.42 38.81,16.05 40.24,14.62 48.29,14.62 49.01,13.91 52.9,13.91 53.7,13.11 61.83,13.11 62.22,12.72 65.61,12.72 65.99,12.34 65.99,11.79 66.48,11.31 67.66,11.31 67.77,11.2 72.19,11.2 75.11,14.12 76,14.12 76.32,14.43 78.7,14.43 81.51,17.24 81.51,23.68 81.83,24 81.83,28.67 84.76,31.61 102.6,31.61 103.21,32.22 105.23,32.22 106.24,31.21 131.02,31.21 133.9,34.09 133.9,37.79 v5(134.21,38.1) 134.12,38.19 134.12,38.66 133.95,38.82 133.95,40.01 134.69,40.75 134.69,41.05 134.4,41.34 134.4,43.21 132.55,45.06 130.54,45.06 129.93,45.67 128.78,45.67 128.53,45.92 128.53,46.07 128.56,46.11 128.56,48.05 128.8,48.28 v8(128.96,48.28) ; v8(4.03,26.32) 4.48,25.86 4.48,21.98 v5(3.99,21.49)
  BOTTOM w0.095: v8(5.31,18.85) 5.12,19.04 RE191.1 ; U16.1 6.82,21.15 6.02,20.35 v8(5.86,20.35) 5.81,20.4 RE191.1 ; v5(3.99,21.49) 3.99,21.11 4.09,21.02 5.02,21.02 5.12,20.92 RE191.1 ; v8(4.03,26.32) 3.88,26.18 UE6.2 ; v8(18.71,17.66) 19.22,18.17 19.22,18.74 19.87,19.4 22.59,19.4 23.68,20.49 24.57,20.49 25.82,21.74 29.12,21.74 30.26,22.88 34.43,22.88 35.31,22 38.73,22 v5(38.82,21.92) ; v5(134.21,38.1) 134.79,37.52 140.84,37.52 142.96,35.4 v4(143,35.4)
  BOTTOM w0.112: v8(128.96,48.28) 129.34,48.66 UCPU1.AP15
SIO_SLP_S4#: length 203.7
  TOP w0.095: v1(153.73,30.24) v2(154.37,30.24) 159.41,30.24 159.93,29.71 JAPS1.5 ; v1(15.92,20.56) 15.9,20.54 UE3.N12
  IN1 w0.076: v8(78.49,20.78) 79.29,19.99 79.29,15.05 76.22,11.98 74.14,11.98 72.45,10.3 70.02,10.3 69.8,10.51 66.95,10.51 65.8,11.67 65.8,12.44 65.58,12.66 62.44,12.66 62.31,12.53 55.36,12.53 50.56,17.33 43.58,17.33 42.42,18.49 38.16,18.49 37.55,19.1 37.55,19.36 33.77,23.14 30.38,23.14 29.19,24.33 28.69,24.33 28.47,24.55 24.06,24.55 23.7,24.2 22.95,24.2 22.13,23.37 20.25,23.37 19.72,22.84 18.71,22.84 18.13,22.27 17.45,22.27 17.07,21.89 17.07,21.6 16.03,20.56 v1(15.92,20.56)
  GND1 w0.095: v3(153.34,30.14) 153.44,30.24 v1(153.73,30.24) ; v1(15.92,20.56) 15.68,20.56 v3(15.59,20.47)
  GND1 w0.102: v3(9.92,27.49) 9.97,27.54 9.97,28.06 v1(9.92,28.11)
  IN2 w0.064: v3(153.34,30.14) 153.21,30.14 148.45,34.89 148.45,36.79 147.89,37.35 145.39,37.35 144.59,36.55 142.87,36.55 142.52,36.89 142.52,37.43 140.28,39.67 134.93,39.67 133.54,41.05 v3(133.22,41.05)
  IN3 w0.064: v3(9.92,27.49) 10.69,26.71 11.29,26.71 12.67,25.33 12.67,23.15 13.16,22.66 13.39,22.66 v3(15.59,20.47)
  GND3 w0.095: v4(132.87,41.04) 133.21,41.04 v3(133.22,41.05)
  IN4 w0.076: v8(78.49,20.78) 78.54,20.84 78.54,23.58 80.54,25.58 80.54,29.46 81,29.92 81,30.22 83.82,33.05 102.02,33.05 102.62,33.65 105.98,33.65 106.27,33.36 130.46,33.36 131.97,34.87 131.97,40.14 v4(132.87,41.04)
  BOTTOM w0.076: v4(132.87,41.04) 132.85,41.04 132.66,40.85 131.66,40.85 131.26,41.25 130.34,41.25 129.7,41.89 129.1,41.89 128.74,42.25 128.74,42.5 128.43,42.81 128.43,44.53 UCPU1.BA16
SIO_SLP_S5#: length 193.1
  TOP w0.095: v7(18.95,20.16) 18.95,20.1 19.1,19.95 UE3.N8 ; JAPS1.4 v2(158.95,29.21) 158.47,29.68 v1(153.69,29.68)
  IN1 w0.076: v7(18.95,20.16) 19.27,20.16 19.95,20.84 27.03,20.84 27.36,20.51 v9(29.01,20.51)
  GND1 w0.095: v9(29.01,20.51) 29.24,20.75 29.35,20.75 29.45,20.84 v3(29.45,20.9) ; v3(153.34,29.59) 153.6,29.59 v1(153.69,29.68)
  IN2 w0.064: v8(78.95,22.35) 79.46,21.84 79.46,13.37 76.74,10.66 75.43,10.66 74.97,10.2 71.29,10.2 70.58,9.49 60.36,9.49 59.29,10.56 57.56,10.56 57.16,10.96 55.19,10.96 52.61,13.54 45.16,13.54 42.42,16.29 39.7,16.29 36.01,19.97 36.01,22.06 34.95,23.13 32.35,23.13 31.86,22.63 29.25,22.63 29.11,22.49 29.1,22.49 28.9,22.29 28.9,21.27 29.27,20.9 v3(29.45,20.9) ; v3(153.34,29.59) 153.18,29.59 152.63,30.14 152.63,30.34 148.24,34.73 148.24,36.72 147.81,37.16 145.51,37.16 144.7,36.35 142.76,36.35 142.29,36.82 142.29,37.37 140.2,39.46 134.87,39.46 133.81,40.52 v3(133.23,40.52)
  GND3 w0.095: v4(132.86,40.58) 132.92,40.52 v3(133.23,40.52)
  IN4 w0.076: v4(132.86,40.58) 132.17,39.88 132.17,34.71 130.62,33.15 106.18,33.15 105.89,33.44 102.71,33.44 102.11,32.84 83.91,32.84 81.2,30.14 81.2,29.83 80.77,29.4 80.77,25.48 78.95,23.67 v8(78.95,22.35)
  BOTTOM w0.076: v4(132.86,40.58) 131.66,40.58 131.14,41.09 130.27,41.09 129.63,41.73 128.94,41.73 128.58,42.09 128.58,42.43 128.27,42.74 128.27,43.94 128.11,44.09 128.11,44.76 128.39,45.04 UCPU1.AY16
SIO_SLP_SUS#: length 312.6
  TOP w0.095: v7(26.14,23.34) 26.14,23.37 27.21,24.43 29.47,24.43 29.92,24.89 32.09,24.89 32.56,25.36 v1(32.56,26.16) ; R91.1 152.3,22.64 152.17,22.64 v7(151.8,23.01) ; v1(131.2,8.53) 131.2,8.89 131.33,9.02 131.33,11.81 132.37,12.85 138.49,12.85 139.36,13.72 144.53,13.72 145.34,12.91 145.89,12.91 147.59,14.61 147.59,16.33 148.82,17.56 v7(148.82,19.59) 148.82,19.82 v2(148.6,20.04) 148.38,20.26 v7(148.38,20.46)
  TOP w0.112: v8(5.93,31.64) 6.29,32 7.55,32 7.7,31.85 UC6.1
  IN1 w0.076: v8(128.96,48.92) 129.28,48.6 130.09,48.6 130.38,48.3 130.38,46.35 131.13,45.6 132.68,45.6 134.36,43.92 135.09,43.92 137.64,41.37 137.64,40.33 140.08,37.89 140.08,37.26 140.93,36.4 143.08,36.4 143.3,36.18 143.3,35.4 150.4,28.31 150.4,22.65 148.38,20.63 v7(148.38,20.46) 148.06,20.14 147.47,20.14 147.44,20.11 147.44,20.11 146.57,19.24 146.57,19.24 145.12,17.79 145.12,17.79 143.58,16.25 137.4,16.25 136.81,15.67 132.99,15.67 132.64,16.01 132.64,16.39 132.23,16.81 126.89,16.81 125.93,17.77 123.19,17.77 122.78,18.18 113.65,18.18 112.46,16.99 109.34,16.99 108.87,16.52 99.33,16.52 98.8,15.98 97.45,15.98 96.77,15.3 85.42,15.3 84.8,15.91 81.02,15.91 76.47,11.37 75.38,11.37 74.1,10.09 74.1,9.6 73.89,9.39 72.58,9.39 72.3,9.66 69.62,9.66 69.42,9.86 66.72,9.86 65.23,11.35 61,11.35 60.44,11.92 54.42,11.92 50.71,15.62 50.71,15.86 49.93,16.64 48.49,16.64 47.93,16.09 43.63,16.09 42.97,16.75 39.04,16.75 36.67,19.12 36.67,19.38 33.65,22.4 31.23,22.4 31.01,22.17 28.52,22.17 28.36,22.33 26.71,22.33 26.14,22.9 v7(26.14,23.34) 26.05,23.25 v9(24.73,23.25) ; v7(148.82,19.59) 148.9,19.67 148.9,19.81 150.01,20.92 150.53,20.92 150.76,21.14 150.76,21.53 151.8,22.57 v7(151.8,23.01) 151.96,23.01 155.11,26.16 162.71,26.16 163.23,26.68 165.72,26.68 v9(165.78,26.75)
  GND1 w0.095: v3(24.36,23.25) v9(24.73,23.25) ; v3(166.09,26.98) 165.94,26.83 165.86,26.83 v9(165.78,26.75) ; v1(32.56,26.16) 32.56,26.56 v3(33,27) ; v1(131.2,8.53) 131.2,8.35 v3(131.34,8.2)
  IN2 w0.064: v8(5.93,31.64) 7.76,29.81 7.76,26.02 8.61,25.16 11.85,25.16 12.18,25.49 14.59,25.49 16.27,23.81 17.3,23.81 17.97,24.47 23.14,24.47 v3(24.36,23.25)
  GND3 w0.095: v3(166.09,26.98) 166.34,27.23 v6(166.62,27.23) ; v3(131.34,8.2) 131.72,8.58 v4(131.72,9.11) ; v4(32.69,27.1) 32.9,27.1 v3(33,27)
  IN4 w0.076: v6(166.62,27.23) 166.62,30.43 167.98,31.79 167.98,35.15 165.79,37.34 165.79,37.96 166.16,38.33 166.16,46.59 165.56,47.19 165.56,49.19 165.38,49.37 165.38,49.75 166.34,50.72 166.34,52.45 165.3,53.5 165.3,58.61 v5(163.91,60) 163.52,60 162.35,61.17 162.35,65.83 v5(162.56,66.03)
  BOTTOM w0.095: v4(32.69,27.1) 33.06,27.1 33.09,27.13 QE2.2
  BOTTOM w0.112: v8(128.96,48.92) 129.35,49.31 UCPU1.AN15
SIO_SLP_WLAN#: length 378.5
  TOP w0.095: QE23.1 268.1,59.47 v7(268.12,59.49) ; UE3.D9 18.3,12.43 v8(18.71,12.83) ; v7(151.22,38.49) 151.55,38.82 152.68,38.82 152.96,39.1 156.66,39.1 157.22,39.66 159.11,39.66 162.6,36.16 162.6,28.36 160.72,26.48 v2(160.72,21.95) 160.72,18.12 v7(160.8,18.04)
  IN1 w0.076: v7(151.22,38.49) 150.8,38.07 144.02,38.07 143.8,37.85 v9(143.79,37.85) ; v7(160.8,18.04) 160.91,18.16 168.47,18.16 169.11,17.52 173.07,17.52 173.36,17.81 176.81,17.81 180.93,13.68 181.32,13.68 183.36,11.64 184.9,11.64 186.81,9.73 206.36,9.73 211.42,14.79 224.83,14.79 226.56,13.06 227.72,13.06 231.26,9.51 249.21,9.51 251.2,11.5 253.74,11.5 255.35,13.11 258.98,13.11 260.24,14.37 260.24,17.2 263.16,20.11 263.16,23.36 263.58,23.78 263.58,25.03 265.41,26.86 265.41,29.97 265.75,30.31 265.75,37.79 266.5,38.54 266.5,41.25 266.55,41.3 266.55,48.79 267.97,50.21 267.97,52.82 267.74,53.05 267.74,59.11 v7(268.12,59.49)
  GND1 w0.095: v9(143.79,37.85) v3(143.79,37.52)
  IN2 w0.064: v3(81.78,29.72) 81.15,29.72 80.28,28.85 80.28,25.58 81.19,24.67 81.19,17.42 79.81,16.04 79.81,13.45 76.82,10.47 75.5,10.47 74.44,9.4 70.76,9.4 70.66,9.3 60.28,9.3 59.21,10.37 57.48,10.37 57.08,10.77 55.11,10.77 52.53,13.35 45.08,13.35 42.34,16.1 39.62,16.1 35.82,19.89 35.82,21.98 34.87,22.94 32.43,22.94 31.93,22.44 30.85,22.44 30.72,22.32 v3(30.72,22.27)
  GND3 w0.095: v4(143.73,37.84) 143.73,37.58 v3(143.79,37.52) ; v4(30.37,22.16) 30.61,22.16 v3(30.72,22.27) ; v6(82.1,30.05) v3(81.78,29.72)
  IN4 w0.076: v6(82.1,30.05) 84.29,32.23 102.36,32.23 102.96,32.83 105.64,32.83 105.93,32.54 131.34,32.54 132.78,33.98 132.78,36.6 133.11,36.93 v4(133.11,37.04) 133.11,40.14 133.55,40.58 133.55,41.22 132.87,41.89 130.12,41.89 129.42,42.59 128.36,42.59 128.07,42.3 v5(128.06,42.3)
  BOTTOM w0.095: v5(128.06,42.3) 127.92,42.44 127.92,43.5 UCPU1.BB17 ; v8(18.71,12.83) 18.85,12.83 19.1,13.09 19.1,15.86 19.11,15.87 19.11,16.2 19.11,16.21 19.11,17.13 19.72,17.75 19.72,18.61 20.06,18.95 22.77,18.95 23.7,19.88 24.73,19.88 26.16,21.3 29.51,21.3 v4(30.37,22.16) ; v4(133.11,37.04) 133.72,37.04 136.41,34.35 142.65,34.35 143.73,35.43 v4(143.73,37.84)
SKTOCC#: length 7.9
  BOTTOM w0.076: 99.65,68.12 100.83,66.94 100.83,66.52 100.7,66.39 UCPU1.A65 ; RC223.1 v2(95.38,69.97)
  BOTTOM w0.095: 99.65,68.12 97.5,68.12 96.37,69.25 RC223.1
SLEEVE:
  vias: v2(281.41,61.28)
SLEEVE_R:
  vias: v2(289.35,66.25)
SLP_WLAN#_GATE: length 379.6
  TOP w0.095: v8(17.1,16.81) UE3.K10 ; v7(151.65,38.49) 152.67,38.49 153.06,38.88 156.75,38.88 157.31,39.43 159.01,39.43 162.38,36.07 162.38,28.45 160.39,26.47 160.39,18.01 v7(160.42,17.98) ; R5837.1 268.96,59.04 268.75,59.25 v7(268.75,59.91)
  IN1 w0.076: v9(144.56,37.74) 144.69,37.87 151.03,37.87 v7(151.65,38.49) ; v7(268.75,59.91) 268.75,59.67 267.95,58.87 267.95,53.14 268.17,52.91 268.17,50.13 266.75,48.7 266.75,41.21 266.7,41.16 266.7,38.46 265.95,37.71 265.95,30.23 265.61,29.89 265.61,26.77 263.78,24.94 263.78,20.45 260.45,17.11 260.45,13.74 260.23,13.52 260.23,13.25 259.88,12.9 255.44,12.9 253.83,11.29 251.28,11.29 249.3,9.31 231.18,9.31 227.63,12.86 226.47,12.86 224.75,14.58 211.5,14.58 206.45,9.53 186.73,9.53 184.82,11.44 183.28,11.44 181.24,13.48 180.85,13.48 176.72,17.61 173.44,17.61 173.16,17.32 169.03,17.32 168.39,17.95 161.12,17.95 160.92,17.75 160.65,17.75 v7(160.42,17.98)
  GND1 w0.095: v3(144.32,37.5) v9(144.56,37.74)
  GND3 w0.095: v4(144.13,37.87) 144.13,37.7 v3(144.32,37.5)
  IN4 w0.076: v5(39.23,21.9) 39.23,21.81 39.84,21.2 39.84,20.43 39.1,19.69 39.1,18.29 39.01,18.21 39.01,16.14 40.28,14.86 48.39,14.86 49.11,14.15 53.02,14.15 53.86,13.31 62.13,13.31 62.33,13.52 65.3,13.52 66.2,12.62 66.2,11.88 66.57,11.51 67.75,11.51 67.86,11.4 72.11,11.4 75.03,14.32 75.92,14.32 76.24,14.64 78.61,14.64 79.77,15.79 79.77,19.08 81.1,20.41 81.1,23.85 81.42,24.17 81.42,28.88 84.57,32.03 102.45,32.03 103.05,32.63 105.4,32.63 106.41,31.62 130.71,31.62 133.11,34.02 v4(133.11,36.44) ; v8(17.1,16.81) 17.1,16.66 16.35,15.91 14.88,15.91 14.78,15.81 14.38,15.81 14.14,16.05 14.14,16.45 12.19,18.4 9.57,18.4 8.68,19.29 8.68,19.99 v5(7.02,21.65)
  BOTTOM w0.095: v5(39.23,21.9) 38.94,21.61 38.69,21.61 38.52,21.78 35.22,21.78 34.34,22.66 30.35,22.66 29.21,21.52 26,21.52 24.64,20.16 23.67,20.16 22.68,19.17 19.96,19.17 19.5,18.7 19.5,17.84 18.91,17.25 17.54,17.25 v8(17.1,16.81) ; v2(6.02,21.48) 6.19,21.65 v5(7.02,21.65) ; v4(133.11,36.44) 134,36.44 136.31,34.13 142.74,34.13 144.13,35.52 v4(144.13,37.87)
SM_PG_CTRL: length 5.7
  BOTTOM w0.095: v2(112.49,11.73) 113.37,10.84 PR609.1
  BOTTOM w0.254: RC383.2 112.69,13.01 UC9.4 114.45,13 114.45,11.96 RE241.2 114.38,11.91 113.47,11 PR609.1
SM_RCOMP0: length 4.7
  TOP w0.076: v8(127.09,47.67) 126.7,47.28 126.7,46.93 126.26,46.5 126.21,46.5
  TOP w0.305: RC11.1 124.99,44.79 125.32,45.12 125.32,45.61 126.21,46.5
  BOTTOM w0.254: v8(127.09,47.67) 127.15,47.67 127.49,48.01 UCPU1.AR18
SM_RCOMP1: length 3.6
  TOP w0.076: 126.59,46.09 126.59,46.48 127.1,46.99 v8(127.1,47.03)
  TOP w0.305: 126.59,46.09 v2(126.08,45.57) 125.88,45.38 RC12.1
  BOTTOM w0.254: UCPU1.AT18 127.26,47.03 v8(127.1,47.03)
SM_RCOMP2: length 2.6
  TOP w0.305: RC13.1 126.77,45.53 127.1,45.86 v8(127.1,46.41)
  BOTTOM w0.254: v8(127.1,46.41) 127.17,46.41 127.46,46.71 UCPU1.AU18
SML1_SMBCLK: length 221.2
  TOP w0.095: UE3.D8 19.48,12.79 v8(19.49,12.79)
  IN2 w0.064: v3(139.16,56.24) 138.82,55.9 138.82,55.75 139.1,55.47 139.1,54.83 139.27,54.66 140.31,54.66 142.38,52.59 142.38,50.24 142.58,50.04 142.58,47.86 142.14,47.42 142.14,46.83 141.16,45.85 141.16,45.78 v3(141.35,45.6) ; v8(19.49,12.79) 19.67,12.61 19.67,12.58 20.64,11.6 25.76,11.6 25.86,11.5 26.85,11.5 30.56,7.8 31.91,7.8 33.39,6.32 34.84,6.32 35.09,6.57 46.67,6.57 47.88,5.37 48.73,5.37 49,5.63 51.62,5.63 52.24,5.01 52.76,5.01 76.73,5.01 79.55,7.83 108.69,7.83 111.41,10.55 134.22,10.55 135.03,11.36 147.99,11.36 150.89,8.47 157.84,8.47 159.18,7.13 159.74,7.13 160.19,7.58 v3(160.22,7.58)
  IN3 w0.064: v3(141.35,45.6) 141.15,45.4 141.15,45.25 140.62,44.72 140.62,42.28 140.8,42.11 140.8,40.07 142.22,38.65 142.22,37.31 143.02,36.51 143.6,36.51 146.53,33.57 148.04,33.57 149.65,31.96 150.19,31.96 151.55,30.6 151.55,27.49 152,27.04 152,26.22 151.61,25.83 151.61,23.14 150.22,21.75 150.22,15.17 151.99,13.4 156.84,13.4 159.98,10.26 159.98,7.83 v3(160.22,7.58)
  GND3 w0.095: v4(139.19,56.61) 139.19,56.58 139.16,56.55 v3(139.16,56.24)
  BOTTOM w0.076: UCPU1.W3 136.49,56.31 136.67,56.31 136.86,56.37 136.96,56.37 137.19,56.31 137.37,56.31 137.46,56.35 137.89,56.35 138.05,56.19 138.77,56.19 v4(139.19,56.61) 139.28,56.61 139.59,56.3 v2(139.61,56.3) 140.98,56.3 RC23.1
SML1_SMBDAT: length 224.2
  TOP w0.095: UE3.E11 v8(17.07,13.58)
  IN2 w0.064: v3(140.81,45.6) 140.97,45.75 140.97,45.93 141.95,46.91 141.95,47.5 142.39,47.94 142.39,49.96 142.19,50.16 142.19,52.51 140.23,54.47 139.19,54.47 138.91,54.75 138.91,55.39 138.63,55.67 138.63,56.17 v3(138.58,56.23) ; v3(159.69,7.59) 159.42,7.32 159.26,7.32 157.91,8.66 150.96,8.66 148.07,11.55 134.95,11.55 134.14,10.74 111.33,10.74 108.61,8.02 79.47,8.02 76.65,5.2 52.68,5.2 52.68,5.2 52.32,5.2 51.7,5.82 48.92,5.82 48.65,5.56 47.96,5.56 46.75,6.76 35.01,6.76 34.76,6.51 33.47,6.51 31.99,7.99 30.64,7.99 26.93,11.69 25.94,11.69 25.84,11.79 20.72,11.79 19.88,12.63 19.88,12.95 19.63,13.2 19.39,13.2 19.12,13.47 19.12,13.71 18.87,13.96 17.44,13.96 v8(17.07,13.58)
  IN3 w0.064: v3(159.69,7.59) 159.79,7.69 159.79,10.18 156.76,13.21 151.91,13.21 150.03,15.09 150.03,21.83 151.42,23.22 151.42,25.91 151.8,26.3 151.8,26.96 151.36,27.41 151.36,30.52 150.11,31.77 149.57,31.77 147.96,33.38 146.46,33.38 143.52,36.32 142.94,36.32 142.03,37.23 142.03,38.57 140.61,39.99 140.61,42.03 140.55,42.09 140.55,42.09 140.43,42.2 140.43,44.8 140.96,45.33 140.96,45.45 v3(140.81,45.6)
  GND3 w0.095: v4(138.67,56.6) 138.58,56.5 v3(138.58,56.23)
  BOTTOM w0.076: UCPU1.V3 136.21,56.48 136.64,56.48 136.83,56.54 136.98,56.54 137.21,56.47 137.33,56.47 137.35,56.48 137.43,56.51 137.96,56.51 138.11,56.35 138.43,56.35 v4(138.67,56.6) 139.61,57.53 v2(140.13,57.53) 140.91,57.53 RC25.1
SNUB_1.0V: length 4.2
  TOP w0.095: PC700.1 135.61,3.83 v2(135.19,3.41)
  TOP w0.508: PR700.2 137.46,5.09 135.8,5.09 PC700.1
SNUB_1V_PRIM: length 1.3
  TOP w0.095: v2(71.99,33.19) 71.99,34.24 PC1519.1
SNUB_CHG1: length 1.8
  TOP w0.095: PR316.2 63.15,27.05 v2(63.86,27.76)
SNUB_CHG2: length 1.7
  TOP w0.095: PR317.2 v2(68,25.65)
SNUB_PRIM: length 1.1
  BOTTOM w0.508: PR1416.2 154.01,74.17 PC1419.1
SNUB_VCC_EDRAM: length 1.3
  TOP w0.095: PR1505.2 v2(62.59,34.23)
SNUB_VCCIO: length 3.5
  BOTTOM w0.095: PC1410.1 153.29,53.94 v2(151.94,53.94)
  BOTTOM w0.508: PR1403.2 154.04,54.69 PC1410.1
SP7_SDWP: length 7.5
  BOTTOM w0.095: v2(294.69,28.49) 294.69,29.98 QR1.1 294.04,30.44 292.46,32.02 RR10.2 292.06,32.65 291.07,33.64 UR1.29
SPI_CLK_VROM: length 13.5
  BOTTOM w0.095: U1.6 165.19,44.45 165.45,44.19 165.45,43.31 165.55,43.21 165.87,43.21 165.96,43.31 165.96,43.83 166.06,43.92 166.25,43.92 166.34,43.83 166.34,42.59 166.44,42.49 166.63,42.49 166.72,42.59 166.72,43.64 166.82,43.73 166.92,43.73 ; 166.92,43.73 v8(166.92,43.73) 166.92,43.73 ; 166.92,43.73 167.01,43.73 167.1,43.64 167.1,43 167.2,42.9 167.39,42.9 167.48,43 167.48,43.08 167.58,43.18 168.81,43.18 169.06,42.93 169.06,42.38 169.24,42.2 RP1.2 169.96,42.2 170.16,42 170.16,40.86 RC28.2
SPI_IO2_VROM: length 13.5
  BOTTOM w0.095: RP2.3 160.95,47.04 160.86,46.95 160.08,46.95 159.85,47.18 159.85,49.37 159.71,49.5 158.56,49.5 158.46,49.4 v2(158.46,49.24) 158.46,49.1 158.58,48.98 159.15,48.98 159.32,48.8 159.32,47.45 158.89,47.02 158.74,47.02 158.15,46.44 158.15,44.66 157.95,44.45 157.04,44.45 U1.3
SPI_IO3_VROM: length 13.1
  BOTTOM w0.095: RP2.4 160.45,48.36 160.69,48.6 162.42,48.6 162.65,48.37 162.65,47.56 162.8,47.4 163.06,47.4 163.26,47.61 163.26,48.77 163.41,48.93 163.67,48.93 163.77,48.83 v2(163.77,48.47) 163.77,46.57 163.18,45.98 163.18,43.69 163.69,43.18 164.29,43.18 U1.7
SPI_SI_VROM: length 14.3
  BOTTOM w0.095: U1.5 165.09,45.72 165.32,45.95 165.32,46.15 164.67,46.8 164.67,47.76 164.83,47.93 165.13,47.93 165.31,47.75 165.31,46.77 165.77,46.32 165.77,45.35 166.66,44.46 167.03,44.46 167.79,43.69 170.85,43.69 171.03,43.52 v8(171.03,42.99) 170.74,42.7 RP1.1
SPI_SO_VROM: length 14.1
  TOP w0.095: v8(158.96,46.55) v11(158.21,46.55)
  BOTTOM w0.095: U1.2 157.04,43.18 157.86,43.18 158.01,43.34 158.01,43.91 158.19,44.08 158.36,44.08 158.54,44.26 158.54,46.12 v8(158.96,46.55) 159.26,46.84 159.63,46.84 159.91,46.57 163.36,46.57 163.46,46.67 163.46,47.01 163.37,47.1 162.6,47.1 162.39,47.31 162.07,47.31 161.87,47.1 161.55,47.1 161.45,47.2 RP2.2
SPK_CLK: length 10.6
  TOP w0.095: RA64.2 289.51,7.7 289.51,9.35 289.49,9.38 v8(289.49,9.48)
  BOTTOM w0.095: v8(289.49,9.48) 289.49,9.8 288.72,10.56 284.55,10.56 283.59,9.61 283.59,9.13 283.36,8.89 JSPK1.6
SPK_DAT: length 10.5
  TOP w0.095: v8(290.11,9.15) 290.07,9.11 v2(290.07,8.29) RA63.2
  BOTTOM w0.095: JSPK1.7 283.29,9.69 284.38,10.78 288.86,10.78 289.92,9.72 289.92,9.34 v8(290.11,9.15)
SPK_DET#: length 199.5
  TOP w0.095: v8(134.49,54.63) 134.55,54.63 v2(134.95,55.04)
  IN1 w0.076: v9(165.88,6.35) 166.26,6.35 168.22,4.38 183.14,4.38 184.17,3.35 224.57,3.35 226.55,1.37 227.09,1.37 227.09,1.37 267.91,1.37 268.77,2.23 272.71,2.23 273.92,3.43 289.97,3.43 v7(291.84,5.3)
  GND1 w0.095: v3(165.56,6.49) 165.71,6.35 v9(165.88,6.35)
  IN3 w0.064: v3(150.64,18.54) 151.89,17.29 151.89,15.04 153.09,13.85 157.04,13.85 163.19,7.7 164.36,7.7 v3(165.56,6.49)
  GND3 w0.095: v6(149.75,18.82) 149.79,18.78 150.41,18.78 v3(150.64,18.54)
  IN4 w0.076: v6(149.75,18.82) 149.75,18.87 149.21,19.4 149.21,23.06 149.45,23.29 149.45,27.86 149.15,28.16 149.15,28.6 147.75,30 147.75,32.91 147.51,33.14 147.51,33.16 147.23,33.45 147.23,35.39 147.48,35.64 147.48,37.86 146.18,39.16 144.54,39.16 142.18,41.53 142.18,47.89 140.71,49.36 140.71,49.84 140.23,50.32 138.38,50.32 136.94,51.76 136.94,52.69 136.13,53.51 135.61,53.51 134.49,54.63 v8(134.49,54.63)
  BOTTOM w0.112: UCPU1.W7 134.18,56.1 134.61,55.67 134.61,55.25 134.49,55.14 v8(134.49,54.63)
SPK_OUT_L+: length 15.2
  IN3 w1.016: 273.1,5.89 274.6,5.89 274.94,6.23 275.93,6.23 278.41,8.72 286.62,8.72 286.96,9.06
  vias: v2(283.02,9.94) v3(270.04,6.13) v3(270.51,6.13) v4(269.57,6.51) v4(269.57,6.26) v8(287.91,9.11) v8(288.49,9.11)
SPK_OUT_L+_R:
  vias: v8(269.01,5.68)
SPK_OUT_L-: length 9.5
  IN3 w1.016: 275.4,9.25 276.92,9.25 278.16,10.48 284.38,10.48
  vias: v2(284.28,10.95) v3(270.94,7.7) v3(271.5,7.36) v4(270.23,7.58) v4(270.28,7.31) v8(285.49,9.77) v8(286.07,9.77)
SPK_OUT_L-_R:
  vias: v1(269.22,7.08) v1(269.48,7.2) v3(269.28,7.92) v3(269.62,7.61) v4(269.18,7.28) v4(269.27,7.54)
SPK_OUT_R+: length 12.2
  IN2 w1.016: 282.9,4.38 282.37,3.85 274.02,3.85 271.95,1.78 271.82,1.78
  vias: v1(269.72,1.62) v1(269.88,1.85) v2(283.96,5.15) v3(270.05,1.56) v3(270.09,2.18) v8(283.69,6.52) v8(284.28,6.52)
SPK_OUT_R-: length 14.3
  IN2 w1.016: 269.26,2.9 269.57,3.21 270.73,3.21 271.23,3.71 272.06,3.71 274.03,5.69 ; 284.6,7.65 282.14,7.65 280.18,5.69 277.05,5.69
  vias: v1(268.95,1.85) v1(269.06,1.62) v2(285.9,7.54) v3(268.64,2.03) v3(268.64,1.6) v8(285.47,7.84) v8(285.47,7.26)
SPK_VDD: length 13.1
  TOP w0.095: RA62.2 RA50.2 290.92,7.06 v8(291.09,7.22)
  BOTTOM w0.095: v8(291.09,7.22) 290.86,7.45 290.86,9.14 288.99,11.01 284.29,11.01 283.78,10.49 JSPK1.8
SPKR: length 237.6
  TOP w0.095: v7(151.12,12.26) v2(151.12,12.96) 151.12,13.32 151.54,13.73 151.54,20.65 150.79,21.39 v7(150.47,21.39) ; v8(135.31,46.4) 135.89,46.4 RC118.2
  IN1 w0.076: v7(275.71,61.02) 275.33,60.64 273.29,60.64 270.34,57.68 270.34,55.57 274.12,51.78 274.12,46.36 274.91,45.57 274.91,36 276.19,34.72 276.19,30.37 276.57,29.99 276.57,24.78 276.76,24.59 276.76,18.88 276.44,18.56 276.44,16.1 275.54,15.2 274.63,15.2 273.23,13.81 264.55,13.81 263.82,14.54 262.42,14.54 261.86,13.97 261.86,12.71 260.03,10.88 256.83,10.88 254.28,8.33 251.19,8.33 250.14,7.28 230.33,7.28 226.79,10.82 220.09,10.82 219.67,10.4 218.12,10.4 216.16,12.35 212.43,12.35 207.37,7.29 185.8,7.29 183.89,9.2 180.56,9.2 177.48,12.28 175.62,12.28 174.67,11.33 169.67,11.33 168.65,12.35 165.16,12.35 164.96,12.15 162.04,12.15 161.84,12.35 151.21,12.35 v7(151.12,12.26) ; v8(135.31,46.4) 135.99,47.09 137.92,47.09 138.09,46.91 138.09,46.67 137.64,46.22 137.34,46.22 136.8,45.69 136.8,44.35 138.53,42.62 138.53,42.01 138.7,41.84 138.7,40.7 142.08,37.32 144.08,37.32 144.9,36.5 144.9,35.33 152.01,28.23 152.01,24.21 151.41,23.62 151.41,22.48 150.47,21.54 v7(150.47,21.39)
  BOTTOM w0.112: v8(135.31,46.4) 135.03,46.12 UCPU1.AW5
SRTCRST#: length 16
  TOP w0.095: RC68.1 132.49,38.63 132.59,38.74 CC9.1 132.68,38.76 133.17,39.25 133.17,39.94 132.75,40.35 132.63,40.35 v2(132.34,40.65) 132.34,41.9 131.48,42.76 v1(131.48,42.9)
  GND1 w0.095: v3(131.5,44.15) 131.36,44.15 131.17,43.95 131.17,43.13 131.4,42.9 v1(131.48,42.9)
  IN2 w0.064: v8(127.08,48.96) 127.12,48.92 127.22,48.92 127.54,48.6 127.54,47.03 127.84,46.73 128.17,46.73 129.22,45.68 130,45.68 131.52,44.16 131.52,44.15 v3(131.5,44.15)
  BOTTOM w0.112: UCPU1.AN18 127.52,49.31 127.17,48.96 v8(127.08,48.96)
SS_1.8VA: length 2.8
  BOTTOM w0.254: PU800.9 161.63,62.85 161.89,63.1 161.89,64.15 161.69,64.34 PC806.1
SS_1.8VU: length 4.1
  BOTTOM w0.095: PC906.1 160.63,3.27 v2(160.63,2.98)
  BOTTOM w0.254: PU900.9 157.68,4.11 157.96,3.83 158.98,3.83 159.22,4.07 PC906.1
SS_1V_PRIM: length 2.6
  BOTTOM w0.254: PC1520.1 68.67,30.41 69.07,30.81 69.81,30.81 70.07,31.06 PU1501.7
SS_PRIM: length 1.4
  BOTTOM w0.254: PU1401.7 158.32,73.91 PC1420.1
SS_VCC_EDRAM: length 1.3
  BOTTOM w0.254: PC1511.1 59.33,31.23 59.35,31.25 PU1500.7
SS_VCCIO: length 2.7
  BOTTOM w0.254: PC1411.1 164.79,58.23 164.28,57.71 163.26,57.71 163,57.45 PU1400.7
SSD_DEVSLP: length 54.9
  GND1 w0.095: v1(151.21,27.11) 151.4,26.91 v3(151.4,26.74)
  GND3 w0.095: v4(151.49,27.2) 151.49,26.82 v3(151.4,26.74)
  IN4 w0.076: v4(151.49,27.2) 151.6,27.31 151.6,30.85 149.42,33.03 149.42,34.93 149.11,35.25 149.11,37.94 149.71,38.54 149.71,46.95 143.8,52.86 143.8,54.08 141.58,56.3 138.35,56.3 137.87,56.78 135.46,56.78 135.05,57.18 133.39,57.18 131.66,58.91 131.66,59.94 132,60.28 132.75,60.28 132.95,60.48 135.36,60.48 v5(136.26,61.38)
  BOTTOM w0.095: v2(150.15,27.55) 151.23,27.55 151.49,27.3 v4(151.49,27.2) 151.59,27.2 151.84,26.95 JNGFF1.38
SSD_IFDET: length 48.6
  TOP w0.095: v1(161.2,45.16) 159.2,47.16 158.04,47.16 156.91,48.29 155.41,48.29 154.29,49.41 154.29,50.91 151.1,54.1 151.1,56.71 148.7,59.12 v2(146.57,59.12) 143.5,59.12 142.98,59.63 142.98,62.14 142.35,62.77 140.36,62.77 139.22,61.62 v8(139.22,60.81) 138.69,60.28 137.43,60.28 136.61,61.09
  TOP w0.112: 136.61,61.09 RC52.2
  GND1 w0.095: v3(161.2,44.79) 161.2,44.79 v1(161.2,45.16)
  GND3 w0.095: v3(161.2,44.79) v6(161.2,44.41)
  IN4 w0.076: v6(161.2,44.41) 161.69,43.92 161.69,40.57 161.15,40.04 v5(160.69,40.04)
  BOTTOM w0.076: UCPU1.G4 135.75,62.71 136.01,62.45 136.31,62.45 136.77,62.28 136.91,62.14 136.91,61.85 137.03,61.73 138.24,61.73 139.16,60.81 v8(139.22,60.81)
SSD_PCIE_WAKE#: length 8.7
  TOP w0.095: v7(151.42,29.23) v2(151.42,28.38) 150.73,28.38 R264.1 150.41,28.07 R32.1
  IN1 w0.076: v9(150.23,31.04) 151.42,29.85 v7(151.42,29.23)
  GND1 w0.095: v9(150.23,31.04) 150.01,31.04 v3(149.86,30.9)
  GND3 w0.095: v3(149.86,30.9) 150.14,31.18 v4(150.14,31.19)
  BOTTOM w0.095: v4(150.14,31.19) 151.7,31.19 151.94,30.95 JNGFF1.54
SSD_PWR_EN: length 45.9
  TOP w0.095: R81.1 152.24,25.41 R87.2 151.15,25.36 v2(150.23,25.36) 149.84,25.75 v1(149.84,26.93)
  GND1 w0.095: v3(149.25,26.96) 149.28,26.93 v1(149.84,26.93)
  GND3 w0.095: v6(149.07,27.36) 149.2,27.24 149.2,27.01 v3(149.25,26.96)
  IN4 w0.076: v8(132.42,55.66) 132.42,54.64 132.86,54.21 134.6,54.21 135.6,53.21 136.14,53.21 136.74,52.61 136.74,51.67 138.31,50.1 140.11,50.1 140.5,49.71 140.5,49.19 141.95,47.74 141.95,41.47 144.46,38.96 146.09,38.96 147.28,37.77 147.28,35.73 147.03,35.48 147.03,33.34 147.55,32.82 147.55,29.92 148.95,28.51 148.95,27.58 149.07,27.46 v6(149.07,27.36)
  BOTTOM w0.112: UCPU1.W12 130.93,56.24 131.17,56.47 131.74,56.47 131.93,56.28 131.93,55.95 132.22,55.66 v8(132.42,55.66)
SSD_SCP: length 20.8
  TOP w0.095: UE3.H5 21.52,15.62 v7(21.91,16.01) ; v2(29.07,4.32) 29.05,4.34 v1(29.05,5.18) 28.63,5.6 RE288.1 RE289.1 28.63,7.27 28.2,7.7 v1(28.2,8.53)
  IN1 w0.076: v7(21.91,16.01) 21.91,15.48 22.08,15.3 23.08,15.3 23.37,15.01 24.2,15.01 24.83,14.37 26.28,14.37 27.94,12.72 v9(28.54,12.72)
  GND1 w0.095: v1(28.2,8.53) 28.2,8.83 v3(28.29,8.92) ; v3(29.05,5.52) v1(29.05,5.18) ; v3(28.23,12.59) 28.41,12.59 v9(28.54,12.72)
  IN3 w0.064: v3(28.23,12.59) 27.91,12.27 27.91,9.3 v3(28.29,8.92)
  GND3 w0.095: v4(29.4,5.52) v3(29.05,5.52)
  BOTTOM w0.095: v4(29.4,5.52) 29.4,6.08 30.17,6.85 R5827.2
SSEQ0: length 8.3
  TOP w0.095: U30.11 269.11,21.89 268.15,20.92 267.68,20.92 R5836.1 266.91,20.15 266.91,18.52 R5839.1 267.82,17.6 267.82,17.4 268.38,16.85 268.85,16.85 268.98,16.72 R5798.2
SUPPLIER_ID0: length 8.3
  BOTTOM w0.076: 136.66,42.04 136.35,42.04 135.69,42.7 135.09,42.7 134.33,43.46 134,43.46 UCPU1.BB7
  BOTTOM w0.095: 136.66,42.04 137.79,42.04 139.1,40.72 RH89.2 RH86.1
SUPPLIER_ID1: length 9.4
  BOTTOM w0.076: UCPU1.BA7 133.86,44.05 134.29,43.62 134.4,43.62 135.15,42.87 135.75,42.87 136.33,42.29 136.48,42.29
  BOTTOM w0.095: 136.48,42.29 138.17,42.29 139.87,40.6 139.87,39.91 RH88.2 RH87.1
SUS_ON_EC: length 30.3
  TOP w0.095: v1(23.53,14.31) 23.53,12.78 UE3.D2 ; RE282.1 10.94,27.41 10.19,27.41 RE11.2 9.34,27.58 9.34,28.56 9.54,28.76 v1(9.92,28.76)
  GND1 w0.095: v3(10.53,28.56) 10.12,28.56 v1(9.92,28.76) ; v1(23.53,14.31) v3(23.53,14.64)
  IN3 w0.064: v3(23.53,14.64) 23.53,15.32 24.17,15.96 24.17,17.86 23.79,18.24 23.79,19.26 22.26,20.78 20.91,20.78 18.8,22.9 18.8,23.65 16.32,26.13 12.31,26.13 11.53,26.91 10.87,26.91 10.3,27.47 10.3,28.33 v3(10.53,28.56)
SUS_ON_P: length 247
  TOP w0.095: v1(8.93,27.07) 8.66,27.34 8.66,29.23 8.49,29.41 UC7.4 7.78,29.41 7.43,29.76 7.43,30.21 RE8.1 6.82,30.82 6.82,31.53 v2(6.91,31.62) 7.38,31.62 7.8,31.2 UC6.2
  GND1 w0.095: v3(8.83,26.55) 8.93,26.65 v1(8.93,27.07)
  IN2 w0.064: v3(8.83,26.55) 10.02,25.35 11.77,25.35 12.1,25.68 14.67,25.68 16.35,24 17.22,24 17.89,24.66 23.56,24.66 24.88,23.34 24.88,21.81 26.03,20.65 26.51,20.65 27.35,19.81 28.31,19.81 29.23,18.89 30.27,18.89 32.58,16.58 32.58,16.05 33.32,15.31 33.59,15.31 36.63,12.26 41.92,12.26 44.35,9.84 51.8,9.84 54.41,7.23 71.13,7.23 71.64,6.73 76,6.73 79.29,10.01 106.84,10.01 108.94,12.12 v3(110.38,12.12) 110.73,12.47 120.94,12.47 121.89,13.42 136.32,13.42 136.78,13.87 145.04,13.87 145.57,13.34 150.39,13.34 151.55,12.18 v3(151.55,11.36)
  GND3 w0.095: v4(152.53,11.15) 151.76,11.15 v3(151.55,11.36) ; v3(110.38,12.12) 110.08,11.81 v4(110.08,11.8)
  IN4 w0.076: v5(163.92,59.12) 165,58.03 165,53.09 165.41,52.67 165.41,50.18 165.15,49.92 165.15,49.31 165.35,49.11 165.35,47.03 165.95,46.43 165.95,38.42 165.58,38.05 165.58,37.26 167.72,35.12 167.72,32.02 166.17,30.47 166.17,27.26 166.5,26.93 168.28,26.93 170.03,25.18 170.03,23.53 171.53,22.03 171.53,19.1 169.45,17.02 168.05,17.02 164.53,13.5 162.27,13.5 160.61,11.84 160.3,11.84 159.94,12.2 154.11,12.2 153.07,11.15 v4(152.53,11.15)
  BOTTOM w0.095: PR607.1 112.97,9.93 112.59,10.31 112.59,11.08 111.84,11.83 110.1,11.83 v4(110.08,11.8) ; v4(152.53,11.15) 152.55,11.14 152.55,10.82 152.64,10.73 152.64,6.69 152.57,6.62 152.57,4.91 PR900.1
SUSACK#: length 193.1
  TOP w0.095: v7(13.17,17.7) v2(13.59,17.7) 13.69,17.7 13.98,17.41 14.76,17.41 14.94,17.6 15.31,17.6 15.69,17.22 UE3.K12
  IN1 w0.076: v7(13.17,17.7) 13.52,17.7 15.75,19.92 16.25,19.92 16.44,20.11 18.42,20.11 18.79,20.48 19.27,20.48 19.83,21.04 27.15,21.04 27.38,20.81 29.22,20.81 29.97,20.06 30.48,20.06 32.25,18.29 36.48,18.29 38.5,16.27 40.79,16.27 42.37,14.69 48.03,14.69 48.91,15.57 50.44,15.57 54.72,11.29 59.83,11.29 60,11.11 62.11,11.11 62.76,10.46 65.82,10.46 66.63,9.65 69.29,9.65 69.48,9.46 72.22,9.46 72.49,9.18 73.98,9.18 74.3,9.51 74.3,10 75.46,11.16 76.55,11.16 81.08,15.69 84.7,15.69 85.29,15.09 96.86,15.09 97.54,15.78 98.89,15.78 99.42,16.31 108.96,16.31 109.43,16.78 112.54,16.78 113.49,17.74 117.19,17.74 117.82,17.11 123.05,17.11 123.53,17.6 125.62,17.6 127.25,15.97 132.4,15.97 132.91,15.46 136.9,15.46 137.48,16.05 143.66,16.05 145.41,17.79 145.41,17.79 146.57,18.95 147.52,19.91 147.69,19.91 147.69,19.9 148.28,19.9 148.73,20.35 148.73,20.68 150.71,22.66 150.71,23.77 151.4,24.47 151.4,25.99 151.6,26.19 151.6,27.77 143.83,35.55 143.83,36.54 143.45,36.92 141.62,36.92 138.04,40.5 138.04,41.54 135.26,44.32 134.53,44.32 132.85,46.01 132.49,46.01 132.19,46.31 132.19,47.79 v8(131.7,48.28)
  BOTTOM w0.112: v8(131.7,48.28) 131.32,48.66 UCPU1.AP11
SUSCLK: length 224.6
  TOP w0.095: R33.2 152.31,27 v1(152.31,27.5)
  IN1 w0.076: v9(170,21.81) 169.72,21.81 169.1,21.19 157.19,21.19 156.16,20.16 v9(154.4,20.16)
  GND1 w0.095: v1(152.31,27.5) 152.31,27.52 v3(152.03,27.8) ; v9(154.4,20.16) 154.24,20.16 v3(154.03,19.96) ; v9(170,21.81) v3(170.36,21.81)
  IN2 w0.064: v3(170.36,21.81) 170.49,21.94 173.17,21.94 181.13,13.97 181.13,13.7 182.58,12.26 183.83,12.26 186.28,11.69 187.97,10.01 205.94,10.01 210.16,14.23 225.42,14.23 228.11,11.55 230.73,11.55 232.21,10.07 248.57,10.07 249.68,11.18 250.43,11.18 252.21,12.97 253.05,12.97 258,17.91 259.41,17.91 262.16,20.66 262.16,23.5 263.42,24.76 263.42,26.2 264.81,27.59 264.81,31.55 265.17,31.91 265.17,37.57 273.8,46.2 273.8,46.62 277.3,50.13 277.31,50.13 281.55,54.37 285.22,54.37 285.93,55.07 v3(286.42,55.07) ; v3(154.03,19.96) 153.79,19.96 153.38,20.36 153.38,26.45 v3(152.03,27.8)
  IN3 w0.064: v3(132.55,40.18) 132.72,40.35 132.72,41.72 133,42 133.48,42 133.73,41.75 134.23,41.75 134.44,41.96 135.29,41.96 135.72,41.53 137.88,41.53 139.15,42.8 139.15,43.23 139.82,43.91 139.82,44.93 140.36,45.47 140.36,45.66 140.66,45.96 141.62,45.96 141.84,45.74 141.84,45.31 141.09,44.56 141.09,42.57 141.37,42.29 141.37,40.86 143.89,38.33 144.64,38.33 147.45,35.52 147.45,34.84 149.89,32.4 150.38,32.4 152.03,30.75 v3(152.03,27.8)
  GND3 w0.095: v3(132.55,40.18) 132.09,39.71 v4(131.67,39.71) ; v3(286.42,55.07) 286.42,55.2 v4(286.18,55.45)
  BOTTOM w0.076: 130.96,39.84 CC93.2 130.95,40.46 v2(130.63,40.77) 130.3,40.77 129.51,41.56 128.87,41.56 128.41,42.02 128.41,42.36 128.1,42.67 128.1,43.76 127.82,44.04 UCPU1.BA17
  BOTTOM w0.095: v4(131.67,39.71) 131.08,39.71 130.96,39.84
SW_1.8VA: length 1.2
  BOTTOM w0.095: v2(153.46,63.1) 153.33,62.97 PR803.1
SW_1.8VU: length 1.7
  BOTTOM w0.095: v2(158.37,12.22) 158.19,12.4 PR903.1
SYS_PWROK: length 224.3
  TOP w0.095: v1(25.64,17.56) 25.67,17.58 28.59,17.58 28.73,17.72 28.78,17.72 v7(28.8,17.75) 28.85,17.8 28.85,18.98 29.44,19.56 RE157.1
  IN1 w0.076: v9(151.9,51.91) 148.81,48.82 148.22,48.82 147.36,47.97 144.39,47.97 143.91,48.45 v9(143.75,48.45) ; v9(103.01,14.59) 102.69,14.9 102.1,14.9 99.52,12.33 90.02,12.33 89.88,12.47 80.59,12.47 75.37,7.25 71.66,7.25 71.45,7.46 66.78,7.46 66.23,8.01 61.56,8.01 61.1,8.48 53.04,8.48 48.63,12.88 41.28,12.88 40.42,13.75 38.14,13.75 37.12,14.78 32.75,14.78 30.3,17.23 29.32,17.23 v7(28.8,17.75)
  GND1 w0.095: v1(25.64,17.56) 25.64,17.07 25.38,16.81 24.94,16.81 24.55,17.2 v3(24.55,17.43) ; v9(143.75,48.45) 143.75,48.18 v3(143.67,48.1) ; v1(22.3,14.82) 22.3,14.88 22.56,15.14 22.56,15.27 v3(22.55,15.28) ; v3(103.18,14.23) 103.01,14.4 v9(103.01,14.59) ; v9(151.9,51.91) 151.91,51.91 152.16,52.16 v3(152.16,52.27)
  IN3 w0.064: v3(103.18,14.23) 103.52,14.57 104.38,14.57 105.08,13.88 109.12,13.88 110.68,15.44 115.26,15.44 116.65,16.82 123,16.82 123.65,17.47 125.49,17.47 125.99,16.97 134.71,16.97 134.91,17.17 137.14,17.17 138.13,16.17 143.62,16.17 143.96,16.52 145.98,16.52 146.76,17.3 v8(146.76,17.54) ; v3(22.55,15.28) 22.6,15.24 22.6,15.19 23.15,14.63 23.15,14.43 23.33,14.26 23.63,14.26 23.98,14.61 23.98,15.25 24.66,15.93 24.66,17.32 v3(24.55,17.43)
  GND3 w0.095: v3(152.16,52.27) v6(151.39,52.27) ; v3(143.67,48.1) 143.61,48.16 v4(143.29,48.16)
  IN4 w0.076: v4(143.29,48.16) 143.49,47.96 143.49,46.53 142.75,45.79 142.75,41.53 144.71,39.57 146.39,39.57 147.89,38.07 147.89,35.47 147.64,35.22 147.64,33.65 148.15,33.14 148.15,30.77 148.27,30.65 149.28,29.65 149.28,29.65 149.86,29.07 149.86,23.12 149.62,22.89 149.62,19.9 150.07,19.44 150.07,18.32 148.72,16.97 147.81,16.97 147.62,17.16 147.14,17.16 v8(146.76,17.54) ; v5(139.27,67.19) 139.47,67.39 141.67,67.39 144.4,64.66 147.83,64.66 148.4,64.09 148.4,56.58 148.93,56.05 148.93,55.46 150.45,53.94 150.45,52.61 150.79,52.27 v6(151.39,52.27)
  BOTTOM w0.095: UCPU1.B6 134.72,65.42 135,65.7 135,66.54 135.65,67.19 v5(139.27,67.19) ; RC370.1 v4(143.29,48.16) ; v2(146.48,16.76) 146.76,17.03 v8(146.76,17.54)
SYS_RESET#: length 64.1
  TOP w0.095: RC89.2 RC88.2 136.57,65.59 v1(136.38,65.4) ; v7(161.68,35.69) 161.68,34.3 161.09,33.71 JAPS1.13
  IN1 w0.076: v7(161.68,35.69) 161.6,35.69 160.07,37.22 160.07,37.22 159.88,37.41 158.93,37.41 155.72,40.61 155.72,42.5 153.95,44.27 v9(153.95,44.83)
  GND1 w0.095: v3(135.65,65.57) 136.2,65.57 v1(136.38,65.4) ; v9(153.95,44.83) 154.05,44.74 v3(154.05,44.46)
  GND3 w0.095: v3(154.05,44.46) 153.77,44.46 153.66,44.57 v6(153.6,44.57) ; v4(135.3,65.57) v3(135.65,65.57)
  IN4 w0.076: v4(135.3,65.57) 134.88,65.99 134.88,66.73 136.22,68.07 141.12,68.07 143.86,70.81 146.45,70.81 147.5,70.27 149.35,68.42 149.35,62.01 149.06,61.73 149.06,57.72 150.19,56.59 150.19,55.16 152.54,52.81 152.54,51.63 153.84,50.33 153.84,49.02 153.6,48.77 v6(153.6,44.57)
SYS_RESET#_R: length 2.2
  TOP w0.095: RC89.1 138.65,66.5 138.68,66.53 RC87.2 139.18,66.53 139.31,66.66 v2(140.4,66.66)
TBT_A_AUX_N: length 36
  TOP w0.076: U19.J2 17.24,32.56 16.14,32.56 v7(16.12,32.58) 15.97,32.73 v2(15.17,32.73) 15.02,32.73 14.76,32.99
  TOP w0.157: 14.76,32.99 R185.2
  IN1 w0.089: v9(24.16,38.74) 23.62,39.27 21.95,39.27 20.99,38.32 20.99,38.06 18.31,35.38 16.85,35.38 16.08,34.6 16.08,33.02 16.12,32.98 v7(16.12,32.58)
  GND1 w0.157: v9(24.16,38.74) 24.39,38.74 v3(24.6,38.53)
  IN2 w0.076: v3(33.47,43.53) 33.34,43.53 32.93,43.94 32.93,44.13 33.04,44.24 33.21,44.24 33.35,44.1 33.85,44.1 34.13,43.82 34.13,42.99 33.81,42.67 33.81,39.68 33.14,39.01 33.14,38.82 32.32,38 28.78,38 28.61,37.83 24.5,37.83 24.13,38.19 24.13,38.3 24.21,38.38 24.44,38.38 v3(24.6,38.53)
  GND3 w0.076: v4(32.37,43.77) 32.54,43.94 33.06,43.94 v3(33.47,43.53)
TBT_A_AUX_N_C: length 7.5
  IN3 w0.076: v3(31.55,43.54) 31.44,43.65 30.13,43.65 27.75,46.03 26.6,46.03 26.4,46.23 26.4,46.36 v3(26.19,46.58)
  GND3 w0.157: v3(31.55,43.54) 31.56,43.54 v4(31.79,43.77) ; v3(26.19,46.58) 26.19,46.58 26.44,46.33 v4(26.44,46.25)
TBT_A_AUX_P: length 35.3
  TOP w0.076: v7(16.9,34.27) 17.33,34.27 17.42,34.18 17.42,33.36 U19.J1
  TOP w0.157: R186.2 16.26,34.51 16.26,34.42 16.41,34.27 v7(16.9,34.27)
  IN1 w0.089: v7(16.9,34.27) 16.9,33.33 16.81,33.24 16.55,33.24 16.46,33.33 16.46,34.44 17.01,35 18.47,35 21.38,37.9 21.38,38.16 22.11,38.89 23.46,38.89 23.62,38.74 23.62,38.49 v9(23.34,38.21)
  GND1 w0.157: v9(23.34,38.21) 23.4,38.21 v3(23.73,38.54)
  IN2 w0.076: v3(23.73,38.54) 23.73,38.06 24.34,37.45 28.77,37.45 28.94,37.62 32.47,37.62 33.52,38.67 33.52,38.85 34.19,39.52 34.19,42.51 34.51,42.84 34.51,43.98 34.01,44.48 v3(33.51,44.48)
  GND3 w0.076: v4(32.37,44.41) 32.57,44.21 33.24,44.21 v3(33.51,44.48)
TBT_A_AUX_P_C: length 7.5
  IN3 w0.076: v3(26.79,46.57) 26.65,46.57 26.57,46.49 26.57,46.3 26.67,46.2 27.82,46.2 30.2,43.82 31.28,43.82 31.39,43.93 31.49,43.93 31.57,44.01 v3(31.57,44.15)
  GND3 w0.157: v4(27.09,46.25) 27.09,46.26 v3(26.79,46.57) ; v4(31.79,44.41) 31.79,44.37 v3(31.57,44.15)
TBT_A_CC1: length 31.2
  TOP w0.203: U19.K9 U19.L9
  TOP w0.254: 15.46,29.1 15.66,29.31 U19.L9
  TOP w0.508: 15.46,29.1 14.9,28.54 14.53,28.54 C150.1 v8(14.61,27.77)
  IN4 w0.508: 7.33,40.22 6.31,40.22 3.77,42.75 3.77,43.92 4.02,44.17 ; v8(14.61,27.77) 12.9,27.77 12.4,28.26 7.96,28.26 6.95,29.28 6.95,29.4 5.91,30.44 5.91,30.75 4.6,32.06 4.6,36 7.31,38.71 7.31,39.22
  vias: v2(7.05,40.48) v3(4.83,44.88) v5(7.51,40.22) v5(7.85,40.22) v6(4.37,44.51) v6(4.57,44.67) v7(5.57,46.09) v7(5.84,46.1) v9(4.97,45.39) v9(5.07,45.14)
TBT_A_CC2: length 29.7
  TOP w0.203: U19.K10 U19.L10
  TOP w0.254: U19.L10 v1(15.86,28.81)
  GND1 w0.508: v1(15.86,28.81) 15.66,28.81 v3(15.43,28.58)
  IN2 w0.508: v3(15.43,28.58) 12.72,28.58 7.15,34.15 7.15,35.81 8.46,37.11 v3(8.46,37.28) 8.46,38.53 9.11,39.17 9.11,40.39 9.62,40.9 9.62,42.97 9.46,43.13 9.46,46.23 v3(8.28,47.4)
  GND3 w0.254: v4(16.17,28.25) 15.76,28.25 v3(15.43,28.58)
  BOTTOM w0.254: v4(16.17,28.25) 16.14,28.28 16.14,28.57 v2(16.25,28.67) 16.84,28.67 C149.1
  vias: v1(7.4,47.34) v1(7.72,47.35) v1(8.6,37.73)
TBT_A_DBG_CTL1: length 6.9
  IN1 w0.076: v7(19.48,31.81) 19.52,31.85 19.52,33.7 20.04,34.22 20.6,34.22 22.46,36.08 22.46,36.92 v7(22.6,37.05)
TBT_A_DBG_CTL2: length 7.8
  IN1 w0.076: v7(19.98,31.31) 19.78,31.5 19.78,31.94 19.74,31.98 19.74,32.85 19.82,32.93 20.42,32.93 20.65,33.16 20.65,33.9 22.67,35.92 22.67,36.44 23.25,37.01 v7(23.45,37.01)
TBT_A_DEBUG3: length 4.7
  TOP w0.076: 15.95,32.38 16.02,32.31 U19.L3
  TOP w0.095: 15.95,32.38 14.67,32.38 RT53.1 14.3,32.83 14.02,33.11 13.5,33.11 13.37,32.98 R191.2
TBT_A_DEBUG4: length 5
  TOP w0.076: RT54.1 15.86,32.19 15.99,32.06 16.73,32.06 U19.K3
  TOP w0.095: R192.2 13.08,32.24 13.49,31.83 13.95,31.83 RT54.1
TBT_A_HPD: length 46.3
  TOP w0.095: v7(23.35,28.8) 23.35,28.38 R175.2 v2(24.35,28.28)
  IN1 w0.076: v1(23.12,51.87) 23.83,52.58 23.83,55.95 25.65,57.76 28.45,57.76 29.4,56.81 29.4,56.52 30.35,55.57 30.35,51.64 29.28,50.57 29.28,46.14 30.02,45.4 30.02,43.53 25.88,39.39 25.88,37.86 24.46,36.44 24,36.44 23.8,36.23 23.8,35.81 23.16,35.17 23.16,34.72 23.88,34 23.88,33.92 24.18,33.62 24.18,33.1 23.96,32.88 23.96,30.86 23.35,30.25 v7(23.35,28.8)
  GND1 w0.095: v3(23.42,51.71) 23.28,51.71 v1(23.12,51.87)
  GND3 w0.095: v4(23.19,51.45) 23.42,51.68 v3(23.42,51.71)
TBT_A_I2C_B_N: length 19.9
  TOP w0.076: v1(15.67,30.54) 15.91,30.31 16.02,30.31 16.11,30.4 16.22,30.4 16.31,30.31 U19.L7
  TOP w0.102: ML2.1 11.45,44.93 11.64,44.93 11.7,44.86 v8(11.7,44.62)
  GND1 w0.102: v1(15.67,30.54) 15.64,30.58 15.64,30.91 v3(15.6,30.95)
  IN2 w0.089: v8(11.7,44.62) 12.03,44.62 12.17,44.47 12.17,40.17 11.79,39.79 11.79,37.1 12.94,35.95 12.94,35.68 13.26,35.36 13.26,34.02 14.29,32.99 14.29,30.5 14.6,30.19 15.19,30.19 15.52,30.52 15.52,30.87 v3(15.6,30.95)
TBT_A_I2C_B_N_R: length 4.1
  TOP w0.102: ML2.2 10.06,46.31 10.06,46.54 9.89,46.71 D37.1 9.44,47.1 9.33,47.21 8.94,47.21 8.25,46.52 8.05,46.52 7.88,46.34 JUSBC1.A7
TBT_A_I2C_B_P: length 20
  TOP w0.076: v1(15.29,30.51) 15.75,30.06 16.63,30.06 16.88,30.31 U19.K7
  TOP w0.102: ML2.4 12.05,45.03 v8(12.12,45.03)
  GND1 w0.102: v1(15.29,30.51) 15.29,30.69 v3(15.04,30.94)
  IN2 w0.089: v3(15.04,30.94) 15.17,30.82 15.17,30.67 15.04,30.55 14.75,30.55 14.64,30.65 14.64,33.14 13.62,34.17 13.62,35.51 13.3,35.83 13.3,36.09 12.14,37.25 12.14,39.64 12.52,40.02 12.52,44.62 v8(12.12,45.03)
TBT_A_I2C_B_P_R: length 4.1
  TOP w0.102: ML2.3 10.45,46.63 10.29,46.63 9.89,47.03 D39.1 9.7,47.16 9.42,47.44 8.85,47.44 8.16,46.75 8.02,46.75 7.93,46.84 JUSBC1.A6
TBT_A_I2C_INT#: length 44.1
  TOP w0.076: U19.C1 20.52,33.35 20.52,33.5 20.7,33.68 20.7,33.69 21.02,34.01 21.26,34.01 21.58,34.32
  TOP w0.095: 21.58,34.32 22.01,34.75 22.01,36.05 22.65,36.69 23.12,36.69 23.59,36.23 v2(23.88,36.23) 24.04,36.23 v7(24.24,36.03)
  IN1 w0.076: v1(22.11,52.06) 22.11,52.15 23.37,53.41 23.37,55.77 25.57,57.97 28.53,57.97 29.61,56.89 29.61,56.6 30.56,55.65 30.56,51.55 29.48,50.48 29.48,46.23 30.24,45.47 30.24,43.46 26.09,39.31 26.09,36.71 25.35,35.96 24.3,35.96 v7(24.24,36.03)
  GND1 w0.095: v3(22.14,51.69) 22.14,52.04 v1(22.11,52.06)
  GND3 w0.095: v4(21.89,51.45) v3(22.14,51.69)
TBT_A_LSRX: length 35
  GND1 w0.157: v1(12.96,29.42) v3(13.37,29.42) ; v3(16.04,51.39) 16.04,51.39 v1(16.42,51.39) ; v3(12.24,32.24) v1(11.86,32.24)
  IN2 w0.076: v3(13.37,29.42) 13.74,29.79 13.74,30.23 13.41,30.55 12.42,30.55 11.85,31.13 11.85,32.15 11.97,32.27 12.21,32.27 v3(12.24,32.24)
  IN3 w0.076: v3(12.24,32.24) 12.35,32.24 12.88,32.77 12.88,39.31 13.3,39.72 13.3,42.77 16.04,45.51 16.04,48.67 16.92,49.54 16.92,51.02 16.55,51.39 v3(16.04,51.39)
  GND3 w0.157: v4(16.35,51.16) 16.12,51.39 v3(16.04,51.39) ; v3(12.24,32.24) v6(12.58,32.24)
  IN4 w0.089: v4(17.08,32.47) 16.79,32.18 16.2,32.18 16.11,32.08 12.74,32.08 v6(12.58,32.24)
  BOTTOM w0.157: UT2.A4 18.03,51.12 16.51,51.12 16.47,51.16 v4(16.35,51.16)
TBT_A_LSRX_R: length 0.9
  GND1 w0.157: v1(16.98,31.81) 17.19,31.81 v3(17.39,32.01)
  GND3 w0.157: v3(17.39,32.01) 17.21,32.01 v4(17.08,31.88)
TBT_A_LSTX: length 34.7
  GND1 w0.157: v3(11.93,33.06) 11.68,33.06 v1(11.6,32.98) ; v1(16.42,50.8) v3(16.04,50.8) ; v1(12.96,30.44) v3(13.25,30.14)
  IN2 w0.076: v3(11.93,33.06) 11.93,32.77 11.47,32.31 11.47,30.97 12.27,30.17 13.22,30.17 v3(13.25,30.14)
  IN3 w0.076: v3(16.04,50.8) 16.25,51.01 16.39,51.01 16.54,50.87 16.54,49.7 15.66,48.83 15.66,45.67 12.92,42.93 12.92,39.88 12.5,39.46 12.5,32.92 12.2,32.62 11.78,32.62 11.67,32.73 11.67,32.95 11.78,33.06 v3(11.93,33.06)
  GND3 w0.157: v3(16.04,50.8) 16.3,50.8 v4(16.4,50.7) ; v6(12.27,33.06) v3(11.93,33.06)
  IN4 w0.089: v6(12.27,33.06) 12.14,32.94 12.14,32.74 12.26,32.62 12.85,32.62 13.01,32.47 16.39,32.47 v4(16.4,32.47)
  BOTTOM w0.157: v4(16.4,50.7) 16.58,50.87 18.03,50.87 UT2.A5
TBT_A_LSTX_R: length 0.9
  GND1 w0.157: v1(16.48,31.81) 16.37,31.91 16.2,31.91 v3(16.07,31.79)
  GND3 w0.157: v3(16.07,31.79) 16.3,31.79 v4(16.4,31.88)
TBT_A_RESET_N: length 38.1
  TOP w0.095: v1(16.51,53.44) 16.66,53.59 v2(17.63,53.59) 18.41,53.59 RT17.1
  TOP w0.152: U19.F11 18.98,27.71 v8(18.84,27.57)
  GND1 w0.095: v3(16.3,53.04) 16.51,53.25 v1(16.51,53.44)
  IN3 w0.064: v8(18.84,27.57) 18.21,27.57 18.03,27.75 15.33,27.75 14.92,28.16 13.27,28.16 10.61,30.82 10.61,33.19 11.6,34.19 11.6,39.83 12.01,40.24 12.01,43.29 14.77,46.04 14.77,51.38 15.32,51.93 15.32,52.57 15.79,53.04 v3(16.3,53.04)
TBT_A_SBU1: length 38.6
  TOP w0.076: 13.59,29.42 14.86,29.42 14.98,29.55 16.72,29.55 U19.K8
  TOP w0.095: v7(10.75,28.73) 10.74,28.73 10.74,28.27 10.93,28.08 11.68,28.08 12.11,28.51 12.11,29.21 12.67,29.78 13.22,29.78 13.54,29.46 R5755.2 13.59,29.42
  TOP w0.102: v2(7.23,36.63) 7.23,38.02 v7(7.51,38.3)
  IN1 w0.076: v7(10.75,28.73) 10.79,28.78 10.79,29.41 9.52,30.68 9.52,31.34 9,31.86 7.8,31.86 7.33,32.33 7.33,34.52 7.83,35.02 7.83,36.2 6.77,37.26 6.77,37.97 6.98,38.18 7.39,38.18 v7(7.51,38.3) 7.51,38.03 7.62,37.92 7.74,37.92 7.81,38 7.81,38.48 7.62,38.67 6.7,38.67 6.35,39.01 6.35,40.11 3.76,42.7 3.76,46.7 4.37,47.31 5.48,47.31 6.03,46.75 6.14,46.75 6.22,46.83 6.22,46.94 5.99,47.16 5.99,47.27 6.12,47.4 6.12,47.52 6.05,47.59 v7(5.8,47.59)
TBT_A_SBU2: length 36.8
  TOP w0.076: 13.59,30.39 13.78,30.19 13.78,29.81 13.99,29.6 14.79,29.6 14.99,29.81 U19.L8
  TOP w0.095: 13.59,30.39 R5754.2 13.54,30.11 13.46,30.03 12.61,30.03 11.89,29.31 11.89,28.6 11.58,28.3 11.02,28.3 10.96,28.36 10.96,28.51 11.15,28.7 v7(11.15,28.73)
  IN1 w0.076: v7(7.4,45.84) 7.11,45.84 6.88,46.08 6.42,46.08 5.4,47.1 4.44,47.1 3.97,46.62 3.97,42.79 6.56,40.2 6.56,39.09 6.78,38.87 7.71,38.87 8.02,38.56 8.02,37.91 7.82,37.72 7.69,37.72 v7(7.51,37.54) 7.39,37.54 7.29,37.64 7.29,37.89 7.21,37.97 7.07,37.97 6.97,37.88 6.97,37.34 8.06,36.26 8.06,34.93 7.57,34.44 7.57,32.38 7.88,32.07 9.07,32.07 9.72,31.42 9.72,30.77 11,29.5 11,28.89 v7(11.15,28.73)
TBT_A_USB2_D_N: length 21.8
  GND1 w0.102: v3(16.96,30.72) 16.88,30.79 16.88,31.21 v1(16.98,31.31)
  IN3 w0.089: v3(16.96,30.72) 16.92,30.68 16.92,30.27 16.58,29.92 15.01,29.92 14.28,30.66 14.28,31.98 15.95,33.66 15.95,34.17 17.98,36.21 17.98,37.42 17.49,37.91 17.49,40.98 17.08,41.39 17.08,42.67 17.5,43.09 v3(18.14,43.09)
  GND3 w0.102: v4(19.29,43.65) 19.53,43.65 19.65,43.53 19.65,43.33 19.09,42.77 18.45,42.77 v3(18.14,43.09)
TBT_A_USB2_D_P: length 21.8
  GND1 w0.102: v3(16.14,30.78) 16.48,31.12 v1(16.48,31.31)
  IN3 w0.089: v3(16.14,30.78) 16.14,31.31 16.27,31.44 16.47,31.44 16.57,31.35 16.57,30.41 16.43,30.28 15.16,30.28 14.63,30.81 14.63,31.84 16.31,33.51 16.31,34.03 18.34,36.06 18.34,37.56 17.85,38.06 17.85,41.13 17.44,41.54 17.44,42.52 17.65,42.73 17.92,42.73 v3(18.14,42.5)
  GND3 w0.102: v4(19.94,43.65) 19.88,43.58 19.88,43.24 19.18,42.54 18.19,42.54 v3(18.14,42.5)
TBT_A_USB2_T_N: length 15.6
  TOP w0.076: U19.L6 16.67,30.81 16.75,30.89 16.75,30.98 16.68,31.05 15.67,31.05 15.44,31.27 13.59,31.27
  TOP w0.102: v8(10.89,37.74) 10.72,37.57 10.58,37.57 10.44,37.71 10.44,37.92 10.64,38.12 ML3.4 ; v8(12.65,31.68) 12.65,31.67 12.99,31.33 13.4,31.33 13.45,31.27 13.59,31.27
  IN2 w0.089: v8(12.65,31.68) 12.87,31.45 13.16,31.45 13.35,31.64 13.35,32.55 12.08,33.82 12.08,35.66 11.45,36.29 10.5,36.29 10.08,36.72 10.08,37.2 10.39,37.51 10.71,37.51 10.89,37.69 v8(10.89,37.74)
