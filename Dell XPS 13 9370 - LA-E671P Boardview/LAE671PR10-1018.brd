# Allegro board LAE671PR10-1018.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MUX_USB3_TX0_N_C: length 1.9
  TOP w0.102: U30.34 270.71,26.75 270.78,26.82 270.78,27.18 271.2,27.6 271.2,27.75 C57.1
MUX_USB3_TX0_P: length 31.7
  TOP w0.102: C55.2 271.59,28.9 v8(271.82,29.13) ; JUSBC3.A2 288.55,48.05 288.49,48.11 288.49,48.23 288.42,48.31 288.27,48.31 288.05,48.08 288.05,46.47 287.5,45.91 286.93,45.91 286.81,45.79 286.81,45.17 286.94,45.04 D56.1 286.92,44.84 286.92,44.57 287.03,44.46 287.03,43.86 v8(287.25,43.64)
  IN2 w0.089: v8(287.25,43.64) 287.18,43.57 287.18,43.01 285.42,41.25 282.02,41.25 276.8,36.03 276.8,34.04 273.01,30.25 271.77,30.25 271.57,30.05 271.57,29.39 v8(271.82,29.13)
MUX_USB3_TX0_P_C: length 1.9
  TOP w0.102: U30.33 271.11,26.74 271.01,26.84 271.01,27.09 271.43,27.51 271.43,27.77 C55.1
MUX_USB3_TX1_N: length 39.7
  TOP w0.102: C63.2 270.02,28.68 270.02,28.93 270.21,29.13 v8(270.39,29.13)
  IN2 w0.089: v8(270.39,29.13) 270.12,29.13 270.04,29.2 270.04,29.32 270.18,29.45 270.18,29.92 271.28,31.03 272.72,31.03 275.91,34.22 275.91,36.36 281.59,42.05 285.01,42.05 285.89,42.93 285.89,44.41 287.2,45.71 287.2,48.53 287.62,48.95 287.62,50.96 287.5,51.08 v8(287.5,51.62)
  BOTTOM w0.102: JUSBC3.B3 290.94,52.17 289.77,52.17 289.19,52.75 288.73,52.75 D65.1 288.46,52.53 288.05,52.94 287.86,52.94 v10(287.47,52.55) 287.12,52.2 287.12,52 287.26,51.87 287.33,51.87 287.5,51.7 v8(287.5,51.62)
MUX_USB3_TX1_N_C: length 1.8
  TOP w0.102: C63.1 270.02,27.75 270.02,27.24 269.82,27.04 269.82,26.86 269.91,26.77 U30.36
MUX_USB3_TX1_P: length 39.7
  TOP w0.102: C62.2 269.79,28.68 269.79,28.95 269.65,29.09 v8(269.41,29.09)
  IN2 w0.089: v8(286.89,51.63) 287.14,51.39 287.14,50.93 287.26,50.81 287.26,49.1 286.84,48.68 286.84,45.86 285.54,44.56 285.54,43.08 284.86,42.41 281.45,42.41 275.55,36.51 275.55,34.36 272.57,31.38 271.13,31.38 269.82,30.07 269.82,29.6 269.69,29.47 269.69,29.46 269.69,29.46 269.69,29.32 269.46,29.09 v8(269.41,29.09)
  BOTTOM w0.102: v8(286.89,51.63) 286.89,52.3 287.29,52.69 287.31,52.71 287.77,53.17 D67.1 288.7,52.98 289.29,52.98 v10(289.54,52.73) 289.87,52.4 290.91,52.4 JUSBC3.B2
MUX_USB3_TX1_P_C: length 1.8
  TOP w0.102: U30.37 269.51,26.77 269.59,26.85 269.59,27.14 269.79,27.34 269.79,27.76 C62.1
MUX_USB_SEL: length 33.7
  GND1 w0.095: v1(278.06,20.78) 277.66,20.78 v3(277.63,20.76)
  IN3 w0.064: v3(277.63,20.76) 277.46,20.76 277.26,20.56 276.78,20.56 276.48,20.25 275.46,20.25 275.39,20.19 275.39,17.33 274.4,16.34 274.01,16.34 273.72,16.05 273.72,14.97 274.25,14.45 275.2,14.45 276.39,13.26 281.44,13.26 281.89,12.81 281.89,12.11 281.41,11.63 v3(280.62,11.63)
  GND3 w0.095: v6(277.65,20.43) 277.65,20.74 v3(277.63,20.76) ; v4(280.18,11.63) v3(280.62,11.63)
  IN4 w0.076: v6(277.65,20.43) 277.68,20.46 278.67,20.46 280.86,18.27 281.72,18.27 282.09,18.64 282.09,19.19 283.59,20.69 285.74,20.69 285.84,20.79 v5(285.93,20.79)
  BOTTOM w0.095: v2(281.4,10.1) 280.54,10.95 R5817.1 280.44,10.98 280.18,11.25 v4(280.18,11.63)
NB_LID#: length 69.3
  TOP w0.095: v7(50.29,6.22) v2(52.82,6.22) 55.53,6.22 58.93,2.81 58.93,2.2 59.4,1.73 59.68,1.73 59.87,1.81 60,1.94 61.32,1.94 61.97,1.29 74.79,1.29 75.05,1.54 75.05,2.55 75.15,2.65 R274.2 75.53,2.46 76.46,1.53 U26.3
  IN1 w0.076: v7(50.29,6.22) 49.84,6.22 47.26,8.81 32.15,8.81 31.77,9.19 v1(30.88,9.19)
  GND1 w0.095: v1(30.88,9.19) 31.06,9.37 v3(31.22,9.37)
  GND3 w0.095: v6(31.11,9.81) 31.22,9.7 v3(31.22,9.37)
  IN4 w0.076: v4(24.3,19.39) 24.3,19.7 24.56,19.97 25.06,19.97 25.42,19.6 27.09,19.6 27.98,18.71 27.98,15.74 30.46,13.26 30.46,10.41 31.06,9.81 v6(31.11,9.81)
  BOTTOM w0.095: RE237.2 25.52,19.01 25.32,19.21 24.48,19.21 v4(24.3,19.39)
NB_MUTE#: length 326.8
  TOP w0.095: UE3.A4 22.3,9.42 22,9.11 22,6.53 21.88,6.42 21.88,4.35 22.21,4.02 23.43,4.02 23.67,3.79 26.13,3.79 26.48,4.13 v2(26.48,4.32) 26.48,4.83 26.33,4.98 26.33,6.5 26.07,6.76 26.07,8.34 25.82,8.59 25.82,8.97 26,9.15 28.38,9.15 28.5,9.03 30.08,9.03 30.26,9.21 30.26,9.45 30.59,9.77 v7(30.6,9.77) ; D7.1 v7(269.23,64.74)
  IN1 w0.076: v7(30.6,9.77) 30.74,9.77 30.83,9.68 31.94,9.68 32.04,9.79 33.95,9.79 34.41,9.33 37.55,9.33 38.26,10.04 41.8,10.04 42.22,9.62 42.89,9.62 43.17,9.9 47.31,9.9 52.08,5.13 58.74,5.13 58.95,4.92 62.86,4.92 63.57,4.21 68.83,4.21 68.92,4.12 73.41,4.12 73.7,4.41 76.57,4.41 80.42,8.25 104.11,8.25 106.66,10.8 109.08,10.8 109.86,11.58 114.54,11.58 116.45,13.48 131.5,13.48 131.9,13.08 137.83,13.08 138.42,13.66 145.16,13.66 145.16,13.65 149.1,13.65 149.52,14.08 163.22,14.08 163.66,14.51 177.46,14.51 178.57,13.41 178.57,13.05 179.72,11.89 181.1,11.89 182.77,10.22 184.31,10.22 186.22,8.31 206.95,8.31 212.01,13.36 221.01,13.36 222.74,11.64 227.13,11.64 230.67,8.09 249.8,8.09 250.85,9.14 253.94,9.14 257.09,12.29 260.19,12.29 261.02,13.12 261.02,17.11 264.19,20.28 264.19,24.77 266.02,26.6 266.02,29.72 267.46,31.16 267.46,31.61 266.36,32.71 266.36,37.54 267.11,38.29 267.11,40.99 267.16,41.05 267.16,48.54 269.04,50.42 269.04,52.62 268.35,53.31 268.35,58.7 269.5,59.84 269.5,64.47 v7(269.23,64.74)
NRB_BIT: length 2.8
  TOP w0.095: v8(133.54,47.68) 134.07,47.16 134.9,47.16 RC45.2
  BOTTOM w0.112: UCPU1.AR7 133.87,48.01 v8(133.54,47.68)
PA_USB2_RBIAS: length 2.9
  TOP w0.095: v1(21.03,43.98) 20.94,43.9 RT42.1 21.19,43.31 v2(21.95,42.55)
  GND1 w0.095: v3(21.48,44.04) 21.08,44.04 v1(21.03,43.98)
  GND3 w0.095: v4(21.24,44.3) 21.24,44.28 v3(21.48,44.04)
PANEL_BKEN_EC: length 70.3
  TOP w0.095: v7(29.86,54.06) 30.15,54.06 31.03,54.94 31.03,57.99 31.41,58.37 35.55,58.37 v2(35.68,58.25) 42.51,58.25 v1(43.7,57.06) ; UE3.J9 18.3,16.44 v8(18.7,16.84)
  IN1 w0.076: v9(19.22,25.61) 19.53,25.61 20.56,26.63 20.96,26.63 21.29,26.96 21.29,29.01 23.14,30.86 23.14,31.24 23.14,31.58 23.13,31.59 23.13,31.83 23.14,31.83 23.14,31.89 23.5,32.26 23.5,33.01 23.35,33.16 23.35,33.91 22.76,34.51 22.76,35.46 23.32,36.02 23.32,36.33 23.83,36.84 24.28,36.84 25.39,37.95 25.39,39.48 29.62,43.71 29.62,45.23 28.87,45.98 28.87,50.81 29.86,51.79 v7(29.86,54.06)
  GND1 w0.095: v3(43.6,56.68) 43.7,56.78 v1(43.7,57.06) ; v3(19.62,25.61) v9(19.22,25.61)
  GND3 w0.095: v3(43.6,56.68) 43.7,56.59 43.7,56.36 43.76,56.3 43.76,56.21 v6(43.8,56.17) ; v3(19.62,25.61) 19.72,25.5 v6(19.72,24.98)
  IN4 w0.076: v6(19.72,24.98) 19.72,23.98 20.83,22.88 20.83,21.16 19.32,19.65 19.32,17.44 18.72,16.84 v8(18.7,16.84) ; v5(40.8,52.68) 40.8,52.85 43.8,55.85 v6(43.8,56.17)
  BOTTOM w0.095: D5.3 v5(40.8,52.68)
PANEL_BKLEN: length 218.8
  IN4 w0.076: v8(131.29,57.73) 131.29,57.45 132.39,56.34 133.2,56.34 133.43,56.12 134.16,56.12 134.24,56.04 134.67,56.04 134.8,56.17 135.88,56.17 136.39,55.66 140.44,55.66 141.64,54.46 142.85,54.46 143.37,53.94 143.37,52.71 149.3,46.78 149.3,38.71 148.7,38.11 148.7,35.13 148.45,34.88 148.45,34.2 148.97,33.68 148.97,31.12 150.68,29.4 150.68,18.07 148.96,16.35 147.57,16.35 147.37,16.54 144.99,16.54 144.58,16.13 138.51,16.13 137.98,15.6 131.58,15.6 131.44,15.74 123.72,15.74 123.59,15.62 121.39,15.62 121.3,15.7 113.9,15.7 113.06,14.86 83.13,14.86 81.99,13.72 80.75,13.72 79.34,12.31 78.41,12.31 77.48,11.39 75.21,11.39 74.4,10.58 74.4,9.97 73.63,9.2 67.75,9.2 67.07,9.88 61.64,9.88 61.49,10.04 60.6,10.04 60.06,10.58 52.15,10.58 50.72,12.01 48.67,12.01 47.47,13.2 39.37,13.2 36.84,15.73 36.84,20.09 36.91,20.16 36.91,21.25 36.82,21.34 36.82,21.58 37.01,21.77 37.01,23.39 36.5,23.91 36.5,25.17 38.52,27.19 38.52,31.2 37.94,31.77 37.94,38.14 37.57,38.51 37.57,39.17 36.91,39.83 36.91,46.97 37.39,47.45 37.39,47.81 37.76,48.17 37.76,51.27 v5(38.21,51.73)
  BOTTOM w0.095: v2(35.28,51.05) 37.19,51.05 37.87,51.73 v5(38.21,51.73) 38.57,51.38 D5.2
  BOTTOM w0.112: UCPU1.R12 130.93,58.09 v8(131.29,57.73)
PANEL_ID: length 8.1
  TOP w0.095: UE3.J10 17.12,16.03 14.75,16.03 14.67,15.96 v8(13.37,15.96)
  BOTTOM w0.095: v8(13.37,15.96) 13.51,16.1 v2(13.51,17.75) 13.34,17.93 CE76.1 RE195.2
PB_USB2_RBIAS: length 1.1
  GND1 w0.095: v1(20.39,43.35) 20.28,43.46 20.28,43.93 v3(20.35,44.01)
  GND3 w0.095: v4(20.59,44.3) 20.35,44.06 v3(20.35,44.01)
PBAT_CHARGER_SMBCLK: length 96.7
  TOP w0.095: PR152.2 97.63,11.92 v2(97.71,11.84) 97.71,9.76 PD104.2 98.12,11.4 v1(98.12,11.41) ; PR314.1 59.06,8.96 v1(59.03,9) ; UE3.N2 23.95,19.67 23.95,19.89 25.47,21.41 27.03,21.41 RE112.1 27.67,21.14 28.56,21.14 28.66,21.24 v1(28.66,21.33)
  GND1 w0.095: v3(29.27,21.42) 28.75,21.42 28.67,21.33 v1(28.66,21.33) ; v1(98.12,11.41) 98.04,11.33 v3(97.79,11.33) ; v3(58.69,9.33) 58.75,9.33 59.03,9.05 v1(59.03,9)
  IN2 w0.064: v3(29.27,21.42) 29.52,21.67 31.84,21.67 32.56,22.39 34.74,22.39 35.38,21.75 35.38,19.45 39.26,15.57 42.06,15.57 44.86,12.78 52.38,12.78 54.96,10.19 56.68,10.19 57.07,9.8 58.66,9.8 58.76,9.7 58.76,9.41 v3(58.69,9.33)
  IN3 w0.064: v3(97.79,11.33) 98.64,12.19 98.64,13.49 97.58,14.55 88.17,14.55 87.86,14.86 84.55,14.86 80.89,11.2 78.31,11.2 75.55,8.43 59.4,8.43 59.05,8.77 59.05,9.1 58.82,9.33 v3(58.69,9.33)
PBAT_CHARGER_SMBDAT: length 98.4
  TOP w0.095: UE3.M3 23.1,19.06 23.46,19.42 23.46,19.71 25.38,21.63 26.44,21.63 26.91,22.1 26.91,22.25 RE111.1 27.26,22.61 v1(27.26,22.66) ; PR154.2 v2(99.52,11.84) 99.52,9.74 PD104.3 99.13,11.33 v1(99.17,11.38)
  GND1 w0.095: v1(27.26,22.66) 28.49,22.66 28.99,22.16 v3(29.28,22.16) ; v3(98.83,11.34) 99.13,11.34 v1(99.17,11.38) ; v1(59.13,9.74) 59.13,9.61 v3(59.43,9.31)
  IN2 w0.064: v3(29.28,22.16) 29.58,21.86 31.76,21.86 32.48,22.58 34.82,22.58 35.57,21.83 35.57,19.53 39.34,15.76 42.14,15.76 44.94,12.97 52.46,12.97 55.04,10.38 56.76,10.38 57.15,9.99 58.74,9.99 59.4,9.33 59.41,9.33 v3(59.43,9.31)
  IN3 w0.064: v3(98.83,11.34) 98.83,13.57 97.66,14.74 88.25,14.74 87.94,15.05 84.47,15.05 80.81,11.39 78.23,11.39 75.47,8.62 59.48,8.62 59.24,8.85 59.24,9.2 59.35,9.31 v3(59.43,9.31)
PBAT_PRES#: length 99.5
  TOP w0.095: v7(17.89,14.46) 17.89,14.45 18.3,14.04 UE3.F9 ; v7(101.42,8.88) 101.5,8.88 101.85,9.23 PD105.3 PD105.2 v2(100.85,11.69) 100.85,12.56 PR157.2 ; v7(59.04,5.24) 58.97,5.31 58.97,6.13 PR158.1 PR325.1
  IN1 w0.076: v7(17.89,14.46) 18.22,14.79 18.71,14.79 18.97,14.54 18.97,14.2 19.16,14.01 21.12,14.01 21.39,13.75 21.63,13.75 21.75,13.87 22.02,13.87 22.2,13.68 22.67,13.68 22.86,13.49 23.64,13.49 23.86,13.27 24.46,13.27 24.81,13.62 25.97,13.62 27.29,12.31 27.29,11.94 28.18,11.04 29.84,11.04 30.5,10.39 30.54,10.39 31.04,9.89 31.86,9.89 31.96,9.99 34.04,9.99 34.5,9.53 37.46,9.53 38.17,10.24 47.25,10.24 52.16,5.33 58.91,5.33 59,5.24 v7(59.04,5.24) 59.04,5.2 59.12,5.12 62.95,5.12 63.66,4.41 68.91,4.41 69,4.32 73.33,4.32 73.62,4.61 76.47,4.61 80.31,8.45 101,8.45 v7(101.42,8.88)
PBTN_SW#: length 339.5
  TOP w0.095: v7(293.69,65.44) SW3.3 ; v7(279.45,34.33) v11(279.45,34.88)
  IN1 w0.076: v7(293.69,65.44) 294.81,65.44 295.38,64.87 295.38,62.79 294.86,62.27 293.89,62.27 291.43,59.82 291.43,59.13 288.76,56.46 286.37,56.46 285.21,55.3 285.21,52.15 284.99,51.93 280.73,51.93 278.78,49.98 278.78,43.31 279.8,42.3 279.8,40.87 279.64,40.7 279.64,34.52 v7(279.45,34.33) 279.45,33.99 279.64,33.81 279.64,33.22 279.84,33.02 279.84,27.81 280.39,27.26 280.39,22.6 279.88,22.09 279.88,19.64 279.06,18.83 279.06,15.18 277.44,13.55 275.27,13.55 273.91,12.18 264.96,12.18 260.45,7.67 259.27,7.67 256.71,5.11 256.13,5.11 254.74,3.71 227.21,3.71 225.46,5.46 223.42,5.46 221.67,7.21 218.24,7.21 216.49,5.46 185.04,5.46 183.13,7.37 169.04,7.37 167.74,8.67 165.17,8.67 164.12,9.71 161.08,9.71 158.87,7.5 152.65,7.5 149.74,10.42 144.96,10.42 144.57,10.81 138.76,10.81 138.13,10.18 118.35,10.18 116.01,7.84 115.7,7.84 115.24,7.38 113.17,7.38 112.37,6.58 81.09,6.58 77.29,2.78 74.38,2.78 74.09,2.49 68.24,2.49 68.15,2.58 62.9,2.58 62.21,3.27 58.29,3.27 58.09,3.48 54.44,3.48 54.04,3.08 50.69,3.08 47.87,5.89 40.78,5.89 40.38,6.29 36.43,6.29 35.82,5.68 33.08,5.68 32.45,6.31 31.04,6.31 29.92,7.42 28.42,7.42 v9(28.15,7.16)
  GND1 w0.095: v3(27.6,7.2) 27.63,7.16 v9(28.15,7.16)
  GND3 w0.095: v3(27.6,7.2) 27.5,7.29 v4(27.5,7.87)
  BOTTOM w0.095: RE187.2 27.42,7.79 CE68.1
PCH_ALW_ON: length 157.2
  TOP w0.095: RPE6.3 19.37,22.62 19.21,22.77 18.22,22.77 18.03,22.58 18.03,21.85 18.2,21.68 v7(18.2,21.55) 18.65,21.1 18.65,19.83 18.69,19.79 18.69,19.21 19.09,18.82 UE3.M8 ; R90.1 151.94,21.74 151.84,21.65 151.84,18.31 v2(151.93,18.22) 151.93,17.13 v1(151.84,17.04)
  IN1 w0.076: v9(31.67,21.18) 31.68,21.19 31.68,21.46 31.18,21.97 28.42,21.97 28.28,22.12 26.63,22.12 25.84,22.9 21.13,22.9 20.85,22.63 20.85,22.55 20.57,22.27 19.05,22.27 18.33,21.55 v7(18.2,21.55)
  GND1 w0.095: v9(31.67,21.18) 31.51,21.02 v3(31.51,20.43) ; v1(151.84,17.04) 151.74,17.04 v3(151.41,16.71)
  IN2 w0.064: v3(31.51,20.43) 31.68,20.43 32.19,19.92 33.84,19.92 37.81,15.94 37.81,14.81 38.67,13.95 42.21,13.95 44.85,11.31 52.38,11.31 55.06,8.63 70.89,8.63 71.03,8.77 76.07,8.77 79.69,12.39 82.56,12.39 83.54,11.41 97.18,11.41 97.94,12.17 99.07,12.17 101.96,15.06 110.84,15.06 111.1,15.32 135.45,15.32 135.84,15.71 149.29,15.71 150.29,16.71 v3(151.41,16.71)
PCH_BATLOW#: length 13.2
  TOP w0.095: v8(129.82,46.4) 129.93,46.4 130.56,45.77 130.56,45.42 132.05,43.93 132.05,42.9 133.8,41.15 133.8,40.33 134.18,39.95 v2(134.74,39.95) 135.18,39.95 135.59,40.35 137.47,40.35 137.75,40.07 RC80.1
  BOTTOM w0.112: UCPU1.AU13 130.02,46.4 v8(129.82,46.4)
PCH_DPWROK_EC: length 16.3
  TOP w0.095: UE3.F8 19.1,14.02 v7(18.69,14.43)
  IN1 w0.076: v9(9.16,12.78) 12.26,12.78 12.66,12.38 14.98,12.38 15.14,12.54 15.14,13.04 15.64,13.53 16.5,13.53 16.98,14.01 18.27,14.01 v7(18.69,14.43)
  GND1 w0.095: v3(9.16,13.2) v9(9.16,12.78)
  GND3 w0.095: v4(8.88,12.93) 8.89,12.93 v3(9.16,13.2)
  BOTTOM w0.095: v4(8.88,12.93) v2(8.19,13.62) 7.98,13.82 6.65,13.82 5.86,13.04 RE248.1
PCH_DPWROK_R: length 177.4
  TOP w0.095: 129.59,37.58 v1(129.59,37.63) ; 129.59,37.58 RC92.1 ; 129.59,37.58 130.66,38.65 v11(130.66,39.07)
  IN1 w0.076: v8(14.25,20.75) 14.28,20.75 14.41,20.88 16.06,20.88 16.86,21.68 16.86,21.97 17.49,22.59 18.11,22.59 18.58,23.07 19.62,23.07 20.13,23.58 22.04,23.58 22.86,24.4 23.51,24.4 23.87,24.75 28.56,24.75 28.77,24.54 29.27,24.54 30.4,23.41 34.4,23.41 v9(37.39,20.42)
  GND1 w0.095: v3(129.87,37.96) 129.59,37.68 v1(129.59,37.63) ; v9(37.39,20.42) 37.16,20.65 v3(37.16,20.71)
  IN2 w0.064: v8(78.5,20.2) 78.32,20.01 78.32,16.17 78.89,15.6 78.89,13.62 76.5,11.23 75.19,11.23 74.73,10.77 71.05,10.77 70.34,10.06 60.6,10.06 59.52,11.13 57.8,11.13 57.36,11.57 55.5,11.57 52.89,14.17 45.52,14.17 42.68,17.01 40.67,17.01 38.72,18.96 38.72,19.67 37.69,20.71 v3(37.16,20.71)
  GND3 w0.095: v3(129.87,37.96) 129.87,38.55 v4(130.14,38.82)
  IN4 w0.076: v8(78.5,20.2) 79.09,20.79 79.09,21.91 79.35,22.17 79.35,23.77 81,25.42 81,29.34 81.4,29.75 81.4,30.05 83.99,32.64 102.19,32.64 102.79,33.24 105.81,33.24 106.1,32.95 130.7,32.95 132.37,34.62 132.37,38.16 v5(132.46,38.25)
  BOTTOM w0.095: v5(132.46,38.25) 132.4,38.3 130.65,38.3 v4(130.14,38.82) 130.14,38.95 CC12.1 129.52,39.89 129.52,41.02 129.33,41.21 128.62,41.21 128.02,41.81 127.85,41.81 127.39,42.28 126.87,42.28 126.67,42.47 126.67,43.47 126.6,43.54 UCPU1.BB20 ; RE248.2 6.27,13.95 6.77,14.46 8.05,14.46 10.06,16.47 10.06,18.25 9.55,18.76 9.55,19.58 9.91,19.94 10.68,19.94 10.94,19.68 12.99,19.68 14.06,20.75 v8(14.25,20.75)
PCH_JTAG_TCK: length 18.2
  IN1 w0.076: v8(94.44,67.91) 94.91,68.38 99.6,68.38 100.35,67.63 103.85,67.63 v9(104.68,68.45)
  GND1 w0.095: v3(104.62,68.98) 104.62,68.5 v9(104.68,68.45)
  GND3 w0.095: v4(104.62,69.4) v3(104.62,68.98)
  BOTTOM w0.076: v4(104.62,69.4) 104.64,69.4 105.04,68.99 v2(105.04,68.92) 105.04,68.72 104.91,68.59 104.91,67.57 105.51,66.97 105.51,66.49 105.39,66.36 105.39,66.11 105.42,66.04 105.42,65.88 105.65,65.65 UCPU1.B56
  BOTTOM w0.112: RC238.1 93.28,67.72 RC258.1 94.01,68.08 94.17,67.91 v8(94.44,67.91)
PCH_JTAG_TDI: length 21.9
  TOP w0.095: v7(93.12,70.76) 93.12,70.75 92.88,70.5 91.96,70.5 91.82,70.64 RC234.1
  IN1 w0.076: v7(93.12,70.76) 94.1,70.76 94.62,70.24 96.05,70.24 96.28,70.01 100.89,70.01 101.34,69.56 101.34,69.18 101.63,68.89 102.53,68.89 102.86,69.22 103.84,69.22 104.82,70.2 v9(104.88,70.2)
  GND1 w0.095: v9(104.88,70.2) v3(104.52,70.2)
  GND3 w0.095: v4(104.28,69.94) 104.28,69.96 v3(104.52,70.2)
  BOTTOM w0.076: UCPU1.D59 104.3,64.28 104.66,64.64 104.66,65.24 104.74,65.46 104.74,65.68 104.68,65.87 104.68,65.96 104.74,66.07 104.74,66.46 104.63,66.57 104.63,67.3 104.56,67.37 104.56,68.69 104.12,69.13 104.12,69.83 104.23,69.94 v4(104.28,69.94)
PCH_JTAG_TDO: length 19.7
  TOP w0.095: v7(93.55,71.24) 93.14,71.65 RC255.2 RC233.1
  IN1 w0.076: v9(105.67,69.26) v7(105.67,69.68) 105.67,69.93 105.1,70.5 104.74,70.5 103.68,69.44 102.78,69.44 102.48,69.14 102.14,69.14 101.98,69.29 101.98,69.55 101.26,70.27 96.31,70.27 96.14,70.44 94.71,70.44 94.19,70.96 93.83,70.96 v7(93.55,71.24)
  GND1 w0.095: v9(105.67,69.26) 105.92,69.01 v3(105.92,68.9)
  GND3 w0.095: v4(105.39,68.64) 105.58,68.83 105.86,68.83 v3(105.92,68.9)
  BOTTOM w0.076: v4(105.39,68.64) 105.24,68.49 105.24,67.49 105.68,67.05 105.68,66.25 UCPU1.A56
PCH_JTAG_TMS: length 18
  TOP w0.095: v11(100.98,68.08) 100.98,68.16 v7(100.51,68.63) 99.84,68.63 99.68,68.78 96.57,68.78 95.97,69.38 93.58,69.38 93.12,69.84 RC252.1 92.53,69.87 RC235.1
  IN1 w0.076: v9(103.91,68.66) 103.91,68.57 103.6,68.26 101.02,68.26 100.65,68.63 v7(100.51,68.63)
  GND1 w0.095: v9(103.91,68.66) 104.05,68.8 v3(104.05,68.99)
  GND3 w0.095: v4(104.22,68.6) 104.11,68.71 104.11,68.92 v3(104.05,68.99)
  BOTTOM w0.076: UCPU1.C59 104.3,65.09 104.51,65.29 104.57,65.48 104.57,65.63 104.51,65.82 104.51,66 104.57,66.11 104.57,66.39 104.46,66.5 104.46,67.2 104.38,67.28 104.38,68.43 v4(104.22,68.6)
PCH_JTAG_TRST#: length 7.3
  TOP w0.095: RC236.1 v11(102.28,70.12) 102.28,69.74 102.04,69.49 v1(101.65,69.49)
  GND1 w0.095: v3(101.7,68.97) 101.7,68.97 101.7,69.44 v1(101.65,69.49)
  GND3 w0.095: v4(101.82,68.65) 101.7,68.76 v3(101.7,68.97)
  BOTTOM w0.076: v4(101.82,68.65) 101.82,68.64 101.82,68.11 102.43,67.49 102.43,66.98 102.85,65.83 102.85,65.42 103.18,65.09 UCPU1.C61
PCH_JTAGX: length 27.4
  IN1 w0.076: v9(86.03,72.41) 86.21,72.6 94.14,72.6 94.43,72.31 96.96,72.31 97.65,71.62 102.03,71.62 103.01,70.64 v9(103.67,70.64)
  GND1 w0.095: v3(103.86,70.23) 103.86,70.28 103.72,70.61 v9(103.67,70.64) ; v3(85.79,72.18) v9(86.03,72.41)
  GND3 w0.095: v3(103.86,70.23) 103.86,69.99 103.8,69.93 v4(103.8,69.81) ; v4(87.33,72.68) 86.89,72.24 85.85,72.24 v3(85.79,72.18)
  BOTTOM w0.076: v4(103.8,69.81) 103.93,69.68 103.93,68.43 104.12,68.24 104.12,67.32 104.3,67.14 104.3,66.42 104.3,66.41 UCPU1.A59
  BOTTOM w0.095: v2(86.3,72.02) 86.99,72.02 RC237.1 87.27,72.62 v4(87.33,72.68) 87.72,73.07 RC257.1
PCH_MUTE#: length 227.1
  TOP w0.095: v7(268.71,65.82) 268.11,66.43 D8.1
  IN1 w0.076: v9(155.19,14.79) 155.21,14.82 156.63,14.82 157.07,15.26 163.48,15.26 163.53,15.31 165.26,15.31 165.6,14.97 177.58,14.97 179,13.55 179,13.2 179.83,12.36 181.21,12.36 182.94,10.62 184.48,10.62 186.39,8.72 206.78,8.72 211.84,13.77 221.18,13.77 222.91,12.04 227.29,12.04 230.84,8.5 249.64,8.5 250.71,9.57 253.25,9.57 253.97,10.29 254.52,10.29 256.92,12.7 259.97,12.7 260.43,13.16 260.43,13.44 260.65,13.65 260.65,17.03 263.98,20.36 263.98,24.86 265.82,26.69 265.82,29.8 266.16,30.14 266.16,37.63 266.9,38.37 266.9,41.08 266.96,41.13 266.96,48.62 268.84,50.5 268.84,52.53 268.15,53.22 268.15,58.78 269.29,59.93 269.29,63.6 268.71,64.18 v7(268.71,65.82)
  GND1 w0.095: v9(155.19,14.79) 155.19,14.26 v3(155.22,14.23)
  IN3 w0.064: v3(150.59,19.16) 150.72,19.16 152.22,17.67 152.22,15.14 153.12,14.23 v3(155.22,14.23)
  GND3 w0.095: v6(149.78,19.24) 149.87,19.16 v3(150.59,19.16)
  IN4 w0.076: v5(140.28,52.63) 140.76,52.16 140.76,51.61 141.47,50.9 141.47,49.94 141.79,49.62 142.39,49.62 142.95,49.05 142.95,48.08 143.25,47.78 143.25,46.62 142.54,45.92 142.54,41.45 144.63,39.37 146.28,39.37 147.68,37.96 147.68,35.55 147.43,35.3 147.43,33.53 147.95,33.02 147.95,30.68 148.19,30.45 148.19,30.45 148.19,30.45 149.19,29.44 149.2,29.44 149.65,28.99 149.65,23.21 149.42,22.97 149.42,19.69 149.78,19.32 v6(149.78,19.24)
  BOTTOM w0.076: UCPU1.AC3 136.04,54.09 136.34,53.79 136.4,53.79 136.51,53.68 137.02,53.68 137.03,53.67 137.43,53.67 137.56,53.74 137.73,53.74 137.81,53.65 139.14,53.65 139.61,53.18 139.78,53.18 v2(139.9,53.05) 140.28,52.67 v5(140.28,52.63)
PCH_PCIE_WAKE#: length 246.5
  TOP w0.095: v7(26.13,42.66) 26.84,42.66 28.15,43.96 28.15,44.86 29.87,46.59 RT432.1 28.61,48.79 28.61,49.19 29.19,49.77 29.19,51.87 29.34,52.03 29.34,53.17 28.21,54.3 27.75,54.3 RT429.2 27.71,54.49 RC396.2 ; v1(131.95,41.56) 131.46,41.56 RC73.2 ; v2(11.73,26.19) RE186.2 10.73,26.78 v1(10.42,27.1) ; UE3.L1 v8(25.37,18.02)
  IN1 w0.076: v7(26.13,42.66) 24.17,40.7 21.31,40.7 19.84,39.23 19.84,38.34 17.77,36.28 16.38,36.28 16.17,36.06 15.57,36.06 15.24,35.73 14.32,35.73 14.11,35.94 12.21,35.94 11.93,36.21 v9(11.9,36.21)
  GND1 w0.095: v9(11.9,36.21) 11.55,35.86 v3(11.18,35.86) ; v3(132.29,41.51) 132.24,41.56 v1(131.95,41.56) ; v1(10.42,27.1) 10.8,27.48 v3(10.8,27.51)
  IN2 w0.064: v8(25.37,18.02) 25.34,18.05 24.65,18.05 24.19,17.58 24.19,17.28 24.71,16.76 25.39,16.76 25.51,16.88 25.54,16.88 26.21,16.88 26.8,16.29 29.37,16.29 29.77,16.68 30.55,16.68 31.21,16.02 31.21,14.25 34.41,11.05 38.98,11.05 39.2,11.27 40.01,11.27 v3(40.3,10.98)
  IN3 w0.064: v3(11.18,35.86) 11.18,35.33 10.28,34.44 10.28,30.3 11.04,29.55 11.04,28.26 10.8,28.02 v3(10.8,27.51) 11.35,27.51 12.53,26.32 16.4,26.32 18.99,23.73 18.99,23.22 20.87,21.34 22.18,21.34 25.37,18.16 v8(25.37,18.02) ; v3(132.29,41.51) 132.19,41.41 132.19,39.93 132.92,39.19 138.31,39.19 141.79,35.71 141.94,35.71 144.31,33.33 144.96,33.33 146.43,31.87 147.48,31.87 150.02,29.34 150.02,23.53 148.86,22.38 148.86,16.62 148,15.75 144.27,15.75 143.93,15.41 116.77,15.41 116.04,14.68 110.99,14.68 108.78,12.46 100.75,12.46 97.9,15.31 88.6,15.31 88.16,15.75 84.13,15.75 80.37,12 76.95,12 74.17,9.22 60.76,9.22 59.88,10.09 48.04,10.09 47.48,10.64 42.89,10.64 42.56,10.97 42.11,10.97 41.72,11.37 40.69,11.37 v3(40.3,10.98)
  GND3 w0.095: v4(131.98,41.35) 132.15,41.35 132.29,41.49 v3(132.29,41.51)
  BOTTOM w0.076: v4(131.98,41.35) 131.71,41.62 130.52,41.62 129.39,42.76 129.23,42.76 129.02,42.96 129.02,43.59 UCPU1.BB15
PCH_PLTRST#: length 22.2
  TOP w0.095: UC2.1 145.31,49.57 145.75,49.14 v7(145.75,49.11) ; v7(145.75,49.11) 145.96,49.33 UC2.2 ; v7(145.75,49.11) v2(144.46,49.11)
  IN1 w0.076: v7(145.75,49.11) 145.15,49.7 142.03,49.7 140.48,51.25 139.94,51.25 138.18,49.49 136.22,49.49 135.61,50.1 134.04,50.1 133.85,50.29 131.85,50.29 131.22,49.66 131.22,49.28 131.59,48.92 v8(131.7,48.92)
  BOTTOM w0.112: UCPU1.AN10 132.1,49.31 v8(131.7,48.92)
PCH_PLTRST#_5105: length 7.6
  TOP w0.095: UE3.K1 v8(25.21,17.22)
  IN2 w0.064: v8(25.21,17.22) 25.32,17.32 26.53,17.32 26.75,17.11 v3(29.73,17.11)
  GND3 w0.095: v4(30.1,17.11) v3(29.73,17.11)
  BOTTOM w0.095: RE183.1 29.99,18.11 30.1,17.99 v4(30.1,17.11) 30.08,17.08 UE5.4
PCH_PLTRST#_EC: length 693.5
  TOP w0.095: UC2.4 146.61,51.42 147.17,50.86 RC76.1 147.63,50.86 148.45,50.04 148.45,46.07 149.22,45.3 158.61,45.3 160.24,43.66 160.24,39.87 163.83,36.28 163.83,28.24 161.96,26.37 161.96,16.63 163.44,15.15 163.44,12.99 162.37,11.92 v1(161.57,11.92) ; v1(22.54,54.89) 22.84,54.6 R164.1 ; RE193.2 8.18,5.51 8.56,5.13 v8(8.56,4.74)
  IN1 w0.076: v9(36.67,38.98) 36.61,38.98 35.37,40.22 35.37,40.95 34.84,41.49 34.84,42.19 33.82,43.2 33.01,43.2 31.64,44.58 31.64,56.39 29.28,58.75 25.24,58.75 22.54,56.06 v1(22.54,54.89) ; v9(280.5,28.62) 280.5,40.2 280.66,40.37 280.66,43.15 279.7,44.11 279.7,49.28 281.36,50.93 v9(282.79,50.93)
  GND1 w0.095: v9(280.5,28.62) 280.23,28.62 v3(280.13,28.51) ; v9(282.79,50.93) 282.8,50.92 v3(283.18,50.92) ; v3(37.01,38.84) 36.87,38.98 v9(36.67,38.98) ; v1(161.57,11.92) v3(161.24,11.92)
  IN2 w0.064: v8(8.56,4.74) 9.86,3.44 19.69,3.44 19.87,3.26 23.22,3.26 25.35,1.12 77.67,1.12 81.01,4.47 108.82,4.47 111.98,1.3 128.15,1.3 129.31,2.47 130.96,2.47 132.12,1.3 132.83,1.3 132.83,1.3 152.55,1.3 152.55,1.3 154.19,1.3 155.47,2.58 160.19,2.58 161.26,1.51 166.19,1.51 166.23,1.55 166.91,2.24 166.92,2.24 167.01,2.33 182.57,2.33 183.67,1.23 221.51,1.23 222.88,2.6 225.42,2.6 226.76,1.25 262.49,1.25 268.54,7.31 268.54,7.87 269.47,8.8 270.03,8.8 272.6,11.36 274.74,11.36 278.9,15.53 278.9,18 278.9,18 278.9,18.1 279.78,18.98 279.78,23.42 279.11,24.09 279.11,26.76 280.13,27.78 v3(280.13,28.51) 280.86,28.51 282.16,29.81 289.79,29.81 v8(289.87,29.72) ; v3(37.01,38.84) 37.01,38.15 38.44,36.73 38.44,28.92 39.17,28.19 39.17,26.07 37.46,24.36 37.46,23.05 37.67,22.84 37.97,22.84 38.56,22.25 38.56,21.03 39.89,19.7 39.89,19.5 40.22,19.18 41.69,19.18 45.01,15.85 53.3,15.85 55.99,13.16 61.62,13.16 62.21,12.58 65.11,12.58 66.8,10.88 70,10.88 70.71,11.6 74.38,11.6 76.24,13.45 76.24,21.1 75.84,21.5 75.84,22.71 76.98,23.84 77.85,23.84 79.83,25.83 79.83,29.33 79.41,29.76 v8(79.41,30.36) ; v3(161.24,11.92) 160.5,12.65 159.62,12.65 156.31,15.96 154.7,15.96 154.07,16.59 154.07,17.61 154.05,17.61 152.91,18.75 152.91,26.18 151.57,27.52 151.57,28.84 150.6,29.81 v3(150.6,30.17)
  IN3 w0.064: v3(28.13,15.11) 28.13,14.59 27.59,14.05 27.59,12.81 26.93,12.15 26.93,12.02 25.84,10.94 25.84,10.35 25.96,10.23 25.96,9.8 25.25,9.09 21.83,9.09 21.68,8.94 14.07,8.94 13.8,8.67 12.6,8.67 10.88,6.96 10.88,5.93 10.26,5.32 9.13,5.32 v8(8.56,4.74)
  GND3 w0.095: v3(283.18,50.92) 283.18,50.96 283.23,51.02 283.23,51.08 283.56,51.41 283.7,51.41 283.86,51.57 v4(284.12,51.57) ; v4(36.81,38.55) 36.81,38.64 v3(37.01,38.84) ; v4(28.84,15.29) 28.32,15.29 v3(28.13,15.11) ; v3(150.6,30.17) v4(151.01,30.17) ; v6(161.59,11.96) 161.54,11.92 v3(161.24,11.92)
  IN4 w0.076: v8(79.41,30.36) 79.41,30.61 83.28,34.48 101.48,34.48 102.13,35.12 123.93,35.12 v5(124.4,34.65) ; v5(174.35,15.64) 173.1,14.39 166.54,14.39 164.99,12.84 162.63,12.84 161.75,11.96 v6(161.59,11.96) ; v5(32.37,25.53) 32.34,25.5 32.34,23.95 31.47,23.08 31.47,21.14 30.76,20.43 30.76,19.53 32.17,18.13 32.17,16.66 30.8,15.29 v4(28.84,15.29)
  BOTTOM w0.095: UR1.1 289.87,31.1 290.21,30.76 290.21,30.06 v8(289.87,29.72) ; v5(124.4,34.65) 133.34,34.65 135.22,32.77 138.94,32.77 139.88,31.82 143.35,31.82 145.01,33.48 145.99,33.48 146.69,32.77 146.69,31.97 148.83,29.83 148.83,28.6 149.21,28.21 150.03,28.21 150.69,28.87 150.69,29.85 v4(151.01,30.17) 151.24,29.95 JNGFF1.50 ; UE5.2 30.14,14.49 29.98,14.34 29.41,14.34 28.84,14.91 v4(28.84,15.29) ; v4(36.81,38.55) 36.48,38.23 36.48,32.55 35.22,31.28 35.22,29.37 34.08,28.23 34.08,25.97 33.64,25.53 v5(32.37,25.53)
PCH_POPIRCOMP: length 2.7
  TOP w0.305: RC107.1 127.99,44.87 v2(127.99,45.46) 127.99,46.31 v8(127.93,46.37)
  BOTTOM w0.254: UCPU1.AU16 128.19,46.4 127.96,46.4 v8(127.93,46.37)
PCH_PWR_EN: length 13.3
  TOP w0.095: v2(153.56,24.64) 153.28,24.37 v7(152.87,24.37) 152.87,23.87 R85.2 153.22,23.06 153.22,23.06 R91.2 R90.2 ; U11.3 v7(152.56,33.33)
  IN1 w0.076: v7(152.87,24.37) 152.87,24.45 152.65,24.66 152.65,33.24 v7(152.56,33.33)
PCH_RSMRST#: length 209.3
  TOP w0.095: v7(35.42,60.56) 39.07,60.56 v2(39.4,60.9) RC250.1
  IN1 w0.076: v9(35.36,41.66) 35.3,41.73 35.3,42.41 34.04,43.66 33.29,43.66 32.09,44.86 32.09,54.75 35.42,58.08 v7(35.42,60.56)
  GND1 w0.095: v9(35.36,41.66) 35.36,41.38 35.4,41.34 v3(35.4,41.3)
  IN2 w0.064: v3(35.4,41.3) 35.4,39.33 35.75,38.99 35.75,35.67 36.51,34.91 36.51,34.04 37.03,33.52 37.03,28.71 37.3,28.44 37.3,26.05 34.91,23.66 32.16,23.66 31.73,23.22 28.93,23.22 27.8,22.09 27.8,21.22 28.08,20.94 28.78,20.94 29.37,20.35 v3(29.44,20.35) 29.56,20.35 30.43,21.22 31.33,21.22 32.32,20.23 33.97,20.23 39.66,14.55 42.42,14.55 45.05,11.91 52.56,11.91 54.75,9.73 56.46,9.73 57.24,8.94 70.76,8.94 70.9,9.08 74.57,9.08 75.64,10.15 76.95,10.15 80.13,13.32 80.13,15.91 81.51,17.29 81.51,25.15 82.16,25.8 82.16,30.19 81.99,30.36 v8(79.99,30.36)
  GND3 w0.095: v3(29.44,20.35) 29.12,20.35 v4(28.88,20.58)
  IN4 w0.076: v5(130.23,39.75) 130.23,39.73 130.43,39.53 130.43,34.99 129.74,34.3 106.66,34.3 106.37,34.59 102.23,34.59 101.67,34.03 83.47,34.03 79.99,30.55 v8(79.99,30.36)
  BOTTOM w0.095: v5(130.23,39.75) 130.28,39.79 130.28,40.54 129.42,41.39 128.7,41.39 128.09,42 127.93,42 127.66,42.26 127.66,43 127.53,43.14 127.53,44.5 127.82,44.8 UCPU1.AY17 ; v4(28.88,20.58) 29.33,20.58 29.43,20.68 RE155.1 29.3,20.91 28.41,20.91 28.31,20.81 RE177.2
PCH_RTCRST#: length 242.1
  TOP w0.095: JAPS1.9 160.18,31.71 160,31.53 v7(159.49,31.53) 159.49,31.24 v11(159.2,30.94) ; v8(9.25,4.77) 9.08,4.94 RE171.2
  IN1 w0.076: v9(147.77,36.34) 148.46,35.64 153.34,35.64 157.46,31.53 v7(159.49,31.53)
  GND1 w0.095: v3(147.31,36.46) 147.55,36.46 147.68,36.34 v9(147.77,36.34)
  IN2 w0.064: v3(30.59,20.12) 31.19,20.12 31.84,19.47 32.55,19.47 35.41,16.61 35.41,16.54 38.68,13.27 42.26,13.27 44.66,10.87 52.17,10.87 54.85,8.18 71.07,8.18 71.21,8.32 76.25,8.32 78.9,10.97 98.16,10.97 98.31,11.12 98.31,11.53 98.5,11.72 99.29,11.72 102.18,14.61 111.2,14.61 111.43,14.84 135.7,14.84 136.14,15.27 150.48,15.27 151.77,16.56 151.77,17.37 151.13,18.01 151.13,24.52 149.7,25.95 149.7,27.96 v3(149.25,28.4)
  IN3 w0.064: v8(9.25,4.77) 10.71,3.31 27.14,3.31 27.73,3.89 27.73,6.73 28.65,7.65 28.65,10.02 28.35,10.31 28.35,11.87 28.95,12.46 28.95,14.08 29.1,14.23 29.1,15.58 28.95,15.74 28.95,17.68 30.59,19.32 v3(30.59,20.12)
  GND3 w0.095: v4(149.26,28.92) 149.26,28.62 149.25,28.61 v3(149.25,28.4) ; v3(147.31,36.46) 146.76,37.02 v4(145.75,37.02)
  IN4 w0.076: v5(128.5,49.96) 128.75,49.96 129.05,50.26 129.61,50.26 129.85,50.02 130.56,50.02 131.05,50.52 134.01,50.52 134.61,49.92 134.69,49.92 137.59,47.01 137.59,45.21 139.83,42.98 139.83,42.14 140.36,41.6 140.36,40.79 140.52,40.63 140.52,40.61 143.53,37.6 143.56,37.6 144.15,37.02 v4(145.75,37.02)
  BOTTOM w0.095: CMOS1.1 150.18,39.1 CC11.1 149.39,39 RC71.1 149.21,38.39 148.22,37.39 145.84,37.39 145.75,37.3 v4(145.75,37.02) 146.06,36.7 147.23,36.7 147.89,36.05 147.89,31.85 149.42,30.32 149.42,29.08 v4(149.26,28.92)
PCH_RTCX1: length 21.1
  TOP w0.095: YC2.1 138.84,36.8 138.08,37.56 138.08,37.89 CC8.1 137.63,38.33 137.63,39.3 137.12,39.81 v7(137.12,39.83)
  IN1 w0.076: v7(137.12,39.83) 136.92,40.04 136.92,41.14 136.12,41.94 135.41,41.94 132.4,44.94 130.45,44.94 130.33,44.83 129.47,44.83 128.96,45.33 128.96,46.14 128.36,46.74 127.85,46.74 127.62,46.97 127.62,49.13 v8(128.03,49.53)
  BOTTOM w0.112: UCPU1.AM18 128.02,49.53 v8(128.03,49.53)
PCH_RTCX2: length 17.5
  TOP w0.095: RC69.1 136.2,39.82 v7(136.21,39.83)
  IN1 w0.076: v8(127.13,49.6) 127.13,49.45 127.46,49.12 127.46,46.76 127.52,46.7 127.52,46.12 129.28,44.36 130.6,44.36 130.73,44.48 132.21,44.48 135.22,41.48 135.92,41.48 136.33,41.07 136.33,39.95 v7(136.21,39.83)
  BOTTOM w0.112: UCPU1.AM20 127.04,49.6 v8(127.13,49.6)
PCH_RTCX2_R: length 2.8
  TOP w0.095: RC69.2 137.11,38.45 137.09,38.42 CC10.1 137.09,37.52 136.34,36.78 YC2.2
PCH_RTD3_CIO_PWR_EN: length 6.3
  BOTTOM w0.076: RC115.1 140.48,60.47 140.19,60.19 v2(139.52,60.19) 138.75,60.19 137.83,61.11 137.67,61.11 137.61,61.04 135.41,61.04 UCPU1.H5
PCH_SMB_ALERT#: length 10.2
  TOP w0.095: v8(132.62,58.86) 133.05,58.43 134.98,58.43 135.4,58.85 136.48,58.85 136.73,58.6 v2(137.35,58.6) 140.07,58.6 RC26.1
  BOTTOM w0.112: v8(132.62,58.86) 132.62,58.63 UCPU1.R10
PCH_SPI_CLK: length 53.4
  IN1 w0.076: v8(165.29,31.31) 165.29,31.37 165.71,31.79 165.71,32.67 164.88,33.5 163.93,33.5 162.47,34.96 162.16,34.96 161.91,35.21 161.43,35.21 159.69,36.95 158.74,36.95 153.02,42.66 149.89,42.66 147,39.77 142.69,39.77 141.16,41.29 141.16,43.93 140.95,44.14 140.95,46.25 v9(141.04,46.34)
  GND1 w0.095: v9(141.04,46.34) 141.2,46.49 v3(141.2,46.71)
  GND3 w0.095: v4(140.87,46.61) 140.87,46.62 140.97,46.71 v3(141.2,46.71)
  BOTTOM w0.076: UCPU1.AV2 136.64,46.11 136.9,46.36 138.63,46.36 138.85,46.15 140.4,46.15 v4(140.87,46.61)
  BOTTOM w0.095: RC32.1 169.2,25.64 168.82,26.02 168.82,29.6 167.31,31.11 165.5,31.11 v8(165.29,31.31) 164.9,31.31 164.37,30.78 JSPI1.8
PCH_SPI_CLK_R: length 31.4
  IN2 w0.064: v8(167.86,41.97) 167.5,42.33 164.94,42.33 164.86,42.41 164.86,42.65 164.96,42.74 168.26,42.74 168.37,42.64 168.37,40.26 167.49,39.38 167.49,34.75 167.82,34.41 167.82,29.82 v8(167.8,29.79)
  BOTTOM w0.095: JSPI1.7 164.56,30.28 164.9,30.62 165.76,30.62 166.97,30.62 v8(167.8,29.79) 168.28,29.31 RC32.2 ; RP1.6 168.13,41.7 v8(167.86,41.97) 167.86,41.99 168.06,42.2 RP1.7
PCH_SPI_CLK_TPM: length 2.8
  IN4 w0.076: v5(169.64,41.7) 169.97,41.38 169.97,39.49 v5(170.27,39.19)
PCH_SPI_CLK_TPM_R: length 41.2
  IN2 w0.064: v3(169.78,40.1) 168.57,38.89 168.57,35.2 168.91,34.85 168.91,21.86 171.35,19.42 172.94,19.42 173.11,19.25 173.2,19.25 173.68,19.73 173.77,19.73 173.86,19.64 173.86,19.55 173.38,19.07 173.38,18.98 173.47,18.89 173.56,18.89 174.04,19.37 174.13,19.37 174.22,19.28 174.22,19.19 173.74,18.71 173.74,18.62 173.83,18.53 173.92,18.53 174.4,19.01 174.49,19.01 174.58,18.92 174.58,18.83 174.1,18.35 174.1,18.26 174.19,18.17 174.28,18.17 174.76,18.65 174.85,18.65 174.94,18.56 174.94,18.47 174.46,17.99 174.46,17.9 174.55,17.81 174.64,17.81 175.12,18.29 175.21,18.29 175.3,18.2 175.3,18.11 174.82,17.63 174.82,17.54 174.91,17.45 175,17.45 175.48,17.93 175.57,17.93 175.66,17.84 175.66,17.75 175.18,17.27 175.18,17.18 176.58,15.78 v3(176.58,15.4)
  GND3 w0.095: v4(170.27,40.1) v3(169.78,40.1) ; v3(176.58,15.4) v4(176.24,15.4)
  BOTTOM w0.095: v4(176.24,15.4) C32.1 174.74,14.64 U7.19
PCH_SPI_CS0#: length 62.3
  IN1 w0.076: v8(165.28,32.2) 164.99,32.49 164.89,32.49 164.81,32.42 164.81,31.24 164.73,31.17 164.58,31.17 164.5,31.24 164.5,32.91 164.43,32.98 164.28,32.98 164.2,32.91 164.2,31.24 164.12,31.17 163.68,31.17 163.48,31.37 163.48,31.48 163.59,31.59 163.78,31.59 163.91,31.73 163.91,32.65 163.01,33.56 162.96,33.56 162.82,33.69 162.82,33.92 162.75,33.99 162.55,33.99 162.48,33.93 162.48,33.68 162.36,33.56 162.22,33.56 162.14,33.64 162.14,34.38 162.07,34.46 161.91,34.46 161.84,34.38 161.84,33.64 161.76,33.56 161.61,33.56 161.53,33.64 161.53,34.38 161.46,34.46 161.3,34.46 161.23,34.38 161.23,33.93 161.11,33.81 160.99,33.81 160.89,33.92 160.89,35.1 159.5,36.49 158.52,36.49 152.89,42.12 150.03,42.12 147.23,39.32 142.5,39.32 140.71,41.11 140.71,43.57 140.31,43.96 v9(140.31,46.34)
  GND1 w0.095: v9(140.31,46.34) 140.31,46.63 v3(140.21,46.73)
  GND3 w0.095: v3(140.21,46.73) 140.17,46.69 140.1,46.69 v4(139.94,46.53)
  BOTTOM w0.076: v4(139.94,46.53) 139.92,46.53 139.69,46.31 138.92,46.31 138.7,46.53 136.68,46.53 136.41,46.8 UCPU1.AU3
  BOTTOM w0.095: RC33.1 167.47,39 167.56,38.9 167.56,36.51 165.28,34.23 v8(165.28,32.2) 164.59,32.2 164.17,31.78 JSPI1.10
PCH_SPI_CS0#_R: length 38.9
  TOP w0.095: v8(167.35,40.42) v11(167.35,39.73)
  IN2 w0.064: v8(167.35,40.42) 166.24,40.42 166.17,40.35 166.17,39.11 166.11,39.05 165.98,39.05 165.92,39.11 165.92,40.35 165.86,40.42 165.73,40.42 165.67,40.35 165.67,39.11 165.6,39.05 165.48,39.05 165.41,39.11 165.41,40.35 165.35,40.42 165.22,40.42 165.16,40.35 165.16,39.11 165.1,39.05 164.97,39.05 164.9,39.11 164.9,40.35 164.84,40.42 164.71,40.42 164.65,40.35 164.65,39.11 164.59,39.05 164.46,39.05 164.4,39.11 164.4,40.35 164.33,40.42 163.82,40.42 161.15,43.09 v3(161.15,43.87)
  GND3 w0.095: v3(161.15,43.87) 161.03,44 v6(160.85,44)
  IN4 w0.076: v5(157.02,41.91) 157.02,42.79 158.74,44.51 160.34,44.51 v6(160.85,44)
  BOTTOM w0.095: v5(157.02,41.91) 157.02,41.91 U1.1 ; v8(167.35,40.42) 166.92,40.42 166.48,39.98 RC33.2 166.64,39.91 167.25,39.3 167.54,39.3 167.92,38.92 167.92,36.44 165.51,34.03 165.51,33 165.75,32.76 165.75,32.05 165.49,31.79 164.66,31.79 164.15,31.28 JSPI1.9
PCH_SPI_CS2#: length 114.6
  IN1 w0.076: v9(166.18,34.47) 165.88,34.47 165.69,34.28 164.1,34.28 162.65,35.73 162.49,35.73 160.34,37.88 160.34,37.88 160.15,38.07 159.2,38.07 156.38,40.89 156.38,43.33 154.26,45.45 152.78,45.45 152.7,45.53 152.7,46.07 152.63,46.15 152.47,46.15 152.4,46.07 152.4,45.53 152.32,45.45 152.17,45.45 152.09,45.53 152.09,46.07 152.02,46.15 151.86,46.15 151.79,46.07 151.79,45.53 151.71,45.45 150.15,45.45 149.97,45.27 148.24,45.27 146.84,46.68 146.84,47.61 146.73,47.72 146.52,47.72 146.45,47.64 146.45,46.19 146.37,46.11 146.22,46.11 146.14,46.19 146.14,47.64 146.07,47.72 145.91,47.72 145.84,47.64 145.84,46.22 145.76,46.14 145.61,46.14 145.53,46.22 145.53,47.64 145.46,47.72 145.31,47.72 145.23,47.64 145.23,46.2 145.15,46.12 145,46.12 144.92,46.2 144.92,47.64 144.85,47.72 144.7,47.72 144.62,47.64 144.62,46.19 144.54,46.11 144.39,46.11 144.31,46.19 144.31,47.64 144.24,47.72 144.07,47.72 143.76,48.03 143.56,48.03 143.48,48.1 143.48,48.3 143.41,48.37 143.25,48.37 143.18,48.3 143.18,47.89 143.1,47.81 142.95,47.81 142.87,47.89 142.87,48.3 142.8,48.37 142.64,48.37 142.57,48.3 142.57,47.78 142.49,47.7 142.34,47.7 142.26,47.78 142.26,48.3 142.19,48.37 142.03,48.37 141.96,48.3 141.96,47.77 141.88,47.7 141.68,47.7 141.6,47.77 141.6,48.24 141.53,48.31 141.19,48.31 141.12,48.24 141.12,47.79 141.88,47.02 141.88,46.79 141.81,46.71 140.1,46.71 140.02,46.63 140.02,46.07 139.9,45.96 139.69,45.96 139.62,46.03 139.62,46.57 139.54,46.64 139.39,46.64 139.31,46.57 139.31,46.04 139.24,45.96 139.07,45.96 138.96,46.07 138.96,46.8 139.14,46.98 v9(139.59,46.98)
  GND1 w0.095: v9(166.18,34.47) v3(166.18,34.85) ; v3(139.42,46.65) 139.42,46.82 v9(139.59,46.98)
  IN2 w0.064: v3(166.18,34.85) 166.6,34.42 166.6,32.45 166.92,32.13 166.92,31.07 166.72,30.88 166.72,23.65 166.66,23.59 166.03,23.59 165.97,23.52 165.97,23.4 166.03,23.33 166.66,23.33 166.72,23.27 166.72,23.14 166.66,23.08 166.03,23.08 165.97,23.01 165.97,22.89 166.03,22.82 166.66,22.82 166.72,22.76 166.72,22.63 166.66,22.57 166.03,22.57 165.97,22.51 165.97,22.38 166.03,22.32 166.66,22.32 166.72,22.25 166.72,22.02 166.93,21.82 166.93,21.73 166.16,20.96 166.16,20.87 166.25,20.78 166.33,20.78 167.11,21.55 167.2,21.55 167.29,21.46 167.29,21.37 166.51,20.6 166.51,20.51 166.6,20.42 166.69,20.42 167.47,21.19 167.56,21.19 167.65,21.1 167.65,21.01 166.87,20.24 166.87,20.15 166.96,20.06 167.05,20.06 167.83,20.83 167.92,20.83 168.01,20.74 168.01,20.65 167.23,19.88 167.23,19.79 167.32,19.7 167.41,19.7 168.19,20.47 168.27,20.47 168.36,20.38 168.36,20.29 167.59,19.52 167.59,19.43 167.68,19.34 167.77,19.34 168.54,20.11 168.63,20.11 168.72,20.02 168.72,19.93 167.95,19.16 167.95,19.07 168.04,18.98 168.13,18.98 168.9,19.75 168.99,19.75 169.08,19.66 169.08,19.57 168.31,18.8 168.31,18.71 168.4,18.62 168.49,18.62 169.26,19.39 169.35,19.39 169.44,19.3 169.44,19.21 168.67,18.44 168.67,18.35 168.76,18.26 168.85,18.26 169.62,19.03 169.71,19.03 169.8,18.94 169.8,18.85 169.03,18.08 169.03,17.99 169.12,17.9 169.21,17.9 169.98,18.67 170.07,18.67 170.16,18.58 170.16,18.49 169.39,17.72 169.39,17.63 169.48,17.54 169.57,17.54 170.34,18.31 170.43,18.31 170.79,17.95 170.96,17.95 v3(171.22,17.7)
  GND3 w0.095: v4(171.48,17.43) v3(171.22,17.7) ; v4(139.06,46.65) v3(139.42,46.65)
  IN4 w0.076: v5(176.43,14.78) 175.9,14.78 174.63,16.05 172.86,16.05 v4(171.48,17.43)
  BOTTOM w0.076: v4(139.06,46.65) 139.02,46.69 138.77,46.69 138.77,46.69 137.67,46.69 UCPU1.AU1
PCH_SPI_CS2#_R: length 1.5
  BOTTOM w0.095: RE262.2 175.1,14.14 U7.20
PCH_SPI_IO2: length 53.6
  IN1 w0.076: v8(139.85,45.53) 140.07,45.31 140.07,43.71 140.5,43.28 140.5,41.02 142.41,39.11 147.31,39.11 150.09,41.89 152.79,41.89 158.39,36.29 159.37,36.29 160.17,35.49 160.17,34 160.32,33.86 160.65,33.86 161.15,33.36 162.92,33.36 163.47,32.82 v9(163.47,32)
  GND1 w0.095: v3(163.12,32.34) v9(163.47,32)
  GND3 w0.095: v4(162.73,32) 162.78,32 v3(163.12,32.34)
  BOTTOM w0.076: RH61.2 140.73,45.22 ; UCPU1.AW2 137.42,45.07 137.79,45.07
  BOTTOM w0.095: RH61.2 140.16,45.19 139.85,45.5 v8(139.85,45.53) 139.8,45.53 139.34,45.07 137.79,45.07 ; RC34.1 165.15,38.54 164.8,38.2 164.8,33.26 164.33,32.78 JSPI1.12 163.13,32.78 162.73,32.38 v4(162.73,32) ; RC243.1 143.65,46.38 143.32,46.38 v2(143.07,46.13) 142.88,45.94 141.45,45.94 140.73,45.22
PCH_SPI_IO2_R: length 35.7
  IN4 w0.076: v5(165.15,39.9) 164.95,39.9 164.63,40.22 164.63,40.61 164.71,40.68 165.39,40.68 165.47,40.76 165.47,40.91 165.39,40.99 164.71,40.99 164.63,41.06 164.63,41.22 164.71,41.29 165.39,41.29 165.47,41.37 165.47,41.52 165.39,41.6 164.71,41.6 164.63,41.67 164.63,41.83 164.71,41.9 165.39,41.9 165.47,41.98 165.47,42.13 165.39,42.21 164.71,42.21 164.63,42.28 164.63,42.43 164.71,42.51 165.39,42.51 165.47,42.59 165.47,42.74 165.39,42.82 164.71,42.82 164.63,42.89 164.63,43.04 164.71,43.12 165.39,43.12 165.47,43.2 165.47,43.35 165.39,43.43 164.71,43.43 164.63,43.5 164.63,43.65 164.71,43.73 165.39,43.73 165.47,43.81 165.47,43.96 165.39,44.03 164.71,44.03 164.63,44.11 164.63,44.26 164.71,44.34 165.39,44.34 165.47,44.42 165.47,44.57 165.39,44.64 164.71,44.64 164.63,44.72 164.63,44.87 164.71,44.95 165.39,44.95 165.47,45.03 165.47,45.18 165.39,45.25 164.71,45.25 164.63,45.33 164.63,45.48 164.71,45.56 165.39,45.56 165.47,45.64 165.47,45.79 165.39,45.86 164.71,45.86 164.63,45.94 164.63,46.09 164.71,46.17 165.04,46.17 165.11,46.24 165.11,46.4 165.04,46.47 164.71,46.47 164.63,46.55 164.63,47.33 163.23,48.72 161.2,48.72 160.95,48.97 v5(160.95,49.17)
  BOTTOM w0.095: v5(165.15,39.9) 165.35,39.9 165.61,39.63 165.61,38.41 165.04,37.84 165.04,33.08 164.25,32.28 JSPI1.11
PCH_SPI_IO3: length 48.2
  TOP w0.095: RH63.2 RH62.2 140.07,44 v1(139.74,44)
  IN1 w0.076: v9(162.28,32.87) 162.01,33.13 161.08,33.13 160.7,33.51 160.22,33.51 159.97,33.77 159.97,35.4 159.29,36.09 158.3,36.09 152.7,41.69 150.18,41.69 147.37,38.88 142.32,38.88 140.3,40.9 140.3,43.11 139.74,43.66 v1(139.74,44)
  GND1 w0.095: v3(139.39,44.04) 139.44,44 v1(139.74,44) ; v9(162.28,32.87) 162.42,32.87 162.6,33.04 v3(162.73,33.04)
  GND3 w0.095: v4(139.22,44.36) 139.24,44.36 139.35,44.25 139.35,44.08 v3(139.39,44.04) ; v4(162.62,33.44) 162.62,33.14 162.71,33.04 v3(162.73,33.04)
  BOTTOM w0.076: UCPU1.AU4 135.72,46.69 135.72,46.3 135.63,46.2 135.63,45.7 136.16,45.17 137.03,45.17 137.25,44.95 137.25,44.51 137.35,44.41 139.17,44.41 v4(139.22,44.36)
  BOTTOM w0.095: v4(162.62,33.44) 162.96,33.78 JSPI1.14 164.12,33.78 164.29,33.95 164.29,37.79 163.93,38.15 RC35.1
PCH_SPI_IO3_R: length 34.3
  IN4 w0.076: v5(160.45,49.17) 160.45,48.97 161.08,48.34 162.09,48.34 162.47,47.96 162.47,47.85 162.12,47.5 162.12,47.4 162.23,47.29 162.34,47.29 162.69,47.64 162.8,47.64 162.91,47.53 162.91,47.42 162.59,47.11 162.59,47 162.7,46.89 162.81,46.89 163.12,47.21 163.23,47.21 163.34,47.1 163.34,46.99 163.2,46.86 163.2,46.75 163.31,46.64 163.42,46.64 163.55,46.77 163.66,46.77 163.93,46.5 163.93,46.09 163.85,46.01 163.29,46.01 163.21,45.94 163.21,45.79 163.29,45.71 163.85,45.71 163.93,45.63 163.93,45.48 163.85,45.4 163.29,45.4 163.21,45.33 163.21,45.18 163.29,45.1 163.85,45.1 163.93,45.02 163.93,44.87 163.85,44.79 163.29,44.79 163.21,44.72 163.21,44.57 163.29,44.49 163.85,44.49 163.93,44.41 163.93,44.26 163.85,44.18 163.29,44.18 163.21,44.11 163.21,43.96 163.29,43.88 163.85,43.88 163.93,43.8 163.93,43.65 163.85,43.58 163.29,43.58 163.21,43.5 163.21,43.35 163.29,43.27 163.85,43.27 163.93,43.19 163.93,43.04 163.85,42.97 163.29,42.97 163.21,42.89 163.21,42.74 163.29,42.66 163.85,42.66 163.93,42.58 163.93,42.43 163.85,42.36 163.29,42.36 163.21,42.28 163.21,42.13 163.29,42.05 163.85,42.05 163.93,41.98 163.93,41.82 163.85,41.75 163.29,41.75 163.21,41.67 163.21,41.52 163.29,41.44 163.85,41.44 163.93,41.37 163.93,41.21 163.85,41.14 163.29,41.14 163.21,41.06 163.21,40.91 163.29,40.83 163.85,40.83 163.93,40.76 163.93,40.6 163.85,40.53 163.29,40.53 163.21,40.45 163.21,40.3 163.29,40.22 163.85,40.22 163.93,40.15 v5(163.93,39.87)
  BOTTOM w0.095: JSPI1.13 164.19,33.28 164.57,33.66 164.57,39.4 164.1,39.87 v5(163.93,39.87)
PCH_SPI_SI: length 53.3
  IN1 w0.076: v8(139.26,45.54) 139.31,45.49 139.31,43.71 140.1,42.92 140.1,40.81 142.23,38.68 147.46,38.68 150.26,41.49 152.61,41.49 158.22,35.88 159.2,35.88 159.77,35.32 159.77,33.27 160.38,32.65 161.68,32.65 163.43,30.9 165.56,30.9 165.83,30.63 165.83,29.61 v8(165.39,29.16)
  BOTTOM w0.095: JSPI1.4 164.33,28.78 164.33,28.79 164.8,28.79 165.18,29.16 v8(165.39,29.16) 165.79,29.16 166.72,28.24 166.72,25.64 RC30.1 ; UCPU1.AV3 136.13,46.11 136.4,45.84 137.19,45.84 137.31,45.71 137.71,45.71 137.88,45.54 v8(139.26,45.54) 139.65,45.93 140.93,45.93 141.44,46.44 RC241.1
PCH_SPI_SI_R: length 35.7
  IN2 w0.064: v3(167.25,23.89) 166.95,24.19 166.95,30.63 167.38,31.06 167.38,34.23 166.41,35.2 166.41,38.93 167.76,40.28 167.76,40.9 167.45,41.21 164.8,41.21 164.72,41.29 164.72,41.55 164.83,41.67 166.92,41.67 v8(167.19,41.94)
  GND3 w0.095: v4(166.86,23.96) 167.18,23.96 v3(167.25,23.89)
  BOTTOM w0.095: v4(166.86,23.96) 166.56,24.26 RC30.2 165.79,23.79 v2(165.32,23.79) 165.1,24.01 165.1,27.75 164.56,28.28 JSPI1.3 ; RP1.5 167.83,41.2 167.19,41.84 v8(167.19,41.94) 167.19,42.01 167.88,42.7 RP1.8
PCH_SPI_SI_TPM: length 44.6
  IN2 w0.064: v3(169.3,40.85) 169.3,40.29 168.12,39.11 168.12,35.01 168.46,34.68 168.46,21.69 171.17,18.98 172.76,18.98 175.35,16.39 175.35,16.29 175.41,16.23 175.46,16.23 175.53,16.16 175.53,16.04 175.46,15.97 175.41,15.97 175.35,15.91 175.35,15.78 175.41,15.72 175.95,15.72 176.01,15.65 176.01,15.53 175.95,15.46 175.41,15.46 175.35,15.4 175.35,15.27 175.41,15.21 175.95,15.21 176.01,15.15 176.01,15.02 175.95,14.96 175.41,14.96 175.35,14.89 175.35,14.77 175.41,14.7 175.95,14.7 176.01,14.64 176.01,14.51 175.95,14.45 175.41,14.45 175.35,14.38 175.35,14.26 175.41,14.19 175.95,14.19 176.01,14.13 176.01,14 175.95,13.94 175.41,13.94 175.35,13.88 175.35,13.7 175.48,13.57 177.92,13.57 178,13.65 178,13.85 177.92,13.93 176.58,13.93 176.47,14.04 v3(176.47,14.45)
  GND3 w0.095: v3(176.47,14.45) 176.47,14.18 v4(176.14,13.85) ; v4(169.64,41.2) 169.64,41.2 v3(169.3,40.85)
  BOTTOM w0.095: v4(176.14,13.85) 175.33,13.85 175.11,13.64 U7.21
PCH_SPI_SO: length 52.9
  IN1 w0.076: v9(137.1,45.57) 137.1,44.38 138.44,43.03 138.62,43.03 139.89,41.76 139.89,40.72 142.14,38.48 147.54,38.48 150.34,41.28 152.52,41.28 158.13,35.67 159.12,35.67 159.56,35.23 159.56,32.59 160.27,31.88 160.65,31.88 160.86,32.09 160.86,32.38 160.93,32.45 161.11,32.45 161.2,32.36 161.2,31.88 161.33,31.75 161.44,31.75 161.79,32.1 161.9,32.1 162,32 162,31.89 161.64,31.52 161.64,31.41 161.75,31.31 161.85,31.31 162.22,31.67 162.33,31.67 162.44,31.57 162.44,31.46 162.07,31.09 162.07,30.98 162.18,30.87 162.28,30.87 162.65,31.24 162.76,31.24 162.87,31.13 162.87,31.03 162.5,30.66 162.5,30.55 162.92,30.13 v8(165.42,30.13)
  GND1 w0.095: v9(137.1,45.57) 136.75,45.57 v3(136.73,45.55)
  GND3 w0.095: v3(136.73,45.55) v4(136.29,45.55)
  BOTTOM w0.095: JSPI1.6 164.77,29.78 165.11,30.13 v8(165.42,30.13) 165.53,30.13 167.17,28.49 167.17,25.7 167.43,25.44 RC31.1
PCH_SPI_SO_R: length 43.6
  IN2 w0.064: v8(161.7,49.81) 161.7,49.23 162.2,48.72 164.05,48.72 170.22,42.56 170.22,39.96 169.01,38.75 169.01,35.38 169.36,35.03 169.36,24.43 v3(169.78,24.02)
  GND3 w0.095: v4(169.43,24.01) 169.77,24.01 v3(169.78,24.02)
  BOTTOM w0.095: RP2.8 161.95,49.64 161.78,49.81 v8(161.7,49.81) 161.65,49.81 161.45,49.61 RP2.7 ; v4(169.43,24.01) 167.68,24.01 RC31.2 167.34,24.26 166.94,24.66 166.94,28.38 165.75,29.57 165.06,29.57 164.77,29.28 JSPI1.5
PCH_SPI_SO_TPM: length 45
  IN2 w0.064: v3(175.06,13.25) 175.1,13.29 175.1,16.37 172.68,18.79 171.09,18.79 168.27,21.61 168.27,34.6 167.93,34.94 167.93,39.19 168.82,40.09 168.82,43.04 168.54,43.32 166.09,43.32 161.96,47.45 v3(161.96,47.68)
  GND3 w0.095: v3(161.96,47.68) 161.96,48.01 v4(161.95,48.02) ; v4(175.06,12.33) v3(175.06,13.25)
  BOTTOM w0.095: U7.24 174.87,12.14 v4(175.06,12.33)
PCH_TBT_FORCE_PWR: length 3.5
  TOP w0.095: v2(133.61,66.52) 133.17,66.08 133.17,65.06 133.7,64.53 v1(133.76,64.53)
  GND1 w0.095: v3(134.29,64.65) 134.16,64.53 v1(133.76,64.53)
  GND3 w0.095: v3(134.29,64.65) 134.29,64.52 v4(134.04,64.27)
PCH_TBT_PERST#: length 233.1
  TOP w0.095: RH90.1 v1(144.58,56.97) ; RT428.1 23.73,54.62 23.87,54.76 26.11,54.76 27,53.87 28.14,53.87 v2(28.54,53.47) 28.98,53.03 v1(28.98,52.17)
  GND1 w0.095: v3(29.43,52.34) 29.16,52.34 v1(28.98,52.17) ; v1(144.58,56.97) 143.74,56.97 v3(143.42,56.65)
  GND3 w0.095: v6(29.82,52.56) 29.61,52.34 v3(29.43,52.34) ; v4(143.69,57.12) 143.69,56.92 v3(143.42,56.65)
  IN4 w0.076: v4(143.69,57.12) 143.69,56.97 145.19,55.47 145.19,55.18 145.85,54.53 145.85,52.63 151.18,47.3 151.18,43.82 150.73,43.36 150.73,39.09 150.85,38.96 150.85,35.39 150.44,34.98 150.44,33.46 152.62,31.28 152.62,26.72 151.93,26.04 151.93,17.59 149.26,14.91 139.1,14.91 138.56,14.38 131.07,14.38 130.93,14.52 125.12,14.52 125,14.4 120.46,14.4 120.38,14.47 114.49,14.47 113.65,13.63 109.77,13.63 108.73,12.59 99.86,12.59 99.19,11.92 91.03,11.92 90.48,12.48 81.51,12.48 80.13,11.09 79.02,11.09 75.87,7.94 67.29,7.94 66.56,8.67 52.03,8.67 49.91,10.79 48.07,10.79 46.94,11.92 36.17,11.92 35.22,12.87 35.22,20.13 34.98,20.38 34.98,22.62 34.43,23.17 34.43,26.02 35.49,27.08 35.49,33.18 35.03,33.64 35.03,38.55 34.49,39.09 34.49,51.48 32.47,53.5 31.49,53.5 30.55,52.56 v6(29.82,52.56)
  BOTTOM w0.076: 142,57.79 141.71,57.79 141.66,57.84 139.68,57.84 138.92,57.08 135.94,57.08 135.62,57.41 UCPU1.U4 ; 142.69,57.45 143.02,57.12 v4(143.69,57.12)
  BOTTOM w0.095: 142,57.79 142.34,57.79 142.69,57.45
PCI_CLK_LPC0: length 7.6
  BOTTOM w0.076: UCPU1.AW9 132.39,45.27 132.39,44.08 132.54,43.92 133,43.92 133.19,43.74 133.19,43.34 133.59,42.93 134.13,42.93 134.91,42.15 135.51,42.15 135.8,41.86 135.8,40.9 RC19.1
PCI_CLK_LPC1: length 7.7
  BOTTOM w0.095: UCPU1.AY9 132.66,44.83 132.91,44.58 132.91,44.47 133.38,44 133.38,43.4 133.67,43.11 134.2,43.11 134.96,42.35 135.56,42.35 137.25,40.66 RC22.1
PCIE_PRX_CARDTX_N1: length 212.3
  IN3 w0.089: v3(130.68,61.55) 131.03,61.55 131.12,61.64 131.12,62.17 132.67,63.72 134.41,63.72 134.91,63.22 134.91,62 135.37,61.53 135.99,61.53 136.91,60.61 136.91,59.64 140.21,56.34 141.91,56.34 142.39,55.86 144.64,55.86 148.07,52.42 148.07,51.67 149.88,49.86 149.88,49.41 154.53,44.76 154.53,39.02 157.64,35.91 157.64,26.05 158.82,24.87 158.82,19.79 161.25,17.36 166.18,17.36 169.12,14.42 175.26,14.42 179.29,10.39 186.03,10.39 187.55,8.87 206.36,8.87 210.83,13.34 221.53,13.34 222.61,12.26 225.6,12.26 226.39,11.46 228.39,11.46 230.98,8.87 250.54,8.87 250.97,9.3 251.62,9.3 252.41,10.08 255.27,10.08 256.79,11.6 256.79,12.38 259.54,15.13 260.59,15.13 264.57,19.11 264.57,21.77 265.56,23.71 266.5,24.65 266.5,25.36 267.71,26.57 267.71,27.88 268.13,28.3 272.17,28.3 273.54,29.68 284.71,29.68 284.88,29.85 287.08,29.85 287.19,29.74 287.19,29.44 287.01,29.27 v8(286.9,29.27)
  GND3 w0.102: v4(130.33,61.55) v3(130.68,61.55)
  BOTTOM w0.102: CR11.1 287.14,29.64 287.14,29.5 v8(286.9,29.27)
